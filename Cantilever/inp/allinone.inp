*NODE, NSET=Nall
       1,-2.187501181250e+000,-9.350005049000e+001,4.675002524500e+001
       2,-2.187501181250e+000,-8.950004833000e+001,4.675002524500e+001
       3,-1.937501046250e+000,-9.350005049000e+001,4.675002524500e+001
       4,-1.937501046250e+000,-8.925004819500e+001,4.675002524500e+001
       5,-3.908502110590e+000,-8.925004819500e+001,4.675002524500e+001
       6,-3.908502110590e+000,-8.950004833000e+001,4.675002524500e+001
       7,-1.937501046250e+000,-9.175004954500e+001,9.750005265000e+000
       8,-1.937501046250e+000,-9.606347331502e+001,9.750005265000e+000
       9,-1.937501046250e+000,-9.680689464198e+001,1.059912851359e+001
      10,-1.937501046250e+000,-9.594022750731e+001,1.709913202359e+001
      11,-1.937501046250e+000,-9.519680618035e+001,1.775000958500e+001
      12,-1.937501046250e+000,-9.175004954500e+001,1.775000958500e+001
      13,-1.937501046250e+000,-9.100004914000e+001,1.700000918000e+001
      14,-1.937501046250e+000,-9.100004914000e+001,1.050000567000e+001
      15,-1.937501046250e+000,-9.547356058864e+001,2.059913391359e+001
      16,-1.937501046250e+000,-9.474022685931e+001,2.609913688359e+001
      17,-1.937501046250e+000,-9.399680553235e+001,2.675001444500e+001
      18,-1.937501046250e+000,-9.175004954500e+001,2.675001444500e+001
      19,-1.937501046250e+000,-9.100004914000e+001,2.600001404000e+001
      20,-1.937501046250e+000,-9.100004914000e+001,2.050001107000e+001
      21,-1.937501046250e+000,-9.175004954500e+001,1.975001066500e+001
      22,-1.937501046250e+000,-9.473013926168e+001,1.975001066500e+001
      23,-1.937501046250e+000,-9.427355994064e+001,2.959913877359e+001
      24,-1.937501046250e+000,-9.340689280598e+001,3.609914228359e+001
      25,-1.937501046250e+000,-9.266347147902e+001,3.675001984500e+001
      26,-1.937501046250e+000,-9.175004954500e+001,3.675001984500e+001
      27,-1.937501046250e+000,-9.100004914000e+001,3.600001944000e+001
      28,-1.937501046250e+000,-9.100004914000e+001,2.950001593000e+001
      29,-1.937501046250e+000,-9.175004954500e+001,2.875001552500e+001
      30,-1.937501046250e+000,-9.353013861368e+001,2.875001552500e+001
      31,-1.937501046250e+000,-9.985347584590e+001,1.936726473612e+000
      32,-1.937501046250e+000,-9.387176115348e+001,4.679958666680e+001
      33,-1.937501046250e+000,-8.925004819500e+001,1.936726473612e+000
      34,-2.187501181250e+000,-9.947515699285e+001,1.936726473612e+000
      35,-2.187501181250e+000,-8.950004833000e+001,1.936726473612e+000
      36,-2.187501181250e+000,-9.606347331502e+001,9.750005265000e+000
      37,-2.187501181250e+000,-9.680689464198e+001,1.059912851359e+001
      38,-2.187501181250e+000,-9.175004954500e+001,9.750005265000e+000
      39,-2.187501181250e+000,-9.100004914000e+001,1.050000567000e+001
      40,-2.187501181250e+000,-9.100004914000e+001,1.700000918000e+001
      41,-2.187501181250e+000,-9.175004954500e+001,1.775000958500e+001
      42,-2.187501181250e+000,-9.519680618035e+001,1.775000958500e+001
      43,-2.187501181250e+000,-9.594022750731e+001,1.709913202359e+001
      44,-2.187501181250e+000,-9.474022685931e+001,2.609913688359e+001
      45,-2.187501181250e+000,-9.399680553235e+001,2.675001444500e+001
      46,-2.187501181250e+000,-9.547356058864e+001,2.059913391359e+001
      47,-2.187501181250e+000,-9.473013926168e+001,1.975001066500e+001
      48,-2.187501181250e+000,-9.175004954500e+001,1.975001066500e+001
      49,-2.187501181250e+000,-9.100004914000e+001,2.050001107000e+001
      50,-2.187501181250e+000,-9.100004914000e+001,2.600001404000e+001
      51,-2.187501181250e+000,-9.175004954500e+001,2.675001444500e+001
      52,-2.187501181250e+000,-9.340689280598e+001,3.609914228359e+001
      53,-2.187501181250e+000,-9.266347147902e+001,3.675001984500e+001
      54,-2.187501181250e+000,-9.427355994064e+001,2.959913877359e+001
      55,-2.187501181250e+000,-9.353013861368e+001,2.875001552500e+001
      56,-2.187501181250e+000,-9.175004954500e+001,2.875001552500e+001
      57,-2.187501181250e+000,-9.100004914000e+001,2.950001593000e+001
      58,-2.187501181250e+000,-9.100004914000e+001,3.600001944000e+001
      59,-2.187501181250e+000,-9.175004954500e+001,3.675001984500e+001
      60,-3.908502110590e+000,-9.350005049000e+001,4.675002524500e+001
      61,-3.908502110590e+000,-9.387176115348e+001,4.679958666680e+001
      62,-3.908502110590e+000,-9.947515699285e+001,1.936726473612e+000
      63,-3.908502110590e+000,-9.985347584590e+001,1.936726473612e+000
      64,-3.908502110590e+000,-8.950004833000e+001,1.936726473612e+000
      65,-3.908502110590e+000,-8.925004819500e+001,1.936726473612e+000
      66,-2.187501181250e+000,-9.321205033448e+001,4.675002524500e+001
      67,-2.187501181250e+000,-9.286005014440e+001,4.675002524500e+001
      68,-2.187501181250e+000,-9.236004987440e+001,4.675002524500e+001
      69,-2.187501181250e+000,-9.178004956120e+001,4.675002524500e+001
      70,-2.187501181250e+000,-9.121604925664e+001,4.675002524500e+001
      71,-2.187501181250e+000,-9.064804894992e+001,4.675002524500e+001
      72,-2.187501181250e+000,-9.006404863456e+001,4.675002524500e+001
      73,-1.937501046250e+000,-9.324505035230e+001,4.675002524500e+001
      74,-1.937501046250e+000,-9.293480018476e+001,4.675002524500e+001
      75,-1.937501046250e+000,-9.253104996674e+001,4.675002524500e+001
      76,-1.937501046250e+000,-9.200829968446e+001,4.675002524500e+001
      77,-1.937501046250e+000,-9.146429939070e+001,4.675002524500e+001
      78,-1.937501046250e+000,-9.091179909235e+001,4.675002524500e+001
      79,-1.937501046250e+000,-9.035504879170e+001,4.675002524500e+001
      80,-1.937501046250e+000,-8.980254849335e+001,4.675002524500e+001
      81,-3.591170939231e+000,-8.925004819500e+001,4.675002524500e+001
      82,-3.149666700819e+000,-8.925004819500e+001,4.675002524500e+001
      83,-2.568221386839e+000,-8.925004819500e+001,4.675002524500e+001
      84,-3.457599867103e+000,-8.950004833000e+001,4.675002524500e+001
      85,-2.841481534399e+000,-8.950004833000e+001,4.675002524500e+001
      86,-1.937501046250e+000,-9.212100398922e+001,9.750005265000e+000
      87,-1.937501046250e+000,-9.268606250309e+001,9.750005265000e+000
      88,-1.937501046250e+000,-9.321661362681e+001,9.750005265000e+000
      89,-1.937501046250e+000,-9.379029898822e+001,9.750005265000e+000
      90,-1.937501046250e+000,-9.434673065455e+001,9.750005265000e+000
      91,-1.937501046250e+000,-9.492472943973e+001,9.750005265000e+000
      92,-1.937501046250e+000,-9.543371344460e+001,9.750005265000e+000
      93,-1.937501046250e+000,-9.578741419374e+001,9.750005265000e+000
      94,-1.937501046250e+000,-9.634511266334e+001,9.804894250890e+000
      95,-1.937501046250e+000,-9.662691936120e+001,1.000500146745e+001
      96,-1.937501046250e+000,-9.678874306143e+001,1.030899676330e+001
      97,-1.937501046250e+000,-9.676962795519e+001,1.087862866452e+001
      98,-1.937501046250e+000,-9.672369459705e+001,1.122312885055e+001
      99,-1.937501046250e+000,-9.665782789481e+001,1.171712911731e+001
     100,-1.937501046250e+000,-9.658329452123e+001,1.227612941917e+001
     101,-1.937501046250e+000,-9.650702781338e+001,1.284812972805e+001
     102,-1.937501046250e+000,-9.643249443980e+001,1.340713002991e+001
     103,-1.937501046250e+000,-9.635969440049e+001,1.395313032475e+001
     104,-1.937501046250e+000,-9.628256102550e+001,1.453163063714e+001
     105,-1.937501046250e+000,-9.620802765192e+001,1.509063093900e+001
     106,-1.937501046250e+000,-9.613609427974e+001,1.563013123033e+001
     107,-1.937501046250e+000,-9.605376090195e+001,1.624763156378e+001
     108,-1.937501046250e+000,-9.598616086545e+001,1.675463183756e+001
     109,-1.937501046250e+000,-9.583577586607e+001,1.739271562027e+001
     110,-1.937501046250e+000,-9.553475116337e+001,1.766955663609e+001
     111,-1.937501046250e+000,-9.493140591943e+001,1.775000958500e+001
     112,-1.937501046250e+000,-9.460396403907e+001,1.775000958500e+001
     113,-1.937501046250e+000,-9.416967270302e+001,1.775000958500e+001
     114,-1.937501046250e+000,-9.366644623426e+001,1.775000958500e+001
     115,-1.937501046250e+000,-9.310462490269e+001,1.775000958500e+001
     116,-1.937501046250e+000,-9.261863221711e+001,1.775000958500e+001
     117,-1.937501046250e+000,-9.208438493863e+001,1.775000958500e+001
     118,-1.937501046250e+000,-9.149821411696e+001,1.770646478702e+001
     119,-1.937501046250e+000,-9.123749836775e+001,1.754754173446e+001
     120,-1.937501046250e+000,-9.104640566309e+001,1.725959711299e+001
     121,-1.937501046250e+000,-9.100004914000e+001,1.670100901854e+001
     122,-1.937501046250e+000,-9.100004914000e+001,1.620050874827e+001
     123,-1.937501046250e+000,-9.100004914000e+001,1.567400846396e+001
     124,-1.937501046250e+000,-9.100004914000e+001,1.513450817263e+001
     125,-1.937501046250e+000,-9.100004914000e+001,1.460150788481e+001
     126,-1.937501046250e+000,-9.100004914000e+001,1.404900758646e+001
     127,-1.937501046250e+000,-9.100004914000e+001,1.352250730215e+001
     128,-1.937501046250e+000,-9.100004914000e+001,1.295700699678e+001
     129,-1.937501046250e+000,-9.100004914000e+001,1.242400670896e+001
     130,-1.937501046250e+000,-9.100004914000e+001,1.189100642114e+001
     131,-1.937501046250e+000,-9.100004914000e+001,1.133850612279e+001
     132,-1.937501046250e+000,-9.100004914000e+001,1.079900583146e+001
     133,-1.937501046250e+000,-9.104640566309e+001,1.024041773701e+001
     134,-1.937501046250e+000,-9.123578077566e+001,9.954086041862e+000
     135,-1.937501046250e+000,-9.150043475182e+001,9.792762386169e+000
     136,-1.937501046250e+000,-9.542809389743e+001,2.094013409773e+001
     137,-1.937501046250e+000,-9.535842719314e+001,2.146263437988e+001
     138,-1.937501046250e+000,-9.528289381902e+001,2.202913468579e+001
     139,-1.937501046250e+000,-9.520882711235e+001,2.258463498576e+001
     140,-1.937501046250e+000,-9.513036040332e+001,2.317313530355e+001
     141,-1.937501046250e+000,-9.505482702919e+001,2.373963560946e+001
     142,-1.937501046250e+000,-9.498149365626e+001,2.428963590646e+001
     143,-1.937501046250e+000,-9.490742694960e+001,2.484513620643e+001
     144,-1.937501046250e+000,-9.483042690802e+001,2.542263651828e+001
     145,-1.937501046250e+000,-9.477762687951e+001,2.581863673212e+001
     146,-1.937501046250e+000,-9.461824154476e+001,2.641991627860e+001
     147,-1.937501046250e+000,-9.430948279513e+001,2.668172771658e+001
     148,-1.937501046250e+000,-9.369124671807e+001,2.675001444500e+001
     149,-1.937501046250e+000,-9.328233712837e+001,2.675001444500e+001
     150,-1.937501046250e+000,-9.273188191147e+001,2.675001444500e+001
     151,-1.937501046250e+000,-9.213649157482e+001,2.675001444500e+001
     152,-1.937501046250e+000,-9.149488783187e+001,2.670527506094e+001
     153,-1.937501046250e+000,-9.123150903827e+001,2.654187781475e+001
     154,-1.937501046250e+000,-9.104241503986e+001,2.624851759054e+001
     155,-1.937501046250e+000,-9.100004914000e+001,2.570851388259e+001
     156,-1.937501046250e+000,-9.100004914000e+001,2.532351367469e+001
     157,-1.937501046250e+000,-9.100004914000e+001,2.482301340442e+001
     158,-1.937501046250e+000,-9.100004914000e+001,2.429501311930e+001
     159,-1.937501046250e+000,-9.100004914000e+001,2.375601282824e+001
     160,-1.937501046250e+000,-9.100004914000e+001,2.322251254015e+001
     161,-1.937501046250e+000,-9.100004914000e+001,2.269451225503e+001
     162,-1.937501046250e+000,-9.100004914000e+001,2.214451195803e+001
     163,-1.937501046250e+000,-9.100004914000e+001,2.162751167885e+001
     164,-1.937501046250e+000,-9.100004914000e+001,2.115451142343e+001
     165,-1.937501046250e+000,-9.100004914000e+001,2.078051122147e+001
     166,-1.937501046250e+000,-9.104280626117e+001,2.025039627682e+001
     167,-1.937501046250e+000,-9.123578077566e+001,1.995409144186e+001
     168,-1.937501046250e+000,-9.149821411696e+001,1.979355546298e+001
     169,-1.937501046250e+000,-9.213150102874e+001,1.975001066500e+001
     170,-1.937501046250e+000,-9.271559861321e+001,1.975001066500e+001
     171,-1.937501046250e+000,-9.327287539023e+001,1.975001066500e+001
     172,-1.937501046250e+000,-9.385399288498e+001,1.975001066500e+001
     173,-1.937501046250e+000,-9.439338912370e+001,1.975001066500e+001
     174,-1.937501046250e+000,-9.500822289867e+001,1.980346954335e+001
     175,-1.937501046250e+000,-9.529610743341e+001,2.000789255166e+001
     176,-1.937501046250e+000,-9.545825186271e+001,2.032014265218e+001
     177,-1.937501046250e+000,-9.423629325385e+001,2.987863892452e+001
     178,-1.937501046250e+000,-9.418169322437e+001,3.028813914565e+001
     179,-1.937501046250e+000,-9.410195984798e+001,3.088613946857e+001
     180,-1.937501046250e+000,-9.402829314153e+001,3.143863976692e+001
     181,-1.937501046250e+000,-9.395375976795e+001,3.199764006878e+001
     182,-1.937501046250e+000,-9.387489305870e+001,3.258914038819e+001
     183,-1.937501046250e+000,-9.380209301938e+001,3.313514068303e+001
     184,-1.937501046250e+000,-9.372669297867e+001,3.370064098840e+001
     185,-1.937501046250e+000,-9.364869293655e+001,3.428564130430e+001
     186,-1.937501046250e+000,-9.357502623010e+001,3.483814160265e+001
     187,-1.937501046250e+000,-9.349875952225e+001,3.541014191153e+001
     188,-1.937501046250e+000,-9.344589282704e+001,3.580664212564e+001
     189,-1.937501046250e+000,-9.334007789879e+001,3.632359997129e+001
     190,-1.937501046250e+000,-9.314605365123e+001,3.657414055489e+001
     191,-1.937501046250e+000,-9.289479070827e+001,3.671345620782e+001
     192,-1.937501046250e+000,-9.220493366814e+001,3.675001984500e+001
     193,-1.937501046250e+000,-9.149932412507e+001,3.670686975747e+001
     194,-1.937501046250e+000,-9.123236083527e+001,3.654269706744e+001
     195,-1.937501046250e+000,-9.104519020106e+001,3.625628865930e+001
     196,-1.937501046250e+000,-9.100004914000e+001,3.568801927152e+001
     197,-1.937501046250e+000,-9.100004914000e+001,3.518101899774e+001
     198,-1.937501046250e+000,-9.100004914000e+001,3.462201869588e+001
     199,-1.937501046250e+000,-9.100004914000e+001,3.409551841157e+001
     200,-1.937501046250e+000,-9.100004914000e+001,3.355601812024e+001
     201,-1.937501046250e+000,-9.100004914000e+001,3.299701781838e+001
     202,-1.937501046250e+000,-9.100004914000e+001,3.247701753758e+001
     203,-1.937501046250e+000,-9.100004914000e+001,3.192451723923e+001
     204,-1.937501046250e+000,-9.100004914000e+001,3.139801695492e+001
     205,-1.937501046250e+000,-9.100004914000e+001,3.085851666359e+001
     206,-1.937501046250e+000,-9.100004914000e+001,3.031251636875e+001
     207,-1.937501046250e+000,-9.100004914000e+001,2.977951608093e+001
     208,-1.937501046250e+000,-9.104763675064e+001,2.923711504789e+001
     209,-1.937501046250e+000,-9.124008423558e+001,2.895007412336e+001
     210,-1.937501046250e+000,-9.149932412507e+001,2.879316561253e+001
     211,-1.937501046250e+000,-9.210606735874e+001,2.875001552500e+001
     212,-1.937501046250e+000,-9.262585336679e+001,2.875001552500e+001
     213,-1.937501046250e+000,-9.317768097808e+001,2.875001552500e+001
     214,-1.937501046250e+000,-9.379153442407e+001,2.879704165038e+001
     215,-1.937501046250e+000,-9.406038688427e+001,2.896960346876e+001
     216,-1.937501046250e+000,-9.424811342300e+001,2.928319162164e+001
     217,-1.937501046250e+000,-9.977571355490e+001,2.519943656123e+000
     218,-1.937501046250e+000,-9.966206097575e+001,3.372337999793e+000
     219,-1.937501046250e+000,-9.953046325251e+001,4.359320924044e+000
     220,-1.937501046250e+000,-9.940484724397e+001,5.301440988100e+000
     221,-1.937501046250e+000,-9.926128609135e+001,6.378149632737e+000
     222,-1.937501046250e+000,-9.914165179751e+001,7.275406836601e+000
     223,-1.937501046250e+000,-9.901005407427e+001,8.262389760851e+000
     224,-1.937501046250e+000,-9.886051120696e+001,9.383961265680e+000
     225,-1.937501046250e+000,-9.873489519842e+001,1.032608132974e+001
     226,-1.937501046250e+000,-9.862722433396e+001,1.113361281321e+001
     227,-1.937501046250e+000,-9.851357175480e+001,1.198600715689e+001
     228,-1.937501046250e+000,-9.837599231688e+001,1.301785294133e+001
     229,-1.937501046250e+000,-9.824439459364e+001,1.400483586558e+001
     230,-1.937501046250e+000,-9.812476029979e+001,1.490209306944e+001
     231,-1.937501046250e+000,-9.800512600595e+001,1.579935027331e+001
     232,-1.937501046250e+000,-9.786156485333e+001,1.687605891794e+001
     233,-1.937501046250e+000,-9.773594884479e+001,1.781817898200e+001
     234,-1.937501046250e+000,-9.760435112155e+001,1.880516190625e+001
     235,-1.937501046250e+000,-9.746677168363e+001,1.983700769069e+001
     236,-1.937501046250e+000,-9.734713738978e+001,2.073426489456e+001
     237,-1.937501046250e+000,-9.720955795185e+001,2.176611067900e+001
     238,-1.937501046250e+000,-9.708394194331e+001,2.270823074306e+001
     239,-1.937501046250e+000,-9.694636250539e+001,2.374007652750e+001
     240,-1.937501046250e+000,-9.682672821154e+001,2.463733373136e+001
     241,-1.937501046250e+000,-9.668914877361e+001,2.566917951581e+001
     242,-1.937501046250e+000,-9.655755105038e+001,2.665616244006e+001
     243,-1.937501046250e+000,-9.643193504184e+001,2.759828250411e+001
     244,-1.937501046250e+000,-9.629435560391e+001,2.863012828856e+001
     245,-1.937501046250e+000,-9.617472131006e+001,2.952738549242e+001
     246,-1.937501046250e+000,-9.603714187214e+001,3.055923127686e+001
     247,-1.937501046250e+000,-9.590554414890e+001,3.154621420111e+001
     248,-1.937501046250e+000,-9.577394642567e+001,3.253319712536e+001
     249,-1.937501046250e+000,-9.563636698775e+001,3.356504290981e+001
     250,-1.937501046250e+000,-9.551075097920e+001,3.450716297386e+001
     251,-1.937501046250e+000,-9.537317154128e+001,3.553900875831e+001
     252,-1.937501046250e+000,-9.526550067681e+001,3.634654024179e+001
     253,-1.937501046250e+000,-9.512792123889e+001,3.737838602623e+001
     254,-1.937501046250e+000,-9.500828694504e+001,3.827564323009e+001
     255,-1.937501046250e+000,-9.487668922181e+001,3.926262615434e+001
     256,-1.937501046250e+000,-9.474509149857e+001,4.024960907859e+001
     257,-1.937501046250e+000,-9.460751206065e+001,4.128145486304e+001
     258,-1.937501046250e+000,-9.448189605211e+001,4.222357492709e+001
     259,-1.937501046250e+000,-9.435029832887e+001,4.321055785134e+001
     260,-1.937501046250e+000,-9.420075546156e+001,4.433212935617e+001
     261,-1.937501046250e+000,-9.408710288241e+001,4.518452369984e+001
     262,-1.937501046250e+000,-9.399737716202e+001,4.585746660274e+001
     263,-1.937501046250e+000,-9.391961487102e+001,4.644068378525e+001
     264,-1.937501046250e+000,-8.980142643285e+001,1.936726473612e+000
     265,-1.937501046250e+000,-9.037401152600e+001,1.936726473612e+000
     266,-1.937501046250e+000,-9.092538976384e+001,1.936726473612e+000
     267,-1.937501046250e+000,-9.148737142934e+001,1.936726473612e+000
     268,-1.937501046250e+000,-9.203874966719e+001,1.936726473612e+000
     269,-1.937501046250e+000,-9.260073133269e+001,1.936726473612e+000
     270,-1.937501046250e+000,-9.315210957053e+001,1.936726473612e+000
     271,-1.937501046250e+000,-9.372469466368e+001,1.936726473612e+000
     272,-1.937501046250e+000,-9.427607290153e+001,1.936726473612e+000
     273,-1.937501046250e+000,-9.483805456703e+001,1.936726473612e+000
     274,-1.937501046250e+000,-9.537882937722e+001,1.936726473612e+000
     275,-1.937501046250e+000,-9.597262132567e+001,1.936726473612e+000
     276,-1.937501046250e+000,-9.652399956352e+001,1.936726473612e+000
     277,-1.937501046250e+000,-9.706477437372e+001,1.936726473612e+000
     278,-1.937501046250e+000,-9.761615261156e+001,1.936726473612e+000
     279,-1.937501046250e+000,-9.819934113236e+001,1.936726473612e+000
     280,-1.937501046250e+000,-9.875071937021e+001,1.936726473612e+000
     281,-1.937501046250e+000,-9.929149418041e+001,1.936726473612e+000
     282,-1.937501046250e+000,-8.925004819500e+001,4.603301246466e+001
     283,-1.937501046250e+000,-8.925004819500e+001,4.531599968432e+001
     284,-1.937501046250e+000,-8.925004819500e+001,4.450936030643e+001
     285,-1.937501046250e+000,-8.925004819500e+001,4.379234752609e+001
     286,-1.937501046250e+000,-8.925004819500e+001,4.312014804452e+001
     287,-1.937501046250e+000,-8.925004819500e+001,4.240313526418e+001
     288,-1.937501046250e+000,-8.925004819500e+001,4.164130918506e+001
     289,-1.937501046250e+000,-8.925004819500e+001,4.078985650841e+001
     290,-1.937501046250e+000,-8.925004819500e+001,4.011765702683e+001
     291,-1.937501046250e+000,-8.925004819500e+001,3.940064424649e+001
     292,-1.937501046250e+000,-8.925004819500e+001,3.868363146615e+001
     293,-1.937501046250e+000,-8.925004819500e+001,3.778736549072e+001
     294,-1.937501046250e+000,-8.925004819500e+001,3.707035271038e+001
     295,-1.937501046250e+000,-8.925004819500e+001,3.635333993004e+001
     296,-1.937501046250e+000,-8.925004819500e+001,3.554670055215e+001
     297,-1.937501046250e+000,-8.925004819500e+001,3.478487447304e+001
     298,-1.937501046250e+000,-8.925004819500e+001,3.397823509515e+001
     299,-1.937501046250e+000,-8.925004819500e+001,3.326122231481e+001
     300,-1.937501046250e+000,-8.925004819500e+001,3.258902283324e+001
     301,-1.937501046250e+000,-8.925004819500e+001,3.187201005290e+001
     302,-1.937501046250e+000,-8.925004819500e+001,3.115499727256e+001
     303,-1.937501046250e+000,-8.925004819500e+001,3.030354459590e+001
     304,-1.937501046250e+000,-8.925004819500e+001,2.958653181556e+001
     305,-1.937501046250e+000,-8.925004819500e+001,2.882470573644e+001
     306,-1.937501046250e+000,-8.925004819500e+001,2.815250625487e+001
     307,-1.937501046250e+000,-8.925004819500e+001,2.743549347453e+001
     308,-1.937501046250e+000,-8.925004819500e+001,2.662885409665e+001
     309,-1.937501046250e+000,-8.925004819500e+001,2.586702801753e+001
     310,-1.937501046250e+000,-8.925004819500e+001,2.515001523719e+001
     311,-1.937501046250e+000,-8.925004819500e+001,2.443300245685e+001
     312,-1.937501046250e+000,-8.925004819500e+001,2.367117637773e+001
     313,-1.937501046250e+000,-8.925004819500e+001,2.290935029862e+001
     314,-1.937501046250e+000,-8.925004819500e+001,2.219233751828e+001
     315,-1.937501046250e+000,-8.925004819500e+001,2.147532473794e+001
     316,-1.937501046250e+000,-8.925004819500e+001,2.075831195759e+001
     317,-1.937501046250e+000,-8.925004819500e+001,1.995167257971e+001
     318,-1.937501046250e+000,-8.925004819500e+001,1.923465979937e+001
     319,-1.937501046250e+000,-8.925004819500e+001,1.851764701903e+001
     320,-1.937501046250e+000,-8.925004819500e+001,1.784544753745e+001
     321,-1.937501046250e+000,-8.925004819500e+001,1.703880815957e+001
     322,-1.937501046250e+000,-8.925004819500e+001,1.627698208046e+001
     323,-1.937501046250e+000,-8.925004819500e+001,1.555996930011e+001
     324,-1.937501046250e+000,-8.925004819500e+001,1.484295651977e+001
     325,-1.937501046250e+000,-8.925004819500e+001,1.417075703820e+001
     326,-1.937501046250e+000,-8.925004819500e+001,1.340893095909e+001
     327,-1.937501046250e+000,-8.925004819500e+001,1.264710487997e+001
     328,-1.937501046250e+000,-8.925004819500e+001,1.193009209963e+001
     329,-1.937501046250e+000,-8.925004819500e+001,1.121307931929e+001
     330,-1.937501046250e+000,-8.925004819500e+001,1.049606653895e+001
     331,-1.937501046250e+000,-8.925004819500e+001,9.644613862290e+000
     332,-1.937501046250e+000,-8.925004819500e+001,8.927601081948e+000
     333,-1.937501046250e+000,-8.925004819500e+001,8.210588301606e+000
     334,-1.937501046250e+000,-8.925004819500e+001,7.493575521264e+000
     335,-1.937501046250e+000,-8.925004819500e+001,6.821376039693e+000
     336,-1.937501046250e+000,-8.925004819500e+001,6.014736661808e+000
     337,-1.937501046250e+000,-8.925004819500e+001,5.297723881466e+000
     338,-1.937501046250e+000,-8.925004819500e+001,4.580711101123e+000
     339,-1.937501046250e+000,-8.925004819500e+001,3.863698320781e+000
     340,-1.937501046250e+000,-8.925004819500e+001,3.191498839210e+000
     341,-1.937501046250e+000,-8.925004819500e+001,2.474486058868e+000
     342,-2.187501181250e+000,-9.888662558174e+001,1.936726473612e+000
     343,-2.187501181250e+000,-9.829809417064e+001,1.936726473612e+000
     344,-2.187501181250e+000,-9.770956275953e+001,1.936726473612e+000
     345,-2.187501181250e+000,-9.712103134842e+001,1.936726473612e+000
     346,-2.187501181250e+000,-9.653249993731e+001,1.936726473612e+000
     347,-2.187501181250e+000,-9.594396852620e+001,1.936726473612e+000
     348,-2.187501181250e+000,-9.536541222376e+001,1.936726473612e+000
     349,-2.187501181250e+000,-9.477688081265e+001,1.936726473612e+000
     350,-2.187501181250e+000,-9.418834940154e+001,1.936726473612e+000
     351,-2.187501181250e+000,-9.359981799043e+001,1.936726473612e+000
     352,-2.187501181250e+000,-9.301128657932e+001,1.936726473612e+000
     353,-2.187501181250e+000,-9.242275516822e+001,1.936726473612e+000
     354,-2.187501181250e+000,-9.184419886577e+001,1.936726473612e+000
     355,-2.187501181250e+000,-9.125566745466e+001,1.936726473612e+000
     356,-2.187501181250e+000,-9.066713604355e+001,1.936726473612e+000
     357,-2.187501181250e+000,-9.007860463245e+001,1.936726473612e+000
     358,-2.187501181250e+000,-9.939748060831e+001,2.519299357640e+000
     359,-2.187501181250e+000,-9.929590379777e+001,3.281125436753e+000
     360,-2.187501181250e+000,-9.915847634820e+001,4.311831308495e+000
     361,-2.187501181250e+000,-9.903897421814e+001,5.208097283923e+000
     362,-2.187501181250e+000,-9.889557166208e+001,6.283616454436e+000
     363,-2.187501181250e+000,-9.878204463852e+001,7.135069131093e+000
     364,-2.187501181250e+000,-9.863864208245e+001,8.210588301606e+000
     365,-2.187501181250e+000,-9.851913995240e+001,9.106854277034e+000
     366,-2.187501181250e+000,-9.838768760933e+001,1.009274685000e+001
     367,-2.187501181250e+000,-9.828013569228e+001,1.089938622789e+001
     368,-2.187501181250e+000,-9.817855888173e+001,1.166121230700e+001
     369,-2.187501181250e+000,-9.805905675168e+001,1.255747828243e+001
     370,-2.187501181250e+000,-9.793955462162e+001,1.345374425786e+001
     371,-2.187501181250e+000,-9.781407738506e+001,1.439482353206e+001
     372,-2.187501181250e+000,-9.769457525500e+001,1.529108950749e+001
     373,-2.187501181250e+000,-9.756312291194e+001,1.627698208046e+001
     374,-2.187501181250e+000,-9.744959588838e+001,1.712843475711e+001
     375,-2.187501181250e+000,-9.733009375833e+001,1.802470073254e+001
     376,-2.187501181250e+000,-9.720461652177e+001,1.896578000674e+001
     377,-2.187501181250e+000,-9.706718907220e+001,1.999648587848e+001
     378,-2.187501181250e+000,-9.695963715515e+001,2.080312525637e+001
     379,-2.187501181250e+000,-9.683415991859e+001,2.174420453057e+001
     380,-2.187501181250e+000,-9.671465778853e+001,2.264047050599e+001
     381,-2.187501181250e+000,-9.658320544547e+001,2.362636307896e+001
     382,-2.187501181250e+000,-9.646370331541e+001,2.452262905439e+001
     383,-2.187501181250e+000,-9.632627586585e+001,2.555333492613e+001
     384,-2.187501181250e+000,-9.621872394880e+001,2.635997430402e+001
     385,-2.187501181250e+000,-9.610519692524e+001,2.721142698067e+001
     386,-2.187501181250e+000,-9.598569479519e+001,2.810769295610e+001
     387,-2.187501181250e+000,-9.585424245212e+001,2.909358552907e+001
     388,-2.187501181250e+000,-9.574669053507e+001,2.990022490696e+001
     389,-2.187501181250e+000,-9.563316351152e+001,3.075167758361e+001
     390,-2.187501181250e+000,-9.550768627496e+001,3.169275685781e+001
     391,-2.187501181250e+000,-9.538220903840e+001,3.263383613201e+001
     392,-2.187501181250e+000,-9.526270690834e+001,3.353010210744e+001
     393,-2.187501181250e+000,-9.513722967178e+001,3.447118138164e+001
     394,-2.187501181250e+000,-9.499980222222e+001,3.550188725338e+001
     395,-2.187501181250e+000,-9.489225030516e+001,3.630852663127e+001
     396,-2.187501181250e+000,-9.477274817511e+001,3.720479260669e+001
     397,-2.187501181250e+000,-9.465922115155e+001,3.805624528335e+001
     398,-2.187501181250e+000,-9.451581859548e+001,3.913176445386e+001
     399,-2.187501181250e+000,-9.439631646543e+001,4.002803042929e+001
     400,-2.187501181250e+000,-9.425888901586e+001,4.105873630103e+001
     401,-2.187501181250e+000,-9.413341177930e+001,4.199981557523e+001
     402,-2.187501181250e+000,-9.400195943624e+001,4.298570814820e+001
     403,-2.187501181250e+000,-9.386453198667e+001,4.401641401995e+001
     404,-2.187501181250e+000,-9.374502985662e+001,4.491267999537e+001
     405,-2.187501181250e+000,-9.364942815257e+001,4.562969277572e+001
     406,-2.187501181250e+000,-9.358370198104e+001,4.612263906220e+001
     407,-2.187501181250e+000,-9.353590112902e+001,4.648114545237e+001
     408,-2.187501181250e+000,-8.950004833000e+001,4.603301246466e+001
     409,-2.187501181250e+000,-8.950004833000e+001,4.531599968432e+001
     410,-2.187501181250e+000,-8.950004833000e+001,4.450936030643e+001
     411,-2.187501181250e+000,-8.950004833000e+001,4.379234752609e+001
     412,-2.187501181250e+000,-8.950004833000e+001,4.312014804452e+001
     413,-2.187501181250e+000,-8.950004833000e+001,4.240313526418e+001
     414,-2.187501181250e+000,-8.950004833000e+001,4.164130918506e+001
     415,-2.187501181250e+000,-8.950004833000e+001,4.078985650841e+001
     416,-2.187501181250e+000,-8.950004833000e+001,4.011765702683e+001
     417,-2.187501181250e+000,-8.950004833000e+001,3.940064424649e+001
     418,-2.187501181250e+000,-8.950004833000e+001,3.868363146615e+001
     419,-2.187501181250e+000,-8.950004833000e+001,3.778736549072e+001
     420,-2.187501181250e+000,-8.950004833000e+001,3.711516600915e+001
     421,-2.187501181250e+000,-8.950004833000e+001,3.635333993004e+001
     422,-2.187501181250e+000,-8.950004833000e+001,3.554670055215e+001
     423,-2.187501181250e+000,-8.950004833000e+001,3.478487447304e+001
     424,-2.187501181250e+000,-8.950004833000e+001,3.397823509515e+001
     425,-2.187501181250e+000,-8.950004833000e+001,3.330603561358e+001
     426,-2.187501181250e+000,-8.950004833000e+001,3.258902283324e+001
     427,-2.187501181250e+000,-8.950004833000e+001,3.187201005290e+001
     428,-2.187501181250e+000,-8.950004833000e+001,3.115499727256e+001
     429,-2.187501181250e+000,-8.950004833000e+001,3.034835789467e+001
     430,-2.187501181250e+000,-8.950004833000e+001,2.963134511433e+001
     431,-2.187501181250e+000,-8.950004833000e+001,2.886951903522e+001
     432,-2.187501181250e+000,-8.950004833000e+001,2.815250625487e+001
     433,-2.187501181250e+000,-8.950004833000e+001,2.743549347453e+001
     434,-2.187501181250e+000,-8.950004833000e+001,2.662885409665e+001
     435,-2.187501181250e+000,-8.950004833000e+001,2.586702801753e+001
     436,-2.187501181250e+000,-8.950004833000e+001,2.515001523719e+001
     437,-2.187501181250e+000,-8.950004833000e+001,2.443300245685e+001
     438,-2.187501181250e+000,-8.950004833000e+001,2.367117637773e+001
     439,-2.187501181250e+000,-8.950004833000e+001,2.290935029862e+001
     440,-2.187501181250e+000,-8.950004833000e+001,2.223715081705e+001
     441,-2.187501181250e+000,-8.950004833000e+001,2.152013803671e+001
     442,-2.187501181250e+000,-8.950004833000e+001,2.075831195759e+001
     443,-2.187501181250e+000,-8.950004833000e+001,1.995167257971e+001
     444,-2.187501181250e+000,-8.950004833000e+001,1.923465979937e+001
     445,-2.187501181250e+000,-8.950004833000e+001,1.856246031780e+001
     446,-2.187501181250e+000,-8.950004833000e+001,1.784544753745e+001
     447,-2.187501181250e+000,-8.950004833000e+001,1.708362145834e+001
     448,-2.187501181250e+000,-8.950004833000e+001,1.627698208046e+001
     449,-2.187501181250e+000,-8.950004833000e+001,1.560478259888e+001
     450,-2.187501181250e+000,-8.950004833000e+001,1.488776981854e+001
     451,-2.187501181250e+000,-8.950004833000e+001,1.417075703820e+001
     452,-2.187501181250e+000,-8.950004833000e+001,1.345374425786e+001
     453,-2.187501181250e+000,-8.950004833000e+001,1.264710487997e+001
     454,-2.187501181250e+000,-8.950004833000e+001,1.193009209963e+001
     455,-2.187501181250e+000,-8.950004833000e+001,1.125789261806e+001
     456,-2.187501181250e+000,-8.950004833000e+001,1.049606653895e+001
     457,-2.187501181250e+000,-8.950004833000e+001,9.689427161062e+000
     458,-2.187501181250e+000,-8.950004833000e+001,8.927601081948e+000
     459,-2.187501181250e+000,-8.950004833000e+001,8.255401600377e+000
     460,-2.187501181250e+000,-8.950004833000e+001,7.538388820035e+000
     461,-2.187501181250e+000,-8.950004833000e+001,6.821376039693e+000
     462,-2.187501181250e+000,-8.950004833000e+001,6.014736661808e+000
     463,-2.187501181250e+000,-8.950004833000e+001,5.342537180237e+000
     464,-2.187501181250e+000,-8.950004833000e+001,4.625524399895e+000
     465,-2.187501181250e+000,-8.950004833000e+001,3.908511619553e+000
     466,-2.187501181250e+000,-8.950004833000e+001,3.191498839210e+000
     467,-2.187501181250e+000,-8.950004833000e+001,2.474486058868e+000
     468,-2.187501181250e+000,-9.634629627074e+001,9.805374988835e+000
     469,-2.187501181250e+000,-9.662691936120e+001,1.000500146745e+001
     470,-2.187501181250e+000,-9.678841665483e+001,1.030776165433e+001
     471,-2.187501181250e+000,-9.209081002283e+001,9.750005265000e+000
     472,-2.187501181250e+000,-9.255234636622e+001,9.750005265000e+000
     473,-2.187501181250e+000,-9.306995721863e+001,9.750005265000e+000
     474,-2.187501181250e+000,-9.367383654643e+001,9.750005265000e+000
     475,-2.187501181250e+000,-9.428202929800e+001,9.750005265000e+000
     476,-2.187501181250e+000,-9.489884889711e+001,9.750005265000e+000
     477,-2.187501181250e+000,-9.542077317328e+001,9.750005265000e+000
     478,-2.187501181250e+000,-9.578310076997e+001,9.750005265000e+000
     479,-2.187501181250e+000,-9.104640566309e+001,1.024041773701e+001
     480,-2.187501181250e+000,-9.123578077566e+001,9.954086041862e+000
     481,-2.187501181250e+000,-9.150043475182e+001,9.792762386169e+000
     482,-2.187501181250e+000,-9.100004914000e+001,1.670750902205e+001
     483,-2.187501181250e+000,-9.100004914000e+001,1.629800880092e+001
     484,-2.187501181250e+000,-9.100004914000e+001,1.579100852714e+001
     485,-2.187501181250e+000,-9.100004914000e+001,1.521250821475e+001
     486,-2.187501181250e+000,-9.100004914000e+001,1.463400790236e+001
     487,-2.187501181250e+000,-9.100004914000e+001,1.404900758646e+001
     488,-2.187501181250e+000,-9.100004914000e+001,1.347050727407e+001
     489,-2.187501181250e+000,-9.100004914000e+001,1.289200696168e+001
     490,-2.187501181250e+000,-9.100004914000e+001,1.231350664929e+001
     491,-2.187501181250e+000,-9.100004914000e+001,1.171550632637e+001
     492,-2.187501181250e+000,-9.100004914000e+001,1.120200604908e+001
     493,-2.187501181250e+000,-9.100004914000e+001,1.079250582795e+001
     494,-2.187501181250e+000,-9.149821411696e+001,1.770646478702e+001
     495,-2.187501181250e+000,-9.123749836775e+001,1.754754173446e+001
     496,-2.187501181250e+000,-9.104640566309e+001,1.725959711299e+001
     497,-2.187501181250e+000,-9.492451240616e+001,1.775000958500e+001
     498,-2.187501181250e+000,-9.458328349926e+001,1.775000958500e+001
     499,-2.187501181250e+000,-9.410418432694e+001,1.775000958500e+001
     500,-2.187501181250e+000,-9.355959677856e+001,1.775000958500e+001
     501,-2.187501181250e+000,-9.299432869036e+001,1.775000958500e+001
     502,-2.187501181250e+000,-9.249799573487e+001,1.775000958500e+001
     503,-2.187501181250e+000,-9.206715115545e+001,1.775000958500e+001
     504,-2.187501181250e+000,-9.583577586607e+001,1.739271562027e+001
     505,-2.187501181250e+000,-9.553571378665e+001,1.766906989615e+001
     506,-2.187501181250e+000,-9.677049462232e+001,1.087212866101e+001
     507,-2.187501181250e+000,-9.672629459845e+001,1.120362884002e+001
     508,-2.187501181250e+000,-9.666476123189e+001,1.166512908923e+001
     509,-2.187501181250e+000,-9.658589452264e+001,1.225662940864e+001
     510,-2.187501181250e+000,-9.650876114765e+001,1.283512972103e+001
     511,-2.187501181250e+000,-9.643249443980e+001,1.340713002991e+001
     512,-2.187501181250e+000,-9.635536106482e+001,1.398563034230e+001
     513,-2.187501181250e+000,-9.627822768983e+001,1.456413065469e+001
     514,-2.187501181250e+000,-9.620109431485e+001,1.514263096708e+001
     515,-2.187501181250e+000,-9.612482760699e+001,1.571463127596e+001
     516,-2.187501181250e+000,-9.604682756487e+001,1.629963159186e+001
     517,-2.187501181250e+000,-9.598442753118e+001,1.676763184458e+001
     518,-2.187501181250e+000,-9.461763698002e+001,2.642080962111e+001
     519,-2.187501181250e+000,-9.430948279513e+001,2.668172771658e+001
     520,-2.187501181250e+000,-9.543102723234e+001,2.091813408585e+001
     521,-2.187501181250e+000,-9.537309386772e+001,2.135263432048e+001
     522,-2.187501181250e+000,-9.530049382852e+001,2.189713461451e+001
     523,-2.187501181250e+000,-9.522056045202e+001,2.249663493824e+001
     524,-2.187501181250e+000,-9.513989374180e+001,2.310163526494e+001
     525,-2.187501181250e+000,-9.505996036530e+001,2.370113558867e+001
     526,-2.187501181250e+000,-9.498002698880e+001,2.430063591240e+001
     527,-2.187501181250e+000,-9.490596028214e+001,2.485613621237e+001
     528,-2.187501181250e+000,-9.483042690802e+001,2.542263651828e+001
     529,-2.187501181250e+000,-9.477762687951e+001,2.581863673212e+001
     530,-2.187501181250e+000,-9.500822289867e+001,1.980346954335e+001
     531,-2.187501181250e+000,-9.529610743341e+001,2.000789255166e+001
     532,-2.187501181250e+000,-9.545825186271e+001,2.032014265218e+001
     533,-2.187501181250e+000,-9.206891914469e+001,1.975001066500e+001
     534,-2.187501181250e+000,-9.249209188445e+001,1.975001066500e+001
     535,-2.187501181250e+000,-9.298082659799e+001,1.975001066500e+001
     536,-2.187501181250e+000,-9.353810337501e+001,1.975001066500e+001
     537,-2.187501181250e+000,-9.403577835770e+001,1.975001066500e+001
     538,-2.187501181250e+000,-9.444107055917e+001,1.975001066500e+001
     539,-2.187501181250e+000,-9.104359393798e+001,2.024817564196e+001
     540,-2.187501181250e+000,-9.123578077566e+001,1.995409144186e+001
     541,-2.187501181250e+000,-9.149821411696e+001,1.979355546298e+001
     542,-2.187501181250e+000,-9.100004914000e+001,2.568651387071e+001
     543,-2.187501181250e+000,-9.100004914000e+001,2.526301364202e+001
     544,-2.187501181250e+000,-9.100004914000e+001,2.475701336878e+001
     545,-2.187501181250e+000,-9.100004914000e+001,2.417951305693e+001
     546,-2.187501181250e+000,-9.100004914000e+001,2.356901272726e+001
     547,-2.187501181250e+000,-9.100004914000e+001,2.295851239759e+001
     548,-2.187501181250e+000,-9.100004914000e+001,2.234801206792e+001
     549,-2.187501181250e+000,-9.100004914000e+001,2.173201173528e+001
     550,-2.187501181250e+000,-9.100004914000e+001,2.121501145610e+001
     551,-2.187501181250e+000,-9.100004914000e+001,2.079701123038e+001
     552,-2.187501181250e+000,-9.149599596763e+001,2.670567499777e+001
     553,-2.187501181250e+000,-9.123321390962e+001,2.654350418112e+001
     554,-2.187501181250e+000,-9.104319922753e+001,2.625073945993e+001
     555,-2.187501181250e+000,-9.372494805788e+001,2.675001444500e+001
     556,-2.187501181250e+000,-9.338793465978e+001,2.675001444500e+001
     557,-2.187501181250e+000,-9.293858346231e+001,2.675001444500e+001
     558,-2.187501181250e+000,-9.246451794898e+001,2.675001444500e+001
     559,-2.187501181250e+000,-9.205560835928e+001,2.675001444500e+001
     560,-2.187501181250e+000,-9.333961181114e+001,3.632457276194e+001
     561,-2.187501181250e+000,-9.314522742569e+001,3.657483403215e+001
     562,-2.187501181250e+000,-9.289479070827e+001,3.671345620782e+001
     563,-2.187501181250e+000,-9.423715992099e+001,2.987213892101e+001
     564,-2.187501181250e+000,-9.418515989291e+001,3.026213913161e+001
     565,-2.187501181250e+000,-9.411322652073e+001,3.080163942294e+001
     566,-2.187501181250e+000,-9.403522647861e+001,3.138663973884e+001
     567,-2.187501181250e+000,-9.395722643649e+001,3.197164005474e+001
     568,-2.187501181250e+000,-9.387922639437e+001,3.255664037064e+001
     569,-2.187501181250e+000,-9.380209301938e+001,3.313514068303e+001
     570,-2.187501181250e+000,-9.372409297726e+001,3.372014099893e+001
     571,-2.187501181250e+000,-9.364609293514e+001,3.430514131483e+001
     572,-2.187501181250e+000,-9.356895956016e+001,3.488364162722e+001
     573,-2.187501181250e+000,-9.349529285371e+001,3.543614192557e+001
     574,-2.187501181250e+000,-9.344502615990e+001,3.581314212915e+001
     575,-2.187501181250e+000,-9.379033663571e+001,2.879659742240e+001
     576,-2.187501181250e+000,-9.405857685699e+001,2.896780015560e+001
     577,-2.187501181250e+000,-9.424699607210e+001,2.927952558596e+001
     578,-2.187501181250e+000,-9.211318771501e+001,2.875001552500e+001
     579,-2.187501181250e+000,-9.264365425748e+001,2.875001552500e+001
     580,-2.187501181250e+000,-9.317056062181e+001,2.875001552500e+001
     581,-2.187501181250e+000,-9.104763675064e+001,2.923711504789e+001
     582,-2.187501181250e+000,-9.124008423558e+001,2.895007412336e+001
     583,-2.187501181250e+000,-9.149932412507e+001,2.879316561253e+001
     584,-2.187501181250e+000,-9.100004914000e+001,3.570101927854e+001
     585,-2.187501181250e+000,-9.100004914000e+001,3.528501905390e+001
     586,-2.187501181250e+000,-9.100004914000e+001,3.473251875555e+001
     587,-2.187501181250e+000,-9.100004914000e+001,3.416051844667e+001
     588,-2.187501181250e+000,-9.100004914000e+001,3.358851813779e+001
     589,-2.187501181250e+000,-9.100004914000e+001,3.301001782540e+001
     590,-2.187501181250e+000,-9.100004914000e+001,3.243151751301e+001
     591,-2.187501181250e+000,-9.100004914000e+001,3.185301720062e+001
     592,-2.187501181250e+000,-9.100004914000e+001,3.127451688823e+001
     593,-2.187501181250e+000,-9.100004914000e+001,3.068301656882e+001
     594,-2.187501181250e+000,-9.100004914000e+001,3.018251629855e+001
     595,-2.187501181250e+000,-9.100004914000e+001,2.977951608093e+001
     596,-2.187501181250e+000,-9.149932412507e+001,3.670686975747e+001
     597,-2.187501181250e+000,-9.123236083527e+001,3.654269706744e+001
     598,-2.187501181250e+000,-9.104519020106e+001,3.625628865930e+001
     599,-2.187501181250e+000,-9.237574356980e+001,3.675001984500e+001
     600,-2.187501181250e+000,-9.203503718841e+001,3.675001984500e+001
     601,-2.447372321580e+000,-9.350005049000e+001,4.675002524500e+001
     602,-2.824271525106e+000,-9.350005049000e+001,4.675002524500e+001
     603,-3.359502814131e+000,-9.350005049000e+001,4.675002524500e+001
     604,-2.321846253796e+000,-9.387176115348e+001,4.679958666680e+001
     605,-2.779118500723e+000,-9.387176115348e+001,4.679958666680e+001
     606,-3.413780843441e+000,-9.387176115348e+001,4.679958666680e+001
     607,-3.908502110590e+000,-9.357175176803e+001,4.621226565974e+001
     608,-3.908502110590e+000,-9.366735347208e+001,4.549525287940e+001
     609,-3.908502110590e+000,-9.378685560214e+001,4.459898690397e+001
     610,-3.908502110590e+000,-9.388245730618e+001,4.388197412363e+001
     611,-3.908502110590e+000,-9.398403411673e+001,4.312014804452e+001
     612,-3.908502110590e+000,-9.409756114029e+001,4.226869536786e+001
     613,-3.908502110590e+000,-9.419316284433e+001,4.155168258752e+001
     614,-3.908502110590e+000,-9.429473965488e+001,4.078985650841e+001
     615,-3.908502110590e+000,-9.439034135893e+001,4.007284372806e+001
     616,-3.908502110590e+000,-9.450386838248e+001,3.922139105141e+001
     617,-3.908502110590e+000,-9.460544519303e+001,3.845956497229e+001
     618,-3.908502110590e+000,-9.470104689707e+001,3.774255219195e+001
     619,-3.908502110590e+000,-9.480262370762e+001,3.698072611284e+001
     620,-3.908502110590e+000,-9.490420051817e+001,3.621890003372e+001
     621,-3.908502110590e+000,-9.499980222222e+001,3.550188725338e+001
     622,-3.908502110590e+000,-9.510137903276e+001,3.474006117427e+001
     623,-3.908502110590e+000,-9.520893094982e+001,3.393342179638e+001
     624,-3.908502110590e+000,-9.531050776036e+001,3.317159571727e+001
     625,-3.908502110590e+000,-9.541208457091e+001,3.240976963816e+001
     626,-3.908502110590e+000,-9.550768627496e+001,3.169275685781e+001
     627,-3.908502110590e+000,-9.563316351152e+001,3.075167758361e+001
     628,-3.908502110590e+000,-9.572876521556e+001,3.003466480327e+001
     629,-3.908502110590e+000,-9.582436691961e+001,2.931765202293e+001
     630,-3.908502110590e+000,-9.592594373016e+001,2.855582594382e+001
     631,-3.908502110590e+000,-9.604544586021e+001,2.765955996839e+001
     632,-3.908502110590e+000,-9.614104756426e+001,2.694254718805e+001
     633,-3.908502110590e+000,-9.623664926831e+001,2.622553440770e+001
     634,-3.908502110590e+000,-9.634420118536e+001,2.541889502982e+001
     635,-3.908502110590e+000,-9.645175310241e+001,2.461225565193e+001
     636,-3.908502110590e+000,-9.654735480645e+001,2.389524287159e+001
     637,-3.908502110590e+000,-9.664893161700e+001,2.313341679248e+001
     638,-3.908502110590e+000,-9.676245864056e+001,2.228196411582e+001
     639,-3.908502110590e+000,-9.685806034460e+001,2.156495133548e+001
     640,-3.908502110590e+000,-9.695963715515e+001,2.080312525637e+001
     641,-3.908502110590e+000,-9.705523885920e+001,2.008611247602e+001
     642,-3.908502110590e+000,-9.717474098925e+001,1.918984650060e+001
     643,-3.908502110590e+000,-9.727034269330e+001,1.847283372025e+001
     644,-3.908502110590e+000,-9.737191950385e+001,1.771100764114e+001
     645,-3.908502110590e+000,-9.747349631440e+001,1.694918156203e+001
     646,-3.908502110590e+000,-9.758104823145e+001,1.614254218414e+001
     647,-3.908502110590e+000,-9.768262504200e+001,1.538071610503e+001
     648,-3.908502110590e+000,-9.777822674604e+001,1.466370332469e+001
     649,-3.908502110590e+000,-9.789175376960e+001,1.381225064803e+001
     650,-3.908502110590e+000,-9.799930568665e+001,1.300561127014e+001
     651,-3.908502110590e+000,-9.810088249720e+001,1.224378519103e+001
     652,-3.908502110590e+000,-9.819648420124e+001,1.152677241069e+001
     653,-3.908502110590e+000,-9.831598633130e+001,1.063050643526e+001
     654,-3.908502110590e+000,-9.841158803534e+001,9.913493654919e+000
     655,-3.908502110590e+000,-9.850718973939e+001,9.196480874576e+000
     656,-3.908502110590e+000,-9.860876654994e+001,8.434654795463e+000
     657,-3.908502110590e+000,-9.872229357349e+001,7.583202118806e+000
     658,-3.908502110590e+000,-9.881789527754e+001,6.866189338464e+000
     659,-3.908502110590e+000,-9.891947208809e+001,6.104363259351e+000
     660,-3.908502110590e+000,-9.902104889864e+001,5.342537180237e+000
     661,-3.908502110590e+000,-9.912860081569e+001,4.535897802352e+000
     662,-3.908502110590e+000,-9.923017762623e+001,3.774071723238e+000
     663,-3.908502110590e+000,-9.933175443678e+001,3.012245644125e+000
     664,-3.908502110590e+000,-9.942138103433e+001,2.340046162554e+000
     665,-3.908502110590e+000,-9.393756001510e+001,4.630609520467e+001
     666,-3.908502110590e+000,-9.402728573548e+001,4.563315230177e+001
     667,-3.908502110590e+000,-9.414692002933e+001,4.473589509791e+001
     668,-3.908502110590e+000,-9.424860917910e+001,4.397322647463e+001
     669,-3.908502110590e+000,-9.434431661418e+001,4.325542071154e+001
     670,-3.908502110590e+000,-9.444600576395e+001,4.249275208825e+001
     671,-3.908502110590e+000,-9.455965834311e+001,4.164035774458e+001
     672,-3.908502110590e+000,-9.465536577819e+001,4.092255198149e+001
     673,-3.908502110590e+000,-9.475705492796e+001,4.015988335821e+001
     674,-3.908502110590e+000,-9.486472579242e+001,3.935235187473e+001
     675,-3.908502110590e+000,-9.497239665689e+001,3.854482039125e+001
     676,-3.908502110590e+000,-9.507408580666e+001,3.778215176797e+001
     677,-3.908502110590e+000,-9.516979324174e+001,3.706434600488e+001
     678,-3.908502110590e+000,-9.526550067681e+001,3.634654024179e+001
     679,-3.908502110590e+000,-9.536718982659e+001,3.558387161850e+001
     680,-3.908502110590e+000,-9.546289726166e+001,3.486606585541e+001
     681,-3.908502110590e+000,-9.556458641144e+001,3.410339723213e+001
     682,-3.908502110590e+000,-9.567225727590e+001,3.329586574865e+001
     683,-3.908502110590e+000,-9.577394642567e+001,3.253319712536e+001
     684,-3.908502110590e+000,-9.587563557544e+001,3.177052850208e+001
     685,-3.908502110590e+000,-9.599526986929e+001,3.087327129822e+001
     686,-3.908502110590e+000,-9.609695901906e+001,3.011060267493e+001
     687,-3.908502110590e+000,-9.619266645414e+001,2.939279691184e+001
     688,-3.908502110590e+000,-9.629435560391e+001,2.863012828856e+001
     689,-3.908502110590e+000,-9.640202646838e+001,2.782259680508e+001
     690,-3.908502110590e+000,-9.650371561815e+001,2.705992818180e+001
     691,-3.908502110590e+000,-9.659942305323e+001,2.634212241870e+001
     692,-3.908502110590e+000,-9.670709391769e+001,2.553459093523e+001
     693,-3.908502110590e+000,-9.682074649685e+001,2.468219659156e+001
     694,-3.908502110590e+000,-9.692243564662e+001,2.391952796827e+001
     695,-3.908502110590e+000,-9.701814308170e+001,2.320172220518e+001
     696,-3.908502110590e+000,-9.713179566085e+001,2.234932786151e+001
     697,-3.908502110590e+000,-9.723348481062e+001,2.158665923823e+001
     698,-3.908502110590e+000,-9.732919224570e+001,2.086885347514e+001
     699,-3.908502110590e+000,-9.743088139547e+001,2.010618485185e+001
     700,-3.908502110590e+000,-9.753855225994e+001,1.929865336837e+001
     701,-3.908502110590e+000,-9.764024140971e+001,1.853598474509e+001
     702,-3.908502110590e+000,-9.773594884479e+001,1.781817898200e+001
     703,-3.908502110590e+000,-9.783763799456e+001,1.705551035872e+001
     704,-3.908502110590e+000,-9.795727228841e+001,1.615825315485e+001
     705,-3.908502110590e+000,-9.805896143818e+001,1.539558453157e+001
     706,-3.908502110590e+000,-9.815466887326e+001,1.467777876848e+001
     707,-3.908502110590e+000,-9.826832145241e+001,1.382538442481e+001
     708,-3.908502110590e+000,-9.837001060218e+001,1.306271580152e+001
     709,-3.908502110590e+000,-9.847169975195e+001,1.230004717824e+001
     710,-3.908502110590e+000,-9.856740718703e+001,1.158224141515e+001
     711,-3.908502110590e+000,-9.868105976619e+001,1.072984707148e+001
     712,-3.908502110590e+000,-9.878274891596e+001,9.967178448192e+000
     713,-3.908502110590e+000,-9.887845635104e+001,9.249372685101e+000
     714,-3.908502110590e+000,-9.897416378612e+001,8.531566922010e+000
     715,-3.908502110590e+000,-9.909977979466e+001,7.589446857953e+000
     716,-3.908502110590e+000,-9.920146894443e+001,6.826778234669e+000
     717,-3.908502110590e+000,-9.929717637951e+001,6.108972471578e+000
     718,-3.908502110590e+000,-9.939886552928e+001,5.346303848294e+000
     719,-3.908502110590e+000,-9.950653639374e+001,4.538772364816e+000
     720,-3.908502110590e+000,-9.960822554351e+001,3.776103741532e+000
     721,-3.908502110590e+000,-9.970991469329e+001,3.013435118248e+000
     722,-3.908502110590e+000,-9.979964041367e+001,2.340492215350e+000
     723,-3.338882802996e+000,-9.985347584590e+001,1.936726473612e+000
     724,-2.585960396418e+000,-9.985347584590e+001,1.936726473612e+000
     725,-3.436947855951e+000,-9.947515699285e+001,1.936726473612e+000
     726,-2.841481534399e+000,-9.947515699285e+001,1.936726473612e+000
     727,-2.839760533470e+000,-8.950004833000e+001,1.936726473612e+000
     728,-3.457599867103e+000,-8.950004833000e+001,1.936726473612e+000
     729,-3.908502110590e+000,-8.950004833000e+001,2.295232863783e+000
     730,-3.908502110590e+000,-8.950004833000e+001,2.743365851496e+000
     731,-3.908502110590e+000,-8.950004833000e+001,3.325938735525e+000
     732,-3.908502110590e+000,-8.950004833000e+001,3.863698320781e+000
     733,-3.908502110590e+000,-8.950004833000e+001,4.401457906038e+000
     734,-3.908502110590e+000,-8.950004833000e+001,4.939217491295e+000
     735,-3.908502110590e+000,-8.950004833000e+001,5.476977076551e+000
     736,-3.908502110590e+000,-8.950004833000e+001,6.059549960579e+000
     737,-3.908502110590e+000,-8.950004833000e+001,6.597309545836e+000
     738,-3.908502110590e+000,-8.950004833000e+001,7.135069131093e+000
     739,-3.908502110590e+000,-8.950004833000e+001,7.672828716349e+000
     740,-3.908502110590e+000,-8.950004833000e+001,8.210588301606e+000
     741,-3.908502110590e+000,-8.950004833000e+001,8.793161185634e+000
     742,-3.908502110590e+000,-8.950004833000e+001,9.330920770891e+000
     743,-3.908502110590e+000,-8.950004833000e+001,9.868680356147e+000
     744,-3.908502110590e+000,-8.950004833000e+001,1.040643994140e+001
     745,-3.908502110590e+000,-8.950004833000e+001,1.094419952666e+001
     746,-3.908502110590e+000,-8.950004833000e+001,1.152677241069e+001
     747,-3.908502110590e+000,-8.950004833000e+001,1.206453199595e+001
     748,-3.908502110590e+000,-8.950004833000e+001,1.269191817874e+001
     749,-3.908502110590e+000,-8.950004833000e+001,1.322967776400e+001
     750,-3.908502110590e+000,-8.950004833000e+001,1.376743734926e+001
     751,-3.908502110590e+000,-8.950004833000e+001,1.430519693451e+001
     752,-3.908502110590e+000,-8.950004833000e+001,1.488776981854e+001
     753,-3.908502110590e+000,-8.950004833000e+001,1.542552940380e+001
     754,-3.908502110590e+000,-8.950004833000e+001,1.600810228783e+001
     755,-3.908502110590e+000,-8.950004833000e+001,1.654586187308e+001
     756,-3.908502110590e+000,-8.950004833000e+001,1.712843475711e+001
     757,-3.908502110590e+000,-8.950004833000e+001,1.766619434237e+001
     758,-3.908502110590e+000,-8.950004833000e+001,1.824876722640e+001
     759,-3.908502110590e+000,-8.950004833000e+001,1.878652681165e+001
     760,-3.908502110590e+000,-8.950004833000e+001,1.936909969568e+001
     761,-3.908502110590e+000,-8.950004833000e+001,1.990685928094e+001
     762,-3.908502110590e+000,-8.950004833000e+001,2.048943216497e+001
     763,-3.908502110590e+000,-8.950004833000e+001,2.102719175022e+001
     764,-3.908502110590e+000,-8.950004833000e+001,2.156495133548e+001
     765,-3.908502110590e+000,-8.950004833000e+001,2.210271092074e+001
     766,-3.908502110590e+000,-8.950004833000e+001,2.268528380476e+001
     767,-3.908502110590e+000,-8.950004833000e+001,2.322304339002e+001
     768,-3.908502110590e+000,-8.950004833000e+001,2.380561627405e+001
     769,-3.908502110590e+000,-8.950004833000e+001,2.434337585931e+001
     770,-3.908502110590e+000,-8.950004833000e+001,2.488113544456e+001
     771,-3.908502110590e+000,-8.950004833000e+001,2.546370832859e+001
     772,-3.908502110590e+000,-8.950004833000e+001,2.600146791385e+001
     773,-3.908502110590e+000,-8.950004833000e+001,2.653922749910e+001
     774,-3.908502110590e+000,-8.950004833000e+001,2.707698708436e+001
     775,-3.908502110590e+000,-8.950004833000e+001,2.761474666962e+001
     776,-3.908502110590e+000,-8.950004833000e+001,2.815250625487e+001
     777,-3.908502110590e+000,-8.950004833000e+001,2.873507913890e+001
     778,-3.908502110590e+000,-8.950004833000e+001,2.927283872416e+001
     779,-3.908502110590e+000,-8.950004833000e+001,2.985541160819e+001
     780,-3.908502110590e+000,-8.950004833000e+001,3.039317119344e+001
     781,-3.908502110590e+000,-8.950004833000e+001,3.093093077870e+001
     782,-3.908502110590e+000,-8.950004833000e+001,3.146869036396e+001
     783,-3.908502110590e+000,-8.950004833000e+001,3.200644994921e+001
     784,-3.908502110590e+000,-8.950004833000e+001,3.254420953447e+001
     785,-3.908502110590e+000,-8.950004833000e+001,3.312678241850e+001
     786,-3.908502110590e+000,-8.950004833000e+001,3.370935530253e+001
     787,-3.908502110590e+000,-8.950004833000e+001,3.424711488778e+001
     788,-3.908502110590e+000,-8.950004833000e+001,3.478487447304e+001
     789,-3.908502110590e+000,-8.950004833000e+001,3.532263405830e+001
     790,-3.908502110590e+000,-8.950004833000e+001,3.590520694232e+001
     791,-3.908502110590e+000,-8.950004833000e+001,3.644296652758e+001
     792,-3.908502110590e+000,-8.950004833000e+001,3.698072611284e+001
     793,-3.908502110590e+000,-8.950004833000e+001,3.751848569809e+001
     794,-3.908502110590e+000,-8.950004833000e+001,3.805624528335e+001
     795,-3.908502110590e+000,-8.950004833000e+001,3.863881816738e+001
     796,-3.908502110590e+000,-8.950004833000e+001,3.917657775264e+001
     797,-3.908502110590e+000,-8.950004833000e+001,3.975915063666e+001
     798,-3.908502110590e+000,-8.950004833000e+001,4.029691022192e+001
     799,-3.908502110590e+000,-8.950004833000e+001,4.087948310595e+001
     800,-3.908502110590e+000,-8.950004833000e+001,4.141724269120e+001
     801,-3.908502110590e+000,-8.950004833000e+001,4.195500227646e+001
     802,-3.908502110590e+000,-8.950004833000e+001,4.249276186172e+001
     803,-3.908502110590e+000,-8.950004833000e+001,4.307533474575e+001
     804,-3.908502110590e+000,-8.950004833000e+001,4.361309433100e+001
     805,-3.908502110590e+000,-8.950004833000e+001,4.419566721503e+001
     806,-3.908502110590e+000,-8.950004833000e+001,4.473342680029e+001
     807,-3.908502110590e+000,-8.950004833000e+001,4.527118638554e+001
     808,-3.908502110590e+000,-8.950004833000e+001,4.585375926957e+001
     809,-3.908502110590e+000,-8.950004833000e+001,4.639151885483e+001
     810,-3.908502110590e+000,-8.925004819500e+001,2.250419565011e+000
     811,-3.908502110590e+000,-8.925004819500e+001,2.564112656411e+000
     812,-3.908502110590e+000,-8.925004819500e+001,3.057058942896e+000
     813,-3.908502110590e+000,-8.925004819500e+001,3.684445125696e+000
     814,-3.908502110590e+000,-8.925004819500e+001,4.267018009724e+000
     815,-3.908502110590e+000,-8.925004819500e+001,4.849590893752e+000
     816,-3.908502110590e+000,-8.925004819500e+001,5.432163777780e+000
     817,-3.908502110590e+000,-8.925004819500e+001,6.014736661808e+000
     818,-3.908502110590e+000,-8.925004819500e+001,6.597309545836e+000
     819,-3.908502110590e+000,-8.925004819500e+001,7.224695728635e+000
     820,-3.908502110590e+000,-8.925004819500e+001,7.807268612663e+000
     821,-3.908502110590e+000,-8.925004819500e+001,8.389841496691e+000
     822,-3.908502110590e+000,-8.925004819500e+001,8.972414380720e+000
     823,-3.908502110590e+000,-8.925004819500e+001,9.554987264748e+000
     824,-3.908502110590e+000,-8.925004819500e+001,1.013756014878e+001
     825,-3.908502110590e+000,-8.925004819500e+001,1.076494633158e+001
     826,-3.908502110590e+000,-8.925004819500e+001,1.134751921560e+001
     827,-3.908502110590e+000,-8.925004819500e+001,1.193009209963e+001
     828,-3.908502110590e+000,-8.925004819500e+001,1.251266498366e+001
     829,-3.908502110590e+000,-8.925004819500e+001,1.309523786769e+001
     830,-3.908502110590e+000,-8.925004819500e+001,1.367781075172e+001
     831,-3.908502110590e+000,-8.925004819500e+001,1.430519693451e+001
     832,-3.908502110590e+000,-8.925004819500e+001,1.488776981854e+001
     833,-3.908502110590e+000,-8.925004819500e+001,1.547034270257e+001
     834,-3.908502110590e+000,-8.925004819500e+001,1.605291558660e+001
     835,-3.908502110590e+000,-8.925004819500e+001,1.663548847063e+001
     836,-3.908502110590e+000,-8.925004819500e+001,1.721806135465e+001
     837,-3.908502110590e+000,-8.925004819500e+001,1.784544753745e+001
     838,-3.908502110590e+000,-8.925004819500e+001,1.842802042148e+001
     839,-3.908502110590e+000,-8.925004819500e+001,1.901059330551e+001
     840,-3.908502110590e+000,-8.925004819500e+001,1.959316618954e+001
     841,-3.908502110590e+000,-8.925004819500e+001,2.017573907357e+001
     842,-3.908502110590e+000,-8.925004819500e+001,2.075831195759e+001
     843,-3.908502110590e+000,-8.925004819500e+001,2.138569814039e+001
     844,-3.908502110590e+000,-8.925004819500e+001,2.196827102442e+001
     845,-3.908502110590e+000,-8.925004819500e+001,2.255084390845e+001
     846,-3.908502110590e+000,-8.925004819500e+001,2.313341679248e+001
     847,-3.908502110590e+000,-8.925004819500e+001,2.371598967651e+001
     848,-3.908502110590e+000,-8.925004819500e+001,2.429856256053e+001
     849,-3.908502110590e+000,-8.925004819500e+001,2.492594874333e+001
     850,-3.908502110590e+000,-8.925004819500e+001,2.550852162736e+001
     851,-3.908502110590e+000,-8.925004819500e+001,2.609109451139e+001
     852,-3.908502110590e+000,-8.925004819500e+001,2.667366739542e+001
     853,-3.908502110590e+000,-8.925004819500e+001,2.725624027945e+001
     854,-3.908502110590e+000,-8.925004819500e+001,2.783881316347e+001
     855,-3.908502110590e+000,-8.925004819500e+001,2.846619934627e+001
     856,-3.908502110590e+000,-8.925004819500e+001,2.904877223030e+001
     857,-3.908502110590e+000,-8.925004819500e+001,2.963134511433e+001
     858,-3.908502110590e+000,-8.925004819500e+001,3.021391799836e+001
     859,-3.908502110590e+000,-8.925004819500e+001,3.079649088239e+001
     860,-3.908502110590e+000,-8.925004819500e+001,3.137906376641e+001
     861,-3.908502110590e+000,-8.925004819500e+001,3.200644994921e+001
     862,-3.908502110590e+000,-8.925004819500e+001,3.258902283324e+001
     863,-3.908502110590e+000,-8.925004819500e+001,3.317159571727e+001
     864,-3.908502110590e+000,-8.925004819500e+001,3.375416860130e+001
     865,-3.908502110590e+000,-8.925004819500e+001,3.433674148533e+001
     866,-3.908502110590e+000,-8.925004819500e+001,3.491931436935e+001
     867,-3.908502110590e+000,-8.925004819500e+001,3.554670055215e+001
     868,-3.908502110590e+000,-8.925004819500e+001,3.612927343618e+001
     869,-3.908502110590e+000,-8.925004819500e+001,3.671184632021e+001
     870,-3.908502110590e+000,-8.925004819500e+001,3.729441920424e+001
     871,-3.908502110590e+000,-8.925004819500e+001,3.787699208827e+001
     872,-3.908502110590e+000,-8.925004819500e+001,3.845956497229e+001
     873,-3.908502110590e+000,-8.925004819500e+001,3.908695115509e+001
     874,-3.908502110590e+000,-8.925004819500e+001,3.966952403912e+001
     875,-3.908502110590e+000,-8.925004819500e+001,4.025209692315e+001
     876,-3.908502110590e+000,-8.925004819500e+001,4.083466980718e+001
     877,-3.908502110590e+000,-8.925004819500e+001,4.141724269120e+001
     878,-3.908502110590e+000,-8.925004819500e+001,4.199981557523e+001
     879,-3.908502110590e+000,-8.925004819500e+001,4.262720175803e+001
     880,-3.908502110590e+000,-8.925004819500e+001,4.320977464206e+001
     881,-3.908502110590e+000,-8.925004819500e+001,4.379234752609e+001
     882,-3.908502110590e+000,-8.925004819500e+001,4.437492041012e+001
     883,-3.908502110590e+000,-8.925004819500e+001,4.495749329414e+001
     884,-3.908502110590e+000,-8.925004819500e+001,4.558487947694e+001
     885,-3.908502110590e+000,-8.925004819500e+001,4.612263906220e+001
     886,-3.908502110590e+000,-8.925004819500e+001,4.648114545237e+001
     887,-2.538656370874e+000,-8.925004819500e+001,1.936726473612e+000
     888,-3.133898692304e+000,-8.925004819500e+001,1.936726473612e+000
     889,-3.585257936038e+000,-8.925004819500e+001,1.936726473612e+000
     890,-1.937501046250e+000,-9.193736879161e+001,9.335634278384e+000
     891,-1.937501046250e+000,-9.293066954223e+001,9.358342901153e+000
     892,-1.937501046250e+000,-9.402919522476e+001,9.239570354623e+000
     893,-1.937501046250e+000,-9.513204446986e+001,9.322604344215e+000
     894,-1.937501046250e+000,-9.595782294149e+001,9.416210848203e+000
     895,-1.937501046250e+000,-9.634508909380e+001,9.450057576025e+000
     896,-1.937501046250e+000,-9.675717159955e+001,9.622659612805e+000
     897,-1.937501046250e+000,-9.703719864077e+001,1.000709989076e+001
     898,-1.937501046250e+000,-9.711741733942e+001,1.042167711474e+001
     899,-1.937501046250e+000,-9.706611471236e+001,1.073319619910e+001
     900,-1.937501046250e+000,-9.704977084349e+001,1.148842296172e+001
     901,-1.937501046250e+000,-9.740194355985e+001,1.245380199862e+001
     902,-1.937501046250e+000,-9.718600812362e+001,1.380858200633e+001
     903,-1.937501046250e+000,-9.675676390279e+001,1.487283686159e+001
     904,-1.937501046250e+000,-9.663770387314e+001,1.599050332250e+001
     905,-1.937501046250e+000,-9.622833469172e+001,1.702073987949e+001
     906,-1.937501046250e+000,-9.616179153237e+001,1.736074737477e+001
     907,-1.937501046250e+000,-9.595328949671e+001,1.775525375494e+001
     908,-1.937501046250e+000,-9.549573647767e+001,1.799566821530e+001
     909,-1.937501046250e+000,-9.511621437952e+001,1.805994569479e+001
     910,-1.937501046250e+000,-9.434371089137e+001,1.813995256252e+001
     911,-1.937501046250e+000,-9.342466863414e+001,1.821360995002e+001
     912,-1.937501046250e+000,-9.230177874914e+001,1.828038396096e+001
     913,-1.937501046250e+000,-9.153386988913e+001,1.803291179353e+001
     914,-1.937501046250e+000,-9.118416260958e+001,1.790470612810e+001
     915,-1.937501046250e+000,-9.087975189369e+001,1.760643188978e+001
     916,-1.937501046250e+000,-9.072234656791e+001,1.722966216291e+001
     917,-1.937501046250e+000,-9.070246619180e+001,1.691326222706e+001
     918,-1.937501046250e+000,-9.056392046402e+001,1.597211011708e+001
     919,-1.937501046250e+000,-9.045237199076e+001,1.485433838747e+001
     920,-1.937501046250e+000,-9.056286886825e+001,1.379582065827e+001
     921,-1.937501046250e+000,-9.046579965369e+001,1.269836955475e+001
     922,-1.937501046250e+000,-9.019713694554e+001,1.159540775119e+001
     923,-1.937501046250e+000,-9.071540076924e+001,1.059578738045e+001
     924,-1.937501046250e+000,-9.072876112700e+001,1.027465167183e+001
     925,-1.937501046250e+000,-9.087497770879e+001,9.918421338471e+000
     926,-1.937501046250e+000,-9.116484212065e+001,9.632091226010e+000
     927,-1.937501046250e+000,-9.150347498614e+001,9.457558612472e+000
     928,-1.937501046250e+000,-9.573361725241e+001,2.074886814815e+001
     929,-1.937501046250e+000,-9.615142580166e+001,2.179533920994e+001
     930,-1.937501046250e+000,-9.588760402398e+001,2.300940133399e+001
     931,-1.937501046250e+000,-9.563835284573e+001,2.432797657225e+001
     932,-1.937501046250e+000,-9.567127409084e+001,2.516210965755e+001
     933,-1.937501046250e+000,-9.505193406889e+001,2.606891997448e+001
     934,-1.937501046250e+000,-9.492893586264e+001,2.642219237594e+001
     935,-1.937501046250e+000,-9.470881922978e+001,2.683995597644e+001
     936,-1.937501046250e+000,-9.425547430445e+001,2.698003170749e+001
     937,-1.937501046250e+000,-9.391031650495e+001,2.701806718254e+001
     938,-1.937501046250e+000,-9.304060283670e+001,2.720880777141e+001
     939,-1.937501046250e+000,-9.155557225115e+001,2.701981814156e+001
     940,-1.937501046250e+000,-9.117820694114e+001,2.687560895791e+001
     941,-1.937501046250e+000,-9.086268413408e+001,2.662790201543e+001
     942,-1.937501046250e+000,-9.074237365620e+001,2.622735884690e+001
     943,-1.937501046250e+000,-9.068066163834e+001,2.589092863922e+001
     944,-1.937501046250e+000,-9.047893096348e+001,2.505361044259e+001
     945,-1.937501046250e+000,-9.056046277617e+001,2.398784746460e+001
     946,-1.937501046250e+000,-9.045218934417e+001,2.294556421987e+001
     947,-1.937501046250e+000,-9.058469716032e+001,2.190139633547e+001
     948,-1.937501046250e+000,-9.061337871307e+001,2.096030641378e+001
     949,-1.937501046250e+000,-9.074750624009e+001,2.026700017183e+001
     950,-1.937501046250e+000,-9.090159297655e+001,1.988433970042e+001
     951,-1.937501046250e+000,-9.119548176978e+001,1.962844792887e+001
     952,-1.937501046250e+000,-9.154963509830e+001,1.946369354112e+001
     953,-1.937501046250e+000,-9.237153410723e+001,1.933069927530e+001
     954,-1.937501046250e+000,-9.359083132078e+001,1.927372481865e+001
     955,-1.937501046250e+000,-9.459640520480e+001,1.943847730895e+001
     956,-1.937501046250e+000,-9.496491349554e+001,1.949496347906e+001
     957,-1.937501046250e+000,-9.537548280012e+001,1.963305962769e+001
     958,-1.937501046250e+000,-9.570426444284e+001,1.998883911003e+001
     959,-1.937501046250e+000,-9.575382608599e+001,2.041872340549e+001
     960,-1.937501046250e+000,-9.450509134459e+001,2.973622068238e+001
     961,-1.937501046250e+000,-9.490897818453e+001,3.070281119771e+001
     962,-1.937501046250e+000,-9.467416707728e+001,3.155252149313e+001
     963,-1.937501046250e+000,-9.446580449539e+001,3.319317860213e+001
     964,-1.937501046250e+000,-9.443384002126e+001,3.406421587822e+001
     965,-1.937501046250e+000,-9.423829347604e+001,3.492922877055e+001
     966,-1.937501046250e+000,-9.372767111478e+001,3.599308001919e+001
     967,-1.937501046250e+000,-9.362548415575e+001,3.631556213716e+001
     968,-1.937501046250e+000,-9.347320812928e+001,3.667704665736e+001
     969,-1.937501046250e+000,-9.317042272942e+001,3.690116815983e+001
     970,-1.937501046250e+000,-9.285239477324e+001,3.702935618836e+001
     971,-1.937501046250e+000,-9.151809649877e+001,3.703891551388e+001
     972,-1.937501046250e+000,-9.115291770378e+001,3.687017478544e+001
     973,-1.937501046250e+000,-9.085614609161e+001,3.656124700264e+001
     974,-1.937501046250e+000,-9.074797357752e+001,3.620621048493e+001
     975,-1.937501046250e+000,-9.073339770481e+001,3.589348828259e+001
     976,-1.937501046250e+000,-9.047254164463e+001,3.490405482598e+001
     977,-1.937501046250e+000,-9.047001866786e+001,3.384239507961e+001
     978,-1.937501046250e+000,-9.047098132343e+001,3.272518375149e+001
     979,-1.937501046250e+000,-9.047349785439e+001,3.168063383081e+001
     980,-1.937501046250e+000,-9.056874174854e+001,3.058802265934e+001
     981,-1.937501046250e+000,-9.070213419770e+001,2.959046680550e+001
     982,-1.937501046250e+000,-9.072064645834e+001,2.926719205804e+001
     983,-1.937501046250e+000,-9.089641818992e+001,2.892013560604e+001
     984,-1.937501046250e+000,-9.119554035520e+001,2.864666933176e+001
     985,-1.937501046250e+000,-9.150545626545e+001,2.847335202360e+001
     986,-1.937501046250e+000,-9.236677898976e+001,2.836521258829e+001
     987,-1.937501046250e+000,-9.334449730452e+001,2.836067074384e+001
     988,-1.937501046250e+000,-9.417696347984e+001,2.861850270870e+001
     989,-1.937501046250e+000,-9.450989555499e+001,2.898951479355e+001
     990,-1.937501046250e+000,-9.455858273499e+001,2.940391477446e+001
     991,-1.937501046250e+000,-9.906836148230e+001,2.655475746449e+000
     992,-1.937501046250e+000,-9.889517103830e+001,3.608220666169e+000
     993,-1.937501046250e+000,-9.863295129396e+001,4.638201742269e+000
     994,-1.937501046250e+000,-9.842362071738e+001,5.664648362854e+000
     995,-1.937501046250e+000,-9.831260209565e+001,6.750679763352e+000
     996,-1.937501046250e+000,-9.819030594962e+001,7.758325743146e+000
     997,-1.937501046250e+000,-9.816025493345e+001,8.799385748158e+000
     998,-1.937501046250e+000,-9.802712654574e+001,1.061600330294e+001
     999,-1.937501046250e+000,-9.774214050253e+001,1.142761452123e+001
    1000,-1.937501046250e+000,-9.728171498942e+001,1.545828418105e+001
    1001,-1.937501046250e+000,-9.708141796921e+001,1.722819749849e+001
    1002,-1.937501046250e+000,-9.693239881386e+001,1.827112747668e+001
    1003,-1.937501046250e+000,-9.676474465636e+001,1.928304072627e+001
    1004,-1.937501046250e+000,-9.670707682304e+001,2.029372448670e+001
    1005,-1.937501046250e+000,-9.659127098787e+001,2.106899868461e+001
    1006,-1.937501046250e+000,-9.578676967877e+001,2.711908016221e+001
    1007,-1.937501046250e+000,-9.555628499530e+001,2.803109771157e+001
    1008,-1.937501046250e+000,-9.555277665663e+001,2.898491421820e+001
    1009,-1.937501046250e+000,-9.533094492348e+001,2.983902580415e+001
    1010,-1.937501046250e+000,-9.412867392065e+001,3.784635347041e+001
    1011,-1.937501046250e+000,-9.409626728611e+001,3.877305821950e+001
    1012,-1.937501046250e+000,-9.404640295077e+001,3.967530992140e+001
    1013,-1.937501046250e+000,-9.389276037433e+001,4.068325329470e+001
    1014,-1.937501046250e+000,-9.369895991254e+001,4.166409842883e+001
    1015,-1.937501046250e+000,-9.356719676746e+001,4.269015517729e+001
    1016,-1.937501046250e+000,-9.349047525278e+001,4.367613878143e+001
    1017,-1.937501046250e+000,-9.344813014670e+001,4.463324881006e+001
    1018,-1.937501046250e+000,-9.354016959770e+001,4.598657909885e+001
    1019,-1.937501046250e+000,-8.999381923610e+001,2.423184976592e+000
    1020,-1.937501046250e+000,-9.055242352135e+001,2.460621854760e+000
    1021,-1.937501046250e+000,-9.118604278633e+001,2.463904123079e+000
    1022,-1.937501046250e+000,-9.175389670533e+001,2.460793147748e+000
    1023,-1.937501046250e+000,-9.229599150832e+001,2.456420126697e+000
    1024,-1.937501046250e+000,-9.283223214509e+001,2.459848711852e+000
    1025,-1.937501046250e+000,-9.346901096919e+001,2.462146504539e+000
    1026,-1.937501046250e+000,-9.401540401586e+001,2.440547002104e+000
    1027,-1.937501046250e+000,-9.455286014346e+001,2.434098630897e+000
    1028,-1.937501046250e+000,-9.507916790792e+001,2.448415872057e+000
    1029,-1.937501046250e+000,-9.569119051407e+001,2.461069875579e+000
    1030,-1.937501046250e+000,-9.625527638508e+001,2.470483927026e+000
    1031,-1.937501046250e+000,-9.682477400291e+001,2.491224493146e+000
    1032,-1.937501046250e+000,-9.738074219477e+001,2.475634228377e+000
    1033,-1.937501046250e+000,-9.795634397247e+001,2.452340851950e+000
    1034,-1.937501046250e+000,-9.849756165758e+001,2.412498304044e+000
    1035,-1.937501046250e+000,-8.969142139491e+001,4.562378966709e+001
    1036,-1.937501046250e+000,-8.983002962731e+001,4.497117890273e+001
    1037,-1.937501046250e+000,-8.990221140342e+001,4.425836563174e+001
    1038,-1.937501046250e+000,-8.988090090096e+001,4.351183602140e+001
    1039,-1.937501046250e+000,-8.991677786409e+001,4.275725559818e+001
    1040,-1.937501046250e+000,-8.994154064622e+001,4.204816683129e+001
    1041,-1.937501046250e+000,-8.986782159294e+001,4.120383990913e+001
    1042,-1.937501046250e+000,-8.991166911948e+001,4.046360107596e+001
    1043,-1.937501046250e+000,-8.999917091765e+001,3.972089449522e+001
    1044,-1.937501046250e+000,-9.002031908372e+001,3.896135863837e+001
    1045,-1.937501046250e+000,-8.998321671019e+001,3.817423373628e+001
    1046,-1.937501046250e+000,-8.991438505920e+001,3.740722441357e+001
    1047,-1.937501046250e+000,-8.985967315125e+001,3.669711230384e+001
    1048,-1.937501046250e+000,-8.990028534824e+001,3.596951716707e+001
    1049,-1.937501046250e+000,-8.986986328024e+001,3.520815218421e+001
    1050,-1.937501046250e+000,-8.995284778502e+001,3.441956226339e+001
    1051,-1.937501046250e+000,-8.986740597156e+001,3.360955818017e+001
    1052,-1.937501046250e+000,-8.986896800712e+001,3.295497119617e+001
    1053,-1.937501046250e+000,-8.994709391003e+001,3.218655852532e+001
    1054,-1.937501046250e+000,-8.988299607676e+001,3.143653931201e+001
    1055,-1.937501046250e+000,-8.996733358890e+001,3.063656146931e+001
    1056,-1.937501046250e+000,-8.984314103516e+001,2.985288527670e+001
    1057,-1.937501046250e+000,-8.981603132576e+001,2.918985910770e+001
    1058,-1.937501046250e+000,-8.986298181090e+001,2.847871768209e+001
    1059,-1.937501046250e+000,-8.989684712948e+001,2.776594031551e+001
    1060,-1.937501046250e+000,-8.985990770317e+001,2.696033557356e+001
    1061,-1.937501046250e+000,-8.984333066982e+001,2.619633174036e+001
    1062,-1.937501046250e+000,-8.990590884781e+001,2.545810397034e+001
    1063,-1.937501046250e+000,-8.986495730147e+001,2.477867964920e+001
    1064,-1.937501046250e+000,-8.993216618670e+001,2.399470096347e+001
    1065,-1.937501046250e+000,-8.986494969764e+001,2.327379710334e+001
    1066,-1.937501046250e+000,-8.987414464463e+001,2.258985215257e+001
    1067,-1.937501046250e+000,-8.997618336832e+001,2.186966310263e+001
    1068,-1.937501046250e+000,-8.993367730823e+001,2.109089015215e+001
    1069,-1.937501046250e+000,-8.984090985595e+001,2.033337874360e+001
    1070,-1.937501046250e+000,-8.976731862863e+001,1.960287851207e+001
    1071,-1.937501046250e+000,-8.975711365721e+001,1.888151966168e+001
    1072,-1.937501046250e+000,-8.991904060623e+001,1.808919682965e+001
    1073,-1.937501046250e+000,-8.982767658174e+001,1.736502785909e+001
    1074,-1.937501046250e+000,-8.984027120334e+001,1.671140448007e+001
    1075,-1.937501046250e+000,-8.992964270458e+001,1.596613204557e+001
    1076,-1.937501046250e+000,-8.986327287590e+001,1.517704483480e+001
    1077,-1.937501046250e+000,-8.987304741851e+001,1.451432123542e+001
    1078,-1.937501046250e+000,-8.995672210665e+001,1.379883193379e+001
    1079,-1.937501046250e+000,-8.987200067259e+001,1.300363512409e+001
    1080,-1.937501046250e+000,-8.992071565827e+001,1.231408265281e+001
    1081,-1.937501046250e+000,-8.984726091976e+001,1.014589234655e+001
    1082,-1.937501046250e+000,-8.997752151345e+001,9.406276026961e+000
    1083,-1.937501046250e+000,-8.986662847814e+001,8.630356783318e+000
    1084,-1.937501046250e+000,-8.983094368790e+001,7.898576449469e+000
    1085,-1.937501046250e+000,-8.982267505891e+001,7.171079700019e+000
    1086,-1.937501046250e+000,-8.982960504901e+001,6.427541829460e+000
    1087,-1.937501046250e+000,-8.983049560070e+001,5.669664049865e+000
    1088,-1.937501046250e+000,-8.982632823899e+001,4.920267927456e+000
    1089,-1.937501046250e+000,-8.980233100896e+001,4.180915125524e+000
    1090,-1.937501046250e+000,-8.975717051059e+001,3.490240086316e+000
    1091,-1.937501046250e+000,-8.999349790165e+001,4.619498079092e+001
    1092,-1.937501046250e+000,-9.344920229025e+001,4.643183518707e+001
    1093,-1.937501046250e+000,-9.309615592492e+001,4.646599057749e+001
    1094,-1.937501046250e+000,-9.274825998094e+001,4.645556528859e+001
    1095,-1.937501046250e+000,-9.179927267496e+001,4.605349288290e+001
    1096,-1.937501046250e+000,-9.117866205668e+001,4.615381052293e+001
    1097,-1.937501046250e+000,-9.059483623619e+001,4.620683744871e+001
    1098,-1.937501046250e+000,-9.245580042053e+001,9.293102475710e+000
    1099,-1.937501046250e+000,-9.347430349633e+001,9.256043198340e+000
    1100,-1.937501046250e+000,-9.458552183170e+001,9.260730049536e+000
    1101,-1.937501046250e+000,-9.558204667887e+001,9.383815048965e+000
    1102,-1.937501046250e+000,-9.713978349726e+001,1.106945707367e+001
    1103,-1.937501046250e+000,-9.709276930473e+001,1.196269871719e+001
    1104,-1.937501046250e+000,-9.714961262949e+001,1.309902732765e+001
    1105,-1.937501046250e+000,-9.679922531219e+001,1.433011514096e+001
    1106,-1.937501046250e+000,-9.660692352914e+001,1.541385342452e+001
    1107,-1.937501046250e+000,-9.653615204417e+001,1.667549374826e+001
    1108,-1.937501046250e+000,-9.475932447250e+001,1.807902229217e+001
    1109,-1.937501046250e+000,-9.389869223108e+001,1.810902037310e+001
    1110,-1.937501046250e+000,-9.288373759926e+001,1.822710891955e+001
    1111,-1.937501046250e+000,-9.188313802473e+001,1.805134867926e+001
    1112,-1.937501046250e+000,-9.047281154449e+001,1.650111469894e+001
    1113,-1.937501046250e+000,-9.046550657942e+001,1.540808162717e+001
    1114,-1.937501046250e+000,-9.047297123350e+001,1.429343759423e+001
    1115,-1.937501046250e+000,-9.047404517827e+001,1.325988490700e+001
    1116,-1.937501046250e+000,-9.051144323510e+001,1.216870862886e+001
    1117,-1.937501046250e+000,-9.050496344666e+001,1.097670153025e+001
    1118,-1.937501046250e+000,-9.588293797093e+001,2.241084923536e+001
    1119,-1.937501046250e+000,-9.590603886876e+001,2.117056744981e+001
    1120,-1.937501046250e+000,-9.567902961217e+001,2.360047931740e+001
    1121,-1.937501046250e+000,-9.526218099778e+001,2.570020466131e+001
    1122,-1.937501046250e+000,-9.352653294782e+001,2.707727315216e+001
    1123,-1.937501046250e+000,-9.192206753596e+001,2.711481496155e+001
    1124,-1.937501046250e+000,-9.244682093437e+001,2.723794159129e+001
    1125,-1.937501046250e+000,-9.058758812567e+001,2.552801606036e+001
    1126,-1.937501046250e+000,-9.046732326733e+001,2.452913941913e+001
    1127,-1.937501046250e+000,-9.046717513141e+001,2.350241823971e+001
    1128,-1.937501046250e+000,-9.047806667314e+001,2.238618208114e+001
    1129,-1.937501046250e+000,-9.051687530054e+001,2.142641880397e+001
    1130,-1.937501046250e+000,-9.069089692034e+001,2.061055360350e+001
    1131,-1.937501046250e+000,-9.190757092721e+001,1.936925056411e+001
    1132,-1.937501046250e+000,-9.298207055910e+001,1.928917453191e+001
    1133,-1.937501046250e+000,-9.415895221598e+001,1.934081447788e+001
    1134,-1.937501046250e+000,-9.465598287616e+001,3.005336285236e+001
    1135,-1.937501046250e+000,-9.452654733451e+001,3.235581370779e+001
    1136,-1.937501046250e+000,-9.389519707068e+001,3.561140667633e+001
    1137,-1.937501046250e+000,-9.194457641635e+001,3.712373229420e+001
    1138,-1.937501046250e+000,-9.245015454718e+001,3.711910181875e+001
    1139,-1.937501046250e+000,-9.046296768366e+001,3.550594604427e+001
    1140,-1.937501046250e+000,-9.057021037974e+001,3.439626713549e+001
    1141,-1.937501046250e+000,-9.045488985777e+001,3.328176367321e+001
    1142,-1.937501046250e+000,-9.056391108621e+001,3.217770560160e+001
    1143,-1.937501046250e+000,-9.047537765541e+001,3.111291010498e+001
    1144,-1.937501046250e+000,-9.047594297303e+001,3.002142760194e+001
    1145,-1.937501046250e+000,-9.189684739119e+001,2.841394791720e+001
    1146,-1.937501046250e+000,-9.285742043065e+001,2.832794468287e+001
    1147,-1.937501046250e+000,-9.374370122235e+001,2.849463562727e+001
    1148,-1.937501046250e+000,-9.810070481269e+001,9.840442325488e+000
    1149,-1.937501046250e+000,-9.741554607551e+001,1.452306841290e+001
    1150,-1.937501046250e+000,-9.721581962130e+001,1.637619051140e+001
    1151,-1.937501046250e+000,-9.594113024044e+001,2.590374766722e+001
    1152,-1.937501046250e+000,-9.458150917031e+001,3.573104609871e+001
    1153,-1.937501046250e+000,-9.443299933618e+001,3.702311777324e+001
    1154,-1.937501046250e+000,-9.349447526956e+001,4.538784425694e+001
    1155,-1.937501046250e+000,-8.986320493049e+001,1.081405834543e+001
    1156,-1.937501046250e+000,-8.968959604708e+001,2.885645678841e+000
    1157,-1.937501046250e+000,-9.241959857872e+001,4.613768650053e+001
    1158,-1.937501046250e+000,-9.217077549426e+001,8.821850293489e+000
    1159,-1.937501046250e+000,-9.429642843246e+001,8.687191129371e+000
    1160,-1.937501046250e+000,-9.542856953241e+001,8.833749056460e+000
    1161,-1.937501046250e+000,-9.616098406477e+001,2.067516994083e+001
    1162,-1.937501046250e+000,-9.746249183787e+001,1.070439492873e+001
    1163,-1.937501046250e+000,-9.623893722793e+001,8.990643060330e+000
    1164,-1.937501046250e+000,-9.495869358153e+001,1.839337893687e+001
    1165,-1.937501046250e+000,-9.652718354299e+001,1.719081620016e+001
    1166,-1.937501046250e+000,-9.175360359941e+001,1.845743638354e+001
    1167,-1.937501046250e+000,-9.032990738038e+001,1.044334611304e+001
    1168,-1.937501046250e+000,-9.545342562810e+001,2.609019037673e+001
    1169,-1.937501046250e+000,-9.202189262728e+001,2.755788030744e+001
    1170,-1.937501046250e+000,-9.037304024125e+001,2.033549427206e+001
    1171,-1.937501046250e+000,-9.121045155849e+001,2.725498683745e+001
    1172,-1.937501046250e+000,-9.026626518704e+001,2.581498350545e+001
    1173,-1.937501046250e+000,-9.345220763708e+001,2.754187006830e+001
    1174,-1.937501046250e+000,-9.450393287180e+001,1.901299449777e+001
    1175,-1.937501046250e+000,-9.207553779107e+001,1.888364780222e+001
    1176,-1.937501046250e+000,-9.396804199780e+001,1.871223241899e+001
    1177,-1.937501046250e+000,-9.412952019455e+001,3.596174416360e+001
    1178,-1.937501046250e+000,-9.483838006368e+001,2.966277241749e+001
    1179,-1.937501046250e+000,-9.325594578738e+001,1.874893786442e+001
    1180,-1.937501046250e+000,-9.247330333065e+001,4.513989815564e+001
    1181,-1.937501046250e+000,-9.276179076107e+001,3.747698165566e+001
    1182,-1.937501046250e+000,-9.164110827840e+001,3.749420057855e+001
    1183,-1.937501046250e+000,-9.400873778832e+001,2.828181785862e+001
    1184,-1.937501046250e+000,-9.161157245988e+001,2.795982035271e+001
    1185,-1.937501046250e+000,-9.032730741781e+001,2.945043551129e+001
    1186,-1.937501046250e+000,-9.364761796839e+001,2.801511850720e+001
    1187,-1.937501046250e+000,-9.305487950806e+001,2.780078862328e+001
    1188,-1.937501046250e+000,-9.487524889118e+001,2.855221731806e+001
    1189,-1.937501046250e+000,-9.753019390985e+001,1.018974815837e+001
    1190,-1.937501046250e+000,-9.762061510945e+001,4.910675904069e+000
    1191,-1.937501046250e+000,-9.739108738474e+001,6.056717963758e+000
    1192,-1.937501046250e+000,-9.724603513740e+001,7.219549655106e+000
    1193,-1.937501046250e+000,-9.726847021639e+001,8.308575738527e+000
    1194,-1.937501046250e+000,-9.063572213990e+001,4.161880230158e+001
    1195,-1.937501046250e+000,-9.220200783254e+001,3.757859262810e+001
    1196,-1.937501046250e+000,-9.313607091902e+001,3.924690931271e+001
    1197,-1.937501046250e+000,-9.321312343247e+001,4.010210467361e+001
    1198,-1.937501046250e+000,-9.284458006860e+001,4.092301825848e+001
    1199,-1.937501046250e+000,-9.254952666788e+001,4.203132637316e+001
    1200,-1.937501046250e+000,-9.244710532125e+001,4.318963003575e+001
    1201,-1.937501046250e+000,-9.269008293491e+001,4.422301988462e+001
    1202,-1.937501046250e+000,-9.288797456917e+001,8.798828785788e+000
    1203,-1.937501046250e+000,-9.079000662872e+001,3.116923413609e+000
    1204,-1.937501046250e+000,-9.142205425720e+001,3.061131800689e+000
    1205,-1.937501046250e+000,-9.199859012970e+001,3.009171839618e+000
    1206,-1.937501046250e+000,-9.255550151189e+001,3.028721115090e+000
    1207,-1.937501046250e+000,-9.315184462297e+001,3.080522588999e+000
    1208,-1.937501046250e+000,-9.380841795216e+001,3.076188925939e+000
    1209,-1.937501046250e+000,-9.430068733590e+001,2.920820964483e+000
    1210,-1.937501046250e+000,-9.480209090065e+001,3.037342627476e+000
    1211,-1.937501046250e+000,-9.534345104957e+001,3.032075218530e+000
    1212,-1.937501046250e+000,-9.600235983249e+001,3.033782081049e+000
    1213,-1.937501046250e+000,-9.659342875799e+001,3.122947370421e+000
    1214,-1.937501046250e+000,-9.719144547823e+001,3.193412705730e+000
    1215,-1.937501046250e+000,-9.774023196747e+001,3.014916014415e+000
    1216,-1.937501046250e+000,-9.842651328508e+001,3.017567601604e+000
    1217,-1.937501046250e+000,-9.068590404282e+001,4.480978588738e+001
    1218,-1.937501046250e+000,-9.063665978198e+001,4.400596957537e+001
    1219,-1.937501046250e+000,-9.054299692715e+001,4.315599819067e+001
    1220,-1.937501046250e+000,-9.114743854666e+001,4.238099731615e+001
    1221,-1.937501046250e+000,-9.092393543722e+001,4.014318714269e+001
    1222,-1.937501046250e+000,-9.106488844458e+001,3.930477702641e+001
    1223,-1.937501046250e+000,-9.099374697986e+001,3.846717642210e+001
    1224,-1.937501046250e+000,-9.062846457918e+001,3.769038928435e+001
    1225,-1.937501046250e+000,-9.581486407798e+001,9.016128858386e+000
    1226,-1.937501046250e+000,-9.049971917109e+001,2.810178039666e+001
    1227,-1.937501046250e+000,-9.038206358515e+001,1.983664325076e+001
    1228,-1.937501046250e+000,-9.028757179303e+001,1.923232645967e+001
    1229,-1.937501046250e+000,-9.031683584371e+001,1.858136925897e+001
    1230,-1.937501046250e+000,-9.027153592047e+001,4.556931672401e+001
    1231,-1.937501046250e+000,-9.366787658089e+001,8.681730650166e+000
    1232,-1.937501046250e+000,-9.050919224971e+001,8.952450634669e+000
    1233,-1.937501046250e+000,-9.045711920624e+001,8.292405385968e+000
    1234,-1.937501046250e+000,-9.047051823471e+001,7.589933746593e+000
    1235,-1.937501046250e+000,-9.049176954538e+001,6.825695685886e+000
    1236,-1.937501046250e+000,-9.050432288874e+001,6.068412631844e+000
    1237,-1.937501046250e+000,-9.049722614085e+001,5.244517236571e+000
    1238,-1.937501046250e+000,-9.047935732759e+001,4.452462521125e+000
    1239,-1.937501046250e+000,-9.037303651790e+001,3.686056786888e+000
    1240,-1.937501046250e+000,-9.322662975486e+001,4.614932667908e+001
    1241,-1.937501046250e+000,-9.288123363062e+001,4.615450753100e+001
    1242,-1.937501046250e+000,-9.489086138623e+001,8.747969977645e+000
    1243,-1.937501046250e+000,-9.739170336523e+001,9.469020547456e+000
    1244,-1.937501046250e+000,-9.650645073066e+001,1.765585804027e+001
    1245,-1.937501046250e+000,-9.583900916354e+001,1.825019944876e+001
    1246,-1.937501046250e+000,-9.541340899239e+001,1.850551322642e+001
    1247,-1.937501046250e+000,-9.071738009034e+001,1.810569201477e+001
    1248,-1.937501046250e+000,-9.040402464046e+001,1.756966815360e+001
    1249,-1.937501046250e+000,-9.065551459802e+001,9.505168201737e+000
    1250,-1.937501046250e+000,-9.523562725947e+001,2.677482348516e+001
    1251,-1.937501046250e+000,-9.456993361868e+001,2.727670677176e+001
    1252,-1.937501046250e+000,-9.413233260579e+001,2.730627537211e+001
    1253,-1.937501046250e+000,-9.063045017926e+001,2.722601473568e+001
    1254,-1.937501046250e+000,-9.036527185167e+001,2.661473339150e+001
    1255,-1.937501046250e+000,-9.036939843875e+001,2.615911085718e+001
    1256,-1.937501046250e+000,-9.080544430527e+001,1.946126333260e+001
    1257,-1.937501046250e+000,-9.120506146631e+001,1.924841430683e+001
    1258,-1.937501046250e+000,-9.534363310551e+001,1.913081096563e+001
    1259,-1.937501046250e+000,-9.586949731854e+001,1.942708255092e+001
    1260,-1.937501046250e+000,-9.611240384794e+001,2.024094713067e+001
    1261,-1.937501046250e+000,-9.395353867021e+001,3.669550671018e+001
    1262,-1.937501046250e+000,-9.365034210774e+001,3.719085596806e+001
    1263,-1.937501046250e+000,-9.314480310442e+001,3.727752087253e+001
    1264,-1.937501046250e+000,-9.057087307082e+001,3.700476675162e+001
    1265,-1.937501046250e+000,-9.037430700049e+001,3.643171234105e+001
    1266,-1.937501046250e+000,-9.079707451358e+001,2.853866114189e+001
    1267,-1.937501046250e+000,-9.113114352421e+001,2.821952738888e+001
    1268,-1.937501046250e+000,-9.249170178513e+001,2.786087445192e+001
    1269,-1.937501046250e+000,-9.497771484774e+001,2.922371506571e+001
    1270,-1.937501046250e+000,-9.790175464170e+001,3.813625234669e+000
    1271,-1.937501046250e+000,-9.021277427965e+001,2.986553158907e+000
    1272,-1.937501046250e+000,-9.055075380599e+001,4.086675485694e+001
    1273,-1.937501046250e+000,-9.150910413021e+001,4.529163803177e+001
    1274,-1.937501046250e+000,-9.032855919542e+001,1.706253554502e+001
    1275,-1.937501046250e+000,-9.262697225345e+001,1.879195844174e+001
    1276,-1.937501046250e+000,-9.454584782692e+001,1.854417683503e+001
    1277,-1.937501046250e+000,-9.126043908107e+001,1.837725859253e+001
    1278,-1.937501046250e+000,-9.040256277095e+001,9.968270104427e+000
    1279,-1.937501046250e+000,-9.162089497331e+001,2.743926145739e+001
    1280,-1.937501046250e+000,-9.110180508510e+001,9.193782591542e+000
    1281,-1.937501046250e+000,-9.526867876827e+001,2.637285651847e+001
    1282,-1.937501046250e+000,-9.623582134036e+001,1.981247867498e+001
    1283,-1.937501046250e+000,-9.027210118824e+001,2.069301450469e+001
    1284,-1.937501046250e+000,-9.485000486293e+001,1.918289105833e+001
    1285,-1.937501046250e+000,-9.398564144687e+001,3.627207149001e+001
    1286,-1.937501046250e+000,-9.112611800400e+001,3.732675677922e+001
    1287,-1.937501046250e+000,-9.444041796114e+001,2.818716790761e+001
    1288,-1.937501046250e+000,-9.039698351880e+001,2.887183870209e+001
    1289,-1.937501046250e+000,-9.207408341201e+001,2.801874517693e+001
    1290,-1.937501046250e+000,-9.677059496471e+001,9.063327045925e+000
    1291,-1.937501046250e+000,-9.300481472581e+001,4.574749926674e+001
    1292,-1.937501046250e+000,-9.607944980078e+001,1.876203235409e+001
    1293,-1.937501046250e+000,-9.155399697299e+001,1.896019798184e+001
    1294,-1.937501046250e+000,-9.088825126278e+001,4.559435115097e+001
    1295,-1.937501046250e+000,-9.511289061072e+001,2.727784177460e+001
    1296,-1.937501046250e+000,-9.159340340975e+001,8.957532571523e+000
    1297,-1.937501046250e+000,-9.380236833134e+001,2.730207277167e+001
    1298,-1.937501046250e+000,-9.327495721109e+001,3.842539994268e+001
    1299,-1.937501046250e+000,-9.092498493367e+001,1.881223639795e+001
    1300,-1.937501046250e+000,-9.435498167932e+001,2.766821255455e+001
    1301,-1.937501046250e+000,-9.494222183414e+001,1.880606698246e+001
    1302,-1.937501046250e+000,-9.573297939199e+001,2.650442849337e+001
    1303,-1.937501046250e+000,-9.108569617190e+001,8.637004378785e+000
    1304,-1.937501046250e+000,-9.406551793616e+001,2.795248264361e+001
    1305,-1.937501046250e+000,-9.244918605370e+001,8.240915516669e+000
    1306,-1.937501046250e+000,-9.650580566099e+001,5.274075118722e+000
    1307,-1.937501046250e+000,-9.618814950548e+001,6.506756442508e+000
    1308,-1.937501046250e+000,-9.622047827440e+001,7.723877273084e+000
    1309,-1.937501046250e+000,-9.211147060999e+001,3.991804220308e+001
    1310,-1.937501046250e+000,-9.171140933579e+001,4.438658961063e+001
    1311,-1.937501046250e+000,-9.182691781682e+001,3.808524208122e+001
    1312,-1.937501046250e+000,-9.485842272746e+001,2.784887066740e+001
    1313,-1.937501046250e+000,-9.259289310136e+001,3.804649009263e+001
    1314,-1.937501046250e+000,-9.390618231266e+001,2.762573609730e+001
    1315,-1.937501046250e+000,-9.168809138145e+001,3.562977243906e+000
    1316,-1.937501046250e+000,-9.226041654614e+001,3.608372843082e+000
    1317,-1.937501046250e+000,-9.289142567954e+001,3.682780395504e+000
    1318,-1.937501046250e+000,-9.363702770080e+001,3.822489667365e+000
    1319,-1.937501046250e+000,-9.433107197331e+001,3.690416057490e+000
    1320,-1.937501046250e+000,-9.506283274015e+001,3.750298462071e+000
    1321,-1.937501046250e+000,-9.567111803527e+001,3.624068344134e+000
    1322,-1.937501046250e+000,-9.626709061095e+001,3.707205004680e+000
    1323,-1.937501046250e+000,-9.691701023636e+001,4.081733178227e+000
    1324,-1.937501046250e+000,-9.447474428379e+001,3.634855837703e+001
    1325,-1.937501046250e+000,-9.469558721723e+001,8.114866359947e+000
    1326,-1.937501046250e+000,-9.630411533940e+001,1.814433357589e+001
    1327,-1.937501046250e+000,-9.403879077168e+001,7.983964125879e+000
    1328,-1.937501046250e+000,-9.114598425045e+001,7.964063075680e+000
    1329,-1.937501046250e+000,-9.121922882459e+001,7.270203767880e+000
    1330,-1.937501046250e+000,-9.135999642158e+001,6.472080122981e+000
    1331,-1.937501046250e+000,-9.147149198888e+001,5.603863599107e+000
    1332,-1.937501046250e+000,-9.127873087763e+001,4.751990346569e+000
    1333,-1.937501046250e+000,-9.107003360879e+001,3.847311711969e+000
    1334,-1.937501046250e+000,-9.107917055711e+001,2.771880625855e+001
    1335,-1.937501046250e+000,-9.041113709807e+001,3.601997761293e+001
    1336,-1.937501046250e+000,-9.319379554602e+001,8.101680807487e+000
    1337,-1.937501046250e+000,-9.172449642998e+001,8.402425423983e+000
    1338,-1.937501046250e+000,-9.326731652353e+001,3.773812640575e+001
    1339,-1.937501046250e+000,-9.169008669891e+001,4.110434968531e+001
    1340,-1.937501046250e+000,-9.591175714401e+001,8.518601406768e+000
    1341,-1.937501046250e+000,-9.649940060896e+001,8.513857209717e+000
    1342,-1.937501046250e+000,-9.215093685432e+001,3.885737202243e+001
    1343,-1.937501046250e+000,-9.142270399414e+001,4.338481379628e+001
    1344,-1.937501046250e+000,-9.541409917216e+001,8.142255845979e+000
    1345,-1.937501046250e+000,-9.123821190089e+001,3.783494561654e+001
    1346,-1.937501046250e+000,-9.512662866582e+001,5.644838772245e+000
    1347,-1.937501046250e+000,-9.495777741324e+001,7.105651062718e+000
    1348,-1.937501046250e+000,-9.250754174556e+001,4.279656460780e+000
    1349,-1.937501046250e+000,-9.317837567731e+001,4.427527943687e+000
    1350,-1.937501046250e+000,-9.394131771626e+001,4.854333991592e+000
    1351,-1.937501046250e+000,-9.484043782900e+001,4.549917219243e+000
    1352,-1.937501046250e+000,-9.580418903137e+001,4.499499789611e+000
    1353,-1.937501046250e+000,-9.186760605828e+001,7.719194984210e+000
    1354,-1.937501046250e+000,-9.204843326194e+001,6.964849401695e+000
    1355,-1.937501046250e+000,-9.265515371791e+001,7.544136741778e+000
    1356,-1.937501046250e+000,-9.183431507729e+001,4.279213314017e+000
    1357,-1.937501046250e+000,-9.376980253880e+001,5.926373491619e+000
    1358,-1.937501046250e+000,-9.237067348914e+001,6.049843225470e+000
    1359,-1.937501046250e+000,-9.372719684298e+001,7.198463753130e+000
    1360,-1.937501046250e+000,-9.255194638779e+001,5.107882821246e+000
    1361,-1.937501046250e+000,-9.290867978734e+001,6.652251651836e+000
    1362,-2.187501181250e+000,-9.867983365209e+001,2.675242938037e+000
    1363,-2.187501181250e+000,-9.804383725212e+001,2.430657534662e+000
    1364,-2.187501181250e+000,-9.743347330120e+001,2.502052776000e+000
    1365,-2.187501181250e+000,-9.684779724170e+001,2.475794178096e+000
    1366,-2.187501181250e+000,-9.627339686660e+001,2.449535532699e+000
    1367,-2.187501181250e+000,-9.566304469390e+001,2.418217407237e+000
    1368,-2.187501181250e+000,-9.506738532692e+001,2.427895788318e+000
    1369,-2.187501181250e+000,-9.449016792002e+001,2.445073530011e+000
    1370,-2.187501181250e+000,-9.392843080688e+001,2.451155105030e+000
    1371,-2.187501181250e+000,-9.328504888388e+001,2.441358364696e+000
    1372,-2.187501181250e+000,-9.270578666094e+001,2.441229802496e+000
    1373,-2.187501181250e+000,-9.214042711559e+001,2.432919002957e+000
    1374,-2.187501181250e+000,-9.159058781029e+001,2.404195933888e+000
    1375,-2.187501181250e+000,-9.096168048515e+001,2.411271176068e+000
    1376,-2.187501181250e+000,-9.046237489852e+001,2.408727121773e+000
    1377,-2.187501181250e+000,-9.853361936179e+001,3.638582330164e+000
    1378,-2.187501181250e+000,-9.805602309265e+001,5.460150479437e+000
    1379,-2.187501181250e+000,-9.781843520137e+001,7.558392180491e+000
    1380,-2.187501181250e+000,-9.750994926338e+001,9.024373503225e+000
    1381,-2.187501181250e+000,-9.749801274745e+001,1.118145498641e+001
    1382,-2.187501181250e+000,-9.682995107467e+001,1.553868584520e+001
    1383,-2.187501181250e+000,-9.692034456211e+001,1.752086125515e+001
    1384,-2.187501181250e+000,-9.647348742781e+001,1.912602397299e+001
    1385,-2.187501181250e+000,-9.599739354758e+001,2.225108012924e+001
    1386,-2.187501181250e+000,-9.551421977540e+001,2.605081001478e+001
    1387,-2.187501181250e+000,-9.521301159305e+001,2.744538694260e+001
    1388,-2.187501181250e+000,-9.527194471498e+001,2.962410466280e+001
    1389,-2.187501181250e+000,-9.475291797297e+001,3.118585080471e+001
    1390,-2.187501181250e+000,-9.404129985071e+001,3.577143826955e+001
    1391,-2.187501181250e+000,-9.400982662272e+001,3.760937164396e+001
    1392,-2.187501181250e+000,-9.373342619386e+001,3.949164102976e+001
    1393,-2.187501181250e+000,-9.328519471546e+001,4.112038994635e+001
    1394,-2.187501181250e+000,-9.315677030586e+001,4.328985635707e+001
    1395,-2.187501181250e+000,-9.306599117785e+001,4.513588665837e+001
    1396,-2.187501181250e+000,-9.325546322594e+001,4.621472396019e+001
    1397,-2.187501181250e+000,-9.318966776209e+001,4.650669238684e+001
    1398,-2.187501181250e+000,-9.280390745639e+001,4.623655758304e+001
    1399,-2.187501181250e+000,-9.151000989515e+001,4.620032532856e+001
    1400,-2.187501181250e+000,-9.038175564861e+001,4.624738114613e+001
    1401,-2.187501181250e+000,-8.988260555365e+001,4.631764489397e+001
    1402,-2.187501181250e+000,-9.006972516138e+001,4.503408330939e+001
    1403,-2.187501181250e+000,-9.017937907187e+001,4.354747438919e+001
    1404,-2.187501181250e+000,-9.021250074387e+001,4.204746485377e+001
    1405,-2.187501181250e+000,-9.017598567350e+001,4.119198741859e+001
    1406,-2.187501181250e+000,-9.014436115493e+001,3.972946901517e+001
    1407,-2.187501181250e+000,-9.040842843514e+001,3.815584899842e+001
    1408,-2.187501181250e+000,-9.024933927712e+001,3.660743496797e+001
