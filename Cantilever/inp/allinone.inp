    9857,-2.062501113750e+000,-9.165464128506e+001,4.612690910573e+001
    9858,-2.062501113750e+000,-9.134433597592e+001,4.617706792574e+001
    9859,-3.595702677457e+000,-8.937504826250e+001,1.932839693575e+001
    9860,-3.333278221478e+000,-8.937504826250e+001,1.919774969485e+001
    9861,-3.646077654611e+000,-8.937504826250e+001,1.905919925970e+001
    9862,-2.062501113750e+000,-9.776256964660e+001,1.089872914468e+001
    9863,-3.377622414543e+000,-8.937504826250e+001,1.945995349185e+001
    9864,-2.062501113750e+000,-9.040864226643e+001,4.414545775393e+001
    9865,-2.062501113750e+000,-9.089815718832e+001,4.408705773451e+001
    9866,-2.062501113750e+000,-9.188438351182e+001,4.499113710455e+001
    9867,-2.062501113750e+000,-9.238982422656e+001,4.644385587277e+001
    9868,-2.062501113750e+000,-9.063230954937e+001,2.873970599218e+001
    9869,-2.062501113750e+000,-9.084859213933e+001,2.871732843319e+001
    9870,-2.062501113750e+000,-9.074214788174e+001,2.847343840046e+001
    9871,-2.062501113750e+000,-9.442342205875e+001,2.713920788439e+001
    9872,-3.613969717166e+000,-8.937504826250e+001,1.762451412224e+001
    9873,-3.690877062622e+000,-8.937504826250e+001,2.618148664656e+001
    9874,-3.644427396539e+000,-8.937504826250e+001,2.592244200990e+001
    9875,-3.381637580300e+000,-8.937504826250e+001,2.604527983103e+001
    9876,-3.335187914217e+000,-8.937504826250e+001,2.578623519437e+001
    9877,-3.626017254758e+000,-9.861271578420e+001,9.823731237439e+000
    9878,-2.062501113750e+000,-9.043226405198e+001,2.890629477227e+001
    9879,-2.062501113750e+000,-9.054210238435e+001,2.864002718056e+001
    9880,-2.683372795153e+000,-8.937504826250e+001,1.084283603029e+001
    9881,-2.681950340808e+000,-8.937504826250e+001,1.120012810885e+001
    9882,-2.062501113750e+000,-8.972357112002e+001,3.202928428911e+001
    9883,-3.031415020239e+000,-8.937504826250e+001,3.095882118126e+001
    9884,-3.323397850986e+000,-8.937504826250e+001,3.114324148713e+001
    9885,-3.022739806730e+000,-8.937504826250e+001,3.128674729137e+001
    9886,-2.677431979101e+000,-8.937504826250e+001,2.325711545652e+001
    9887,-3.665663231384e+000,-8.937504826250e+001,6.195454992623e+000
    9888,-3.039496415218e+000,-8.937504826250e+001,3.064324314095e+001
    9889,-3.343252653832e+000,-8.937504826250e+001,3.054011034987e+001
    9890,-3.335171258853e+000,-8.937504826250e+001,3.085568839018e+001
    9891,-3.391539428168e+000,-8.937504826250e+001,4.338860908253e+001
    9892,-2.062501113750e+000,-9.317082078617e+001,3.689124123282e+001
    9893,-2.062501113750e+000,-9.332221348610e+001,3.677918048159e+001
    9894,-2.062501113750e+000,-9.338769899738e+001,3.701320642115e+001
    9895,-2.062501113750e+000,-9.353909169730e+001,3.690114566991e+001
    9896,-2.394655726360e+000,-8.937504826250e+001,3.018196722048e+001
    9897,-2.062501113750e+000,-8.937504826250e+001,3.032595124529e+001
    9898,-2.862660139485e+000,-9.371751370366e+001,4.653774684147e+001
    9899,-2.725729417199e+000,-9.374212872435e+001,4.635313418632e+001
    9900,-2.062501113750e+000,-8.967997801658e+001,2.719791452405e+001
    9901,-2.062501113750e+000,-8.937504826250e+001,2.743549347453e+001
    9902,-2.062501113750e+000,-8.967997801658e+001,2.679459483510e+001
    9903,-2.062501113750e+000,-8.937504826250e+001,2.703217378559e+001
    9904,-3.691410408694e+000,-8.937504826250e+001,4.328762729041e+001
    9905,-2.062501113750e+000,-9.211549133425e+001,3.800352813098e+001
    9906,-2.062501113750e+000,-9.227750085300e+001,3.838959310159e+001
    9907,-2.062501113750e+000,-9.168568164291e+001,3.833741821221e+001
    9908,-2.062501113750e+000,-9.184769116166e+001,3.872348318281e+001
    9909,-2.062501113750e+000,-9.192986309607e+001,7.171788187032e+000
    9910,-2.062501113750e+000,-9.151526087739e+001,7.324465370125e+000
    9911,-2.062501113750e+000,-9.132074445938e+001,4.133086111176e+001
    9912,-2.062501113750e+000,-9.133560392705e+001,4.092857050374e+001
    9913,-2.062501113750e+000,-9.010436056213e+001,1.200438045287e+001
    9914,-2.062501113750e+000,-9.024257120576e+001,1.164504300206e+001
    9915,-2.062501113750e+000,-9.039972435055e+001,1.193169344089e+001
    9916,-2.062501113750e+000,-9.375553914813e+001,1.795966448938e+001
    9917,-2.062501113750e+000,-9.387166214655e+001,1.813916988343e+001
    9918,-2.062501113750e+000,-9.363465034807e+001,1.819146467189e+001
    9919,-2.062501113750e+000,-8.993805172765e+001,4.625631284245e+001
    9920,-2.062501113750e+000,-9.018762677513e+001,4.622118096853e+001
    9921,-2.062501113750e+000,-9.002877326811e+001,4.647250301796e+001
    9922,-2.062501113750e+000,-9.553531424285e+001,1.983999416178e+001
    9923,-2.062501113750e+000,-9.563501365174e+001,1.961266511056e+001
    9924,-2.062501113750e+000,-9.537092342149e+001,1.966210442061e+001
    9925,-2.062501113750e+000,-9.247487291417e+001,4.445682803097e+001
    9926,-2.062501113750e+000,-9.004079523765e+001,4.390292001046e+001
    9927,-2.062501113750e+000,-8.970112986671e+001,4.402535657891e+001
    9928,-2.062501113750e+000,-9.004141807715e+001,4.427165578212e+001
    9929,-2.062501113750e+000,-9.004707031876e+001,4.314358489011e+001
    9930,-3.345888161404e+000,-8.937504826250e+001,1.465199129737e+001
    9931,-3.645005813282e+000,-8.937504826250e+001,1.477425392903e+001
    9932,-3.401784900214e+000,-8.937504826250e+001,1.492269525448e+001
    9933,-2.062501113750e+000,-8.969047461548e+001,4.365209177375e+001
    9934,-2.062501113750e+000,-9.533123573814e+001,1.984952088260e+001
    9935,-2.062501113750e+000,-9.546643264900e+001,2.001896720878e+001
    9936,-2.062501113750e+000,-9.451052763206e+001,2.833850360428e+001
    9937,-2.062501113750e+000,-9.029507242361e+001,2.163738040730e+001
    9938,-2.062501113750e+000,-9.032898335350e+001,2.187486917305e+001
    9939,-2.062501113750e+000,-9.201832883679e+001,1.833273422574e+001
    9940,-2.062501113750e+000,-9.180830752751e+001,1.830346051583e+001
    9941,-2.062501113750e+000,-9.000299839604e+001,2.113416778854e+001
    9942,-2.062501113750e+000,-9.008675862520e+001,2.083743918497e+001
    9943,-2.062501113750e+000,-8.971686281912e+001,2.092460105487e+001
    9944,-2.062501113750e+000,-9.699391904124e+001,1.235521570363e+001
    9945,-2.062501113750e+000,-9.773050015576e+001,1.250564014052e+001
    9946,-2.062501113750e+000,-9.683933191368e+001,1.210966406292e+001
    9947,-2.062501113750e+000,-9.757591302820e+001,1.226008849981e+001
    9948,-3.647909684616e+000,-9.419118466321e+001,4.298521464486e+001
    9949,-2.062501113750e+000,-9.562359958370e+001,2.627761925408e+001
    9950,-2.062501113750e+000,-9.539144927184e+001,2.621183326663e+001
    9951,-2.062501113750e+000,-9.561107693683e+001,2.661015727944e+001
    9952,-2.062501113750e+000,-9.537892662497e+001,2.654437129199e+001
    9953,-2.677272177723e+000,-8.937504826250e+001,5.615126411311e+000
    9954,-2.389901804929e+000,-8.937504826250e+001,5.476694406773e+000
    9955,-2.062501113750e+000,-9.357407002138e+001,9.503024231670e+000
    9956,-2.062501113750e+000,-9.347274994940e+001,9.268533844546e+000
    9957,-2.062501113750e+000,-9.356129679741e+001,3.607635314256e+001
    9958,-2.062501113750e+000,-9.372168595181e+001,3.602332201036e+001
    9959,-3.044846150618e+000,-8.937504826250e+001,9.788571859865e+000
    9960,-2.743286571557e+000,-8.937504826250e+001,9.641323717914e+000
    9961,-3.342385973519e+000,-8.937504826250e+001,9.482113756518e+000
    9962,-3.040826394459e+000,-8.937504826250e+001,9.334865614567e+000
    9963,-2.062501113750e+000,-8.937504826250e+001,8.232994950992e+000
    9964,-2.062501113750e+000,-8.937504826250e+001,8.591501341163e+000
    9965,-2.381217788223e+000,-8.937504826250e+001,8.380947725830e+000
    9966,-2.062501113750e+000,-9.725088677160e+001,2.206180350994e+000
    9967,-2.062501113750e+000,-9.740710774799e+001,2.488843502189e+000
    9968,-2.062501113750e+000,-9.752481295638e+001,2.219389624806e+000
    9969,-3.591878542703e+000,-8.937504826250e+001,8.168324607638e+000
    9970,-3.326372425821e+000,-8.937504826250e+001,8.068224835902e+000
    9971,-3.642995993709e+000,-8.937504826250e+001,7.908828685399e+000
    9972,-2.062501113750e+000,-9.666984404259e+001,5.529184317292e+000
    9973,-2.062501113750e+000,-9.711248490447e+001,5.920505739810e+000
    9974,-2.062501113750e+000,-9.651101596484e+001,6.145524979185e+000
    9975,-2.062501113750e+000,-9.036336973975e+001,4.102937113776e+001
    9976,-2.062501113750e+000,-9.075107801292e+001,4.121206369757e+001
    9977,-2.062501113750e+000,-9.040585390670e+001,4.140539486009e+001
    9978,-2.062501113750e+000,-9.079356217988e+001,4.158808741989e+001
    9979,-2.062501113750e+000,-9.261445128100e+001,3.689665145213e+001
    9980,-2.062501113750e+000,-9.276465038680e+001,3.687429535343e+001
    9981,-2.062501113750e+000,-9.270891292811e+001,3.703631962381e+001
    9982,-2.062501113750e+000,-9.285911203391e+001,3.701396352511e+001
    9983,-2.062501113750e+000,-8.967047909297e+001,2.014252566165e+001
    9984,-2.062501113750e+000,-8.967047909297e+001,2.054584535060e+001
    9985,-2.449753634790e+000,-8.937504826250e+001,1.023059123298e+001
    9986,-2.393615388262e+000,-8.937504826250e+001,1.064266310747e+001
    9987,-2.062501113750e+000,-9.642299508525e+001,2.743596426384e+000
    9988,-2.062501113750e+000,-9.626433662584e+001,2.460009729862e+000
    9989,-2.062501113750e+000,-9.612643447196e+001,2.708767979296e+000
    9990,-3.046601073382e+000,-8.937504826250e+001,1.876870801769e+001
    9991,-3.033732384803e+000,-8.937504826250e+001,1.907199119733e+001
    9992,-2.689026291041e+000,-8.937504826250e+001,1.887733417975e+001
    9993,-2.062501113750e+000,-9.407700124211e+001,2.809448737485e+001
    9994,-2.062501113750e+000,-9.388168158675e+001,2.807791887874e+001
    9995,-2.062501113750e+000,-9.397354717239e+001,2.787604332309e+001
    9996,-3.329457477043e+000,-8.937504826250e+001,7.757212786151e+000
    9997,-2.062501113750e+000,-9.602257345156e+001,1.856410212965e+001
    9998,-2.062501113750e+000,-9.633266767879e+001,1.848732961100e+001
    9999,-2.062501113750e+000,-9.627646861429e+001,1.894402816354e+001
   10000,-2.062501113750e+000,-9.037115276798e+001,2.374939492074e+001
   10001,-2.062501113750e+000,-9.078025595808e+001,2.377843009593e+001
   10002,-2.062501113750e+000,-9.073361213570e+001,2.353571548348e+001
   10003,-3.638048871972e+000,-8.937504826250e+001,2.534055655906e+001
   10004,-2.062501113750e+000,-9.515069013739e+001,2.637252492033e+001
   10005,-2.710399845214e+000,-8.937504826250e+001,2.220843044566e+001
   10006,-3.063273102522e+000,-8.937504826250e+001,2.205434536819e+001
   10007,-2.719930112290e+000,-8.937504826250e+001,3.898829683758e+001
   10008,-3.062964597226e+000,-8.937504826250e+001,3.917087511320e+001
   10009,-2.691571582681e+000,-8.937504826250e+001,3.937377437965e+001
   10010,-3.349328701232e+000,-8.937504826250e+001,1.055750054824e+001
   10011,-3.396889157325e+000,-8.937504826250e+001,1.029679093301e+001
   10012,-3.085768633522e+000,-8.937504826250e+001,1.028536140331e+001
   10013,-3.030359430022e+000,-8.937504826250e+001,2.566292448334e+001
   10014,-3.027601391486e+000,-8.937504826250e+001,2.535104135009e+001
   10015,-2.675556118293e+000,-8.937504826250e+001,2.550415518955e+001
   10016,-2.062501113750e+000,-8.969844772974e+001,2.795922328519e+001
   10017,-2.062501113750e+000,-8.968151507045e+001,2.831561196848e+001
   10018,-2.062501113750e+000,-8.937504826250e+001,2.815250625487e+001
   10019,-2.062501113750e+000,-9.096573663372e+001,8.515608710482e+000
   10020,-2.062501113750e+000,-9.089705749303e+001,8.813513778428e+000
   10021,-2.062501113750e+000,-9.066335773922e+001,9.535396151190e+000
   10022,-2.062501113750e+000,-9.077308929461e+001,9.742022719557e+000
   10023,-2.062501113750e+000,-9.091802150053e+001,9.598857663326e+000
   10024,-2.062501113750e+000,-8.937504826250e+001,3.438155478410e+001
   10025,-2.062501113750e+000,-8.972644805751e+001,3.460221836822e+001
   10026,-2.398677640184e+000,-8.937504826250e+001,3.541363330736e+001
   10027,-2.727708063109e+000,-8.937504826250e+001,3.520818470257e+001
   10028,-3.353400319100e+000,-8.937504826250e+001,2.458533824196e+001
   10029,-3.373606086248e+000,-8.937504826250e+001,3.407409308215e+000
   10030,-3.439002363594e+000,-8.937504826250e+001,3.176285169294e+000
   10031,-3.611137515425e+000,-8.937504826250e+001,3.327708386316e+000
   10032,-3.596917804423e+000,-8.937504826250e+001,4.468420228533e+001
   10033,-3.377445988963e+000,-8.937504826250e+001,4.481226547675e+001
   10034,-3.689030295131e+000,-8.937504826250e+001,4.497352323864e+001
   10035,-2.062501113750e+000,-9.319886948598e+001,8.408630275807e+000
   10036,-2.062501113750e+000,-9.292175936220e+001,2.198287592732e+000
   10037,-2.688604268976e+000,-8.937504826250e+001,9.255001246001e+000
   10038,-2.395071332209e+000,-8.937504826250e+001,9.060036032568e+000
   10039,-2.395071332209e+000,-8.937504826250e+001,9.440949072125e+000
   10040,-3.334087497704e+000,-8.937504826250e+001,3.175132537485e+001
   10041,-3.640325488530e+000,-8.937504826250e+001,3.157425117651e+001
   10042,-3.640325488530e+000,-8.937504826250e+001,3.188794426791e+001
   10043,-2.062501113750e+000,-9.346253653556e+001,3.848308848800e+001
   10044,-2.062501113750e+000,-9.325367815722e+001,3.810283783260e+001
   10045,-3.341488129092e+000,-8.937504826250e+001,2.744858961968e+001
   10046,-3.635518066498e+000,-8.937504826250e+001,2.731126715236e+001
   10047,-3.614472173184e+000,-8.937504826250e+001,2.757281594185e+001
   10048,-2.395291351107e+000,-8.937504826250e+001,2.832735968760e+001
   10049,-2.062501113750e+000,-8.937504826250e+001,2.848860599566e+001
   10050,-2.062501113750e+000,-9.101390580622e+001,2.675403290380e+001
   10051,-2.062501113750e+000,-9.117166720975e+001,2.687788637504e+001
   10052,-2.062501113750e+000,-9.078152394321e+001,2.691588012190e+001
   10053,-2.062501113750e+000,-9.093928534675e+001,2.703973359314e+001
   10054,-2.062501113750e+000,-9.091101590777e+001,4.590599792368e+001
   10055,-2.062501113750e+000,-9.446339211032e+001,9.534290631738e+000
   10056,-2.062501113750e+000,-9.475239150291e+001,9.534290631738e+000
   10057,-2.449753634790e+000,-8.937504826250e+001,9.827271544038e+000
   10058,-2.781144593374e+000,-8.937504826250e+001,1.003722893867e+001
   10059,-2.062501113750e+000,-9.034306884391e+001,1.667832763804e+001
   10060,-2.062501113750e+000,-9.002679867334e+001,1.678347252861e+001
   10061,-3.651851123347e+000,-8.937504826250e+001,3.328622974645e+001
   10062,-3.651851123347e+000,-8.937504826250e+001,3.357751618846e+001
   10063,-2.062501113750e+000,-8.984257702350e+001,4.653383506948e+001
   10064,-3.611381950365e+000,-9.382484380182e+001,4.573277110532e+001
   10065,-3.165797099946e+000,-9.383856699965e+001,4.562984712157e+001
   10066,-3.462917260171e+000,-9.386104280161e+001,4.546127860684e+001
   10067,-3.344888982497e+000,-8.937504826250e+001,1.571526015988e+001
   10068,-3.401602558226e+000,-8.937504826250e+001,1.544368510053e+001
   10069,-3.077696322597e+000,-8.937504826250e+001,1.546927765949e+001
   10070,-3.134409898325e+000,-8.937504826250e+001,1.519770260014e+001
   10071,-2.062501113750e+000,-9.184172400623e+001,4.579364044031e+001
   10072,-2.062501113750e+000,-9.181385719533e+001,4.738106983735e+000
   10073,-2.062501113750e+000,-9.170183009275e+001,4.245588842651e+000
   10074,-2.062501113750e+000,-9.211764489386e+001,4.365925452109e+000
   10075,-2.720772499533e+000,-8.937504826250e+001,1.266991488496e+001
   10076,-2.062501113750e+000,-9.096453754547e+001,4.206309271352e+000
   10077,-2.062501113750e+000,-9.131968935850e+001,4.029638041627e+000
   10078,-2.062501113750e+000,-9.090957119283e+001,3.829406635965e+000
   10079,-2.062501113750e+000,-9.336198353666e+001,4.299000576718e+001
   10080,-2.062501113750e+000,-9.896184821801e+001,7.205237983847e+000
   10081,-3.011137856543e+000,-9.553109496913e+001,3.293588735044e+001
   10082,-3.077222109513e+000,-9.548498445948e+001,3.328171617287e+001
   10083,-3.518639759436e+000,-9.551328052105e+001,3.306949571108e+001
   10084,-3.584724012407e+000,-9.546717001139e+001,3.341532453351e+001
   10085,-3.335458640112e+000,-8.937504826250e+001,1.314289602880e+001
   10086,-3.035830898528e+000,-8.937504826250e+001,1.323206905906e+001
   10087,-3.608915951260e+000,-8.937504826250e+001,1.273610640570e+001
   10088,-3.695026946059e+000,-8.937504826250e+001,3.301905077712e+001
   10089,-3.334136161749e+000,-8.937504826250e+001,5.815833786352e+000
   10090,-3.392437635796e+000,-8.937504826250e+001,6.086203765904e+000
   10091,-3.642502080308e+000,-8.937504826250e+001,6.508251353286e+000
   10092,-2.062501113750e+000,-9.073799605652e+001,3.010197195025e+001
   10093,-2.062501113750e+000,-9.046295596663e+001,3.021014235613e+001
   10094,-2.062501113750e+000,-9.072500905012e+001,3.035568673953e+001
   10095,-2.395546447209e+000,-9.646527818298e+001,2.592951324657e+001
   10096,-2.062501113750e+000,-9.650771231973e+001,2.561125722097e+001
   10097,-2.062501113750e+000,-9.247020218603e+001,7.771867826964e+000
   10098,-2.062501113750e+000,-9.272867072542e+001,8.109697745763e+000
   10099,-2.062501113750e+000,-9.283165455753e+001,7.761308358318e+000
   10100,-2.062501113750e+000,-9.207642835622e+001,7.859396948179e+000
   10101,-2.062501113750e+000,-9.672376405255e+001,1.735583872765e+001
   10102,-2.062501113750e+000,-9.667848335220e+001,1.702795497552e+001
   10103,-2.062501113750e+000,-9.653106092527e+001,1.723278233837e+001
   10104,-2.062501113750e+000,-9.310097547159e+001,8.040080391173e+000
   10105,-2.062501113750e+000,-9.341876856322e+001,8.137184292049e+000
   10106,-2.062501113750e+000,-9.352143680518e+001,7.754062197859e+000
   10107,-2.062501113750e+000,-9.061423305223e+001,4.131982040543e+000
   10108,-2.062501113750e+000,-9.056107264739e+001,3.748779173425e+000
   10109,-3.649342007832e+000,-8.937504826250e+001,2.362767127532e+001
   10110,-3.664942333371e+000,-8.937504826250e+001,2.391334921726e+001
   10111,-2.062501113750e+000,-9.498656819711e+001,1.964921651121e+001
   10112,-2.062501113750e+000,-9.484752637861e+001,1.962248707203e+001
   10113,-2.062501113750e+000,-9.558965928513e+001,9.378924351702e+000
   10114,-2.062501113750e+000,-9.570606798469e+001,9.195081256412e+000
   10115,-2.062501113750e+000,-9.577754741645e+001,9.395122251321e+000
   10116,-3.644427396539e+000,-8.937504826250e+001,2.563115556789e+001
   10117,-2.606032161032e+000,-8.937504826250e+001,3.229862969120e+000
   10118,-2.858091504548e+000,-8.937504826250e+001,3.274148124690e+000
   10119,-2.687693147521e+000,-8.937504826250e+001,3.560020701784e+000
   10120,-3.064734723861e+000,-8.937504826250e+001,1.944743370377e+001
   10121,-2.715701794982e+000,-8.937504826250e+001,1.960020547361e+001
   10122,-2.062501113750e+000,-9.333691386569e+001,2.818318280915e+001
   10123,-2.062501113750e+000,-9.352117127093e+001,2.828201292886e+001
   10124,-2.062501113750e+000,-9.348847419763e+001,2.801040669083e+001
   10125,-2.062501113750e+000,-9.367273160287e+001,2.810923681054e+001
   10126,-3.042508235385e+000,-8.937504826250e+001,2.045557595677e+001
   10127,-3.695026946059e+000,-8.937504826250e+001,3.272776433511e+001
   10128,-2.062501113750e+000,-9.038356942839e+001,1.256599522011e+001
   10129,-2.062501113750e+000,-9.037649199100e+001,1.289939462488e+001
   10130,-2.062501113750e+000,-9.073292439684e+001,1.279518825821e+001
   10131,-2.062501113750e+000,-9.066919940486e+001,4.508884675930e+000
   10132,-3.591228667165e+000,-8.937504826250e+001,4.484859866099e+000
   10133,-3.317078553677e+000,-8.937504826250e+001,4.315699969781e+000
   10134,-3.313766869795e+000,-8.937504826250e+001,4.610584800855e+000
   10135,-2.062501113750e+000,-9.337454803741e+001,1.821081282691e+001
   10136,-2.062501113750e+000,-9.354219699568e+001,1.847728118006e+001
   10137,-2.062501113750e+000,-9.168048437609e+001,3.704710322939e+001
   10138,-2.062501113750e+000,-9.163004634923e+001,3.688244516792e+001
   10139,-2.062501113750e+000,-9.344637586850e+001,1.928279865480e+001
   10140,-2.062501113750e+000,-9.327893310180e+001,1.902040517769e+001
   10141,-2.062501113750e+000,-9.314199548766e+001,1.929052351143e+001
   10142,-2.062501113750e+000,-9.074388636215e+001,2.926258732191e+001
   10143,-2.062501113750e+000,-9.090738150830e+001,2.924754881683e+001
   10144,-2.062501113750e+000,-9.619173661567e+001,1.719027612515e+001
   10145,-2.062501113750e+000,-9.608428109951e+001,1.705993595154e+001
   10146,-2.062501113750e+000,-9.604768302347e+001,1.722947219720e+001
   10147,-2.062501113750e+000,-8.966503897865e+001,4.474026960458e+001
   10148,-2.062501113750e+000,-9.000532718909e+001,4.462806241761e+001
   10149,-2.062501113750e+000,-8.994987739434e+001,4.500263110606e+001
   10150,-2.062501113750e+000,-9.316404295427e+001,1.874678085697e+001
   10151,-2.062501113750e+000,-9.302710534014e+001,1.901689919071e+001
   10152,-2.062501113750e+000,-9.070430581103e+001,2.062520454360e+001
   10153,-2.062501113750e+000,-9.085888192086e+001,2.071018335258e+001
   10154,-2.062501113750e+000,-9.066554670739e+001,2.080008094873e+001
   10155,-2.062501113750e+000,-9.002190363322e+001,4.119791366386e+001
   10156,-2.062501113750e+000,-9.005876315986e+001,4.162007712494e+001
   10157,-2.062501113750e+000,-9.056530220773e+001,2.119766423639e+001
   10158,-2.062501113750e+000,-9.075846222027e+001,2.132071513004e+001
   10159,-2.062501113750e+000,-9.026470984923e+001,2.677731074661e+001
   10160,-2.062501113750e+000,-9.056919070638e+001,2.660279713301e+001
   10161,-3.067543085436e+000,-8.937504826250e+001,4.478389796711e+001
   10162,-3.387910159582e+000,-8.937504826250e+001,4.512662283131e+001
   10163,-2.062501113750e+000,-9.210592116164e+001,4.054933044679e+001
   10164,-2.062501113750e+000,-9.237573855338e+001,3.980593491758e+001
   10165,-2.062501113750e+000,-9.131951760200e+001,2.749717944022e+001
   10166,-2.062501113750e+000,-9.076955770280e+001,3.464212486785e+000
   10167,-2.062501113750e+000,-9.397289265909e+001,4.462240467577e+001
   10168,-3.635276515002e+000,-8.937504826250e+001,5.927892084474e+000
   10169,-3.607361757337e+000,-8.937504826250e+001,5.633798571057e+000
   10170,-2.062501113750e+000,-9.095294168081e+001,2.643932073768e+001
   10171,-2.062501113750e+000,-9.104794902185e+001,2.658570309828e+001
   10172,-2.062501113750e+000,-9.081789684758e+001,2.660938144498e+001
   10173,-2.062501113750e+000,-9.215267446208e+001,2.839423007808e+001
   10174,-2.062501113750e+000,-9.305864051448e+001,2.450603538274e+000
   10175,-2.062501113750e+000,-9.321857922720e+001,2.189042419154e+000
   10176,-2.062501113750e+000,-9.169554142367e+001,6.405139032076e+000
   10177,-2.062501113750e+000,-9.220087995745e+001,6.194020583321e+000
   10178,-2.062501113750e+000,-8.937504826250e+001,1.343133760847e+001
   10179,-2.062501113750e+000,-8.985462728935e+001,2.814567696261e+000
   10180,-2.062501113750e+000,-8.959482218854e+001,2.680065868855e+000
   10181,-3.293028410081e+000,-9.372647044218e+001,4.647057130257e+001
   10182,-3.661141477015e+000,-9.372175646076e+001,4.650592616327e+001
   10183,-2.062501113750e+000,-9.090776230047e+001,2.641968923253e+001
   10184,-2.062501113750e+000,-9.075774160864e+001,2.640910986071e+001
   10185,-2.062501113750e+000,-9.073843860208e+001,2.620617711387e+001
   10186,-2.062501113750e+000,-9.321735905720e+001,4.662835881592e+001
   10187,-2.062501113750e+000,-9.306223397343e+001,4.662835881592e+001
   10188,-2.062501113750e+000,-9.314291184350e+001,4.648634148217e+001
   10189,-2.062501113750e+000,-9.465748087012e+001,8.767534137549e+000
   10190,-2.062501113750e+000,-9.496981532442e+001,8.513914884805e+000
   10191,-3.016873029486e+000,-8.937504826250e+001,4.428012253965e+000
   10192,-2.062501113750e+000,-9.722724876683e+001,5.347484709965e+000
   10193,-2.062501113750e+000,-9.548569840140e+001,4.029208711767e+000
   10194,-2.062501113750e+000,-9.518155575384e+001,4.092323770735e+000
   10195,-2.062501113750e+000,-9.848006632344e+001,3.328074965884e+000
   10196,-2.062501113750e+000,-9.821768700175e+001,3.726103782416e+000
   10197,-2.062501113750e+000,-9.817746185017e+001,3.095334648877e+000
   10198,-2.062501113750e+000,-9.791508252848e+001,3.493363465410e+000
   10199,-2.062501113750e+000,-9.610641583442e+001,4.643693435859e+000
   10200,-2.062501113750e+000,-9.555223389945e+001,4.466924434505e+000
   10201,-2.062501113750e+000,-9.595380395404e+001,4.291194190303e+000
   10202,-2.062501113750e+000,-9.134080377429e+001,9.126251516658e+000
   10203,-2.062501113750e+000,-9.150824107164e+001,8.939559974818e+000
   10204,-2.062501113750e+000,-9.154176100330e+001,9.215807641614e+000
   10205,-2.062501113750e+000,-9.772355523869e+001,5.758434221597e+000
   10206,-2.062501113750e+000,-9.783831910105e+001,5.185413191753e+000
   10207,-3.643672081555e+000,-8.937504826250e+001,1.299229091734e+001
   10208,-3.036662365292e+000,-9.375807832411e+001,4.623351218814e+001
   10209,-3.130275783997e+000,-9.371751370366e+001,4.653774684147e+001
   10210,-2.062501113750e+000,-9.425802206725e+001,3.605999832329e+001
   10211,-3.316914797950e+000,-8.937504826250e+001,5.215714489056e+000
   10212,-3.017131686115e+000,-8.937504826250e+001,5.072717887855e+000
   10213,-3.316125575623e+000,-8.937504826250e+001,4.919283380322e+000
   10214,-2.062501113750e+000,-9.320167387138e+001,3.749003943320e+001
   10215,-2.062501113750e+000,-9.303479922049e+001,3.757110895919e+001
   10216,-2.062501113750e+000,-9.391484673999e+001,3.913234962463e+001
   10217,-3.645977756835e+000,-8.937504826250e+001,3.956421597481e+001
   10218,-3.644026647073e+000,-8.937504826250e+001,3.985472804282e+001
   10219,-2.062501113750e+000,-9.463650284362e+001,3.964532829182e+001
   10220,-2.062501113750e+000,-9.544960686314e+001,7.445287934050e+000
   10221,-2.062501113750e+000,-9.533597009079e+001,6.852999490883e+000
   10222,-2.062501113750e+000,-9.362358631580e+001,2.692264391575e+001
   10223,-2.062501113750e+000,-9.412613991840e+001,2.686502307624e+001
   10224,-3.330376004444e+000,-8.937504826250e+001,4.001701330621e+001
   10225,-3.028694390842e+000,-9.880377685963e+001,8.390773171759e+000
   10226,-2.062501113750e+000,-9.581783300979e+001,2.177471940424e+000
   10227,-2.062501113750e+000,-9.567711760399e+001,2.439643641408e+000
   10228,-2.062501113750e+000,-9.612300909614e+001,2.193131003155e+000
   10229,-2.062501113750e+000,-9.598229369034e+001,2.455302704139e+000
   10230,-3.634351997102e+000,-8.937504826250e+001,4.165078061563e+000
   10231,-3.319816364948e+000,-8.937504826250e+001,4.007725665472e+000
   10232,-2.062501113750e+000,-9.261175301755e+001,4.618712204178e+001
   10233,-2.062501113750e+000,-9.249273116532e+001,4.589400166782e+001
   10234,-2.062501113750e+000,-9.226907539386e+001,3.950091018634e+000
   10235,-2.062501113750e+000,-9.473687973774e+001,3.601978636499e+001
   10236,-3.644026647073e+000,-8.937504826250e+001,4.014601448484e+001
   10237,-2.062501113750e+000,-9.147880966910e+001,3.784272713711e+001
   10238,-2.062501113750e+000,-9.116237771350e+001,3.768222195718e+001
   10239,-2.062501113750e+000,-9.761148669245e+001,9.606097096954e+000
   10240,-2.062501113750e+000,-9.738640746101e+001,9.769450868748e+000
   10241,-2.062501113750e+000,-9.730485059682e+001,9.519022872921e+000
   10242,-2.062501113750e+000,-9.080239775979e+001,1.872041991093e+001
   10243,-2.062501113750e+000,-9.048369118947e+001,1.893046494178e+001
   10244,-2.062501113750e+000,-9.082421860694e+001,1.905344823055e+001
   10245,-3.015140950471e+000,-9.868768674381e+001,9.261449040365e+000
   10246,-2.557558489311e+000,-9.871837966886e+001,9.031252102476e+000
   10247,-2.393444257858e+000,-9.864670517579e+001,9.568810800523e+000
   10248,-3.101567118663e+000,-8.937504826250e+001,2.700152244203e+001
   10249,-3.045067343638e+000,-8.937504826250e+001,2.672892524619e+001
   10250,-2.062501113750e+000,-9.139132868495e+001,3.821226997987e+001
   10251,-2.062501113750e+000,-9.177316262706e+001,3.796787536945e+001
   10252,-2.062501113750e+000,-9.187842784507e+001,1.863024736934e+001
   10253,-2.691923536610e+000,-8.937504826250e+001,4.007732069945e+001
   10254,-2.724449844428e+000,-8.937504826250e+001,4.047037184304e+001
   10255,-2.391560298434e+000,-8.937504826250e+001,4.026484123590e+001
   10256,-2.062501113750e+000,-9.708940494299e+001,1.057448007263e+001
   10257,-2.062501113750e+000,-9.695979490780e+001,1.050744622988e+001
   10258,-2.062501113750e+000,-9.868982557968e+001,9.245407771357e+000
   10259,-2.062501113750e+000,-8.937504826250e+001,3.886104970167e+000
   10260,-2.062501113750e+000,-9.152958646585e+001,2.847963783376e+001
   10261,-2.062501113750e+000,-9.136724981804e+001,2.833530688119e+001
   10262,-2.062501113750e+000,-9.555959701966e+001,8.302958612396e+000
   10263,-2.062501113750e+000,-9.567776774260e+001,7.963590325681e+000
   10264,-2.062501113750e+000,-9.523143421738e+001,8.211057818972e+000
   10265,-2.062501113750e+000,-9.196342738900e+001,9.060557546399e+000
   10266,-2.062501113750e+000,-9.580842600559e+001,8.491131392790e+000
   10267,-2.062501113750e+000,-9.588113007833e+001,8.743606876720e+000
   10268,-2.062501113750e+000,-9.609989801607e+001,8.538531836128e+000
   10269,-3.602612559953e+000,-9.959850571401e+001,2.430306763839e+000
   10270,-3.602612559953e+000,-9.955364285382e+001,2.766778215288e+000
   10271,-3.287141317576e+000,-9.958467999195e+001,2.533999679343e+000
   10272,-2.062501113750e+000,-9.165678900030e+001,1.850564260210e+001
   10273,-2.062501113750e+000,-9.164984232165e+001,1.960685210306e+001
   10274,-2.062501113750e+000,-9.152392460763e+001,1.962862450205e+001
   10275,-2.062501113750e+000,-9.673382747390e+001,1.576459458385e+001
   10276,-2.062501113750e+000,-9.702288534799e+001,1.595743817830e+001
   10277,-2.062501113750e+000,-9.664499964813e+001,1.609121833842e+001
   10278,-2.062501113750e+000,-9.693405752221e+001,1.628406193287e+001
   10279,-2.062501113750e+000,-9.349213270635e+001,1.798180976751e+001
   10280,-2.062501113750e+000,-9.698758471398e+001,9.595842405595e+000
   10281,-2.062501113750e+000,-9.712759823459e+001,9.788062544575e+000
   10282,-2.062501113750e+000,-9.686424665219e+001,9.818549281161e+000
   10283,-2.062501113750e+000,-9.700426017280e+001,1.001076942014e+001
   10284,-2.062501113750e+000,-9.629653680895e+001,3.025245503396e+000
   10285,-2.062501113750e+000,-9.659207127170e+001,3.069828148082e+000
   10286,-2.062501113750e+000,-9.456313027040e+001,1.923310455279e+001
   10287,-2.062501113750e+000,-9.461659677438e+001,1.943935625808e+001
   10288,-2.062501113750e+000,-9.442990391545e+001,1.942188579952e+001
   10289,-2.062501113750e+000,-9.492375183632e+001,1.896586906889e+001
   10290,-2.062501113750e+000,-9.473603858507e+001,1.891689938955e+001
   10291,-2.391476896355e+000,-9.755655233981e+001,1.774495707035e+001
   10292,-2.062501113750e+000,-9.753302130156e+001,1.792143985727e+001
   10293,-2.478053476187e+000,-9.749891728651e+001,1.817721997010e+001
   10294,-2.062501113750e+000,-9.443154096472e+001,1.854242108613e+001
   10295,-2.062501113750e+000,-9.453785158146e+001,1.878595431583e+001
   10296,-2.062501113750e+000,-9.617149237317e+001,1.927655326195e+001
   10297,-2.062501113750e+000,-9.679335748873e+001,1.520576135339e+001
   10298,-2.062501113750e+000,-9.671843730190e+001,1.547626963486e+001
   10299,-2.062501113750e+000,-9.705583303204e+001,1.549848501312e+001
   10300,-2.062501113750e+000,-9.536429305504e+001,1.946277573999e+001
   10301,-2.062501113750e+000,-9.441058348716e+001,1.877682991750e+001
   10302,-2.062501113750e+000,-9.451689410390e+001,1.902036314720e+001
   10303,-2.062501113750e+000,-9.698468058906e+001,1.912441036650e+001
   10304,-2.062501113750e+000,-9.661911604208e+001,1.920453234963e+001
   10305,-2.915001969770e+000,-9.693407967797e+001,2.241350203417e+001
   10306,-3.286292409093e+000,-9.694352589258e+001,2.234265542462e+001
   10307,-2.849373489924e+000,-9.698362270652e+001,2.204192932005e+001
   10308,-3.220663929247e+000,-9.699306892113e+001,2.197108271051e+001
   10309,-2.062501113750e+000,-9.269191867026e+001,2.695841684143e+001
   10310,-2.062501113750e+000,-9.673645393579e+001,9.636572591644e+000
   10311,-2.062501113750e+000,-9.676791486495e+001,9.345803961695e+000
   10312,-2.062501113750e+000,-9.699429639656e+001,9.316176122156e+000
   10313,-2.062501113750e+000,-9.714027211405e+001,9.043850274575e+000
   10314,-2.062501113750e+000,-9.745082631431e+001,9.246697025341e+000
   10315,-2.062501113750e+000,-9.599545720285e+001,1.737626399554e+001
   10316,-2.062501113750e+000,-9.429973482762e+001,4.266692048483e+000
   10317,-2.062501113750e+000,-9.384126617605e+001,8.078325951245e+000
   10318,-2.062501113750e+000,-9.155698568709e+001,1.875702340125e+001
   10319,-2.062501113750e+000,-9.309337542876e+001,2.816681977867e+001
   10320,-2.390912014838e+000,-8.937504826250e+001,1.611101782438e+001
   10321,-2.062501113750e+000,-9.001383365461e+001,1.599925559589e+001
   10322,-2.062501113750e+000,-9.028541807457e+001,1.626674692257e+001
   10323,-2.062501113750e+000,-8.996914790400e+001,1.637189181314e+001
   10324,-2.062501113750e+000,-9.181771125496e+001,1.956609376329e+001
   10325,-2.062501113750e+000,-9.707494690720e+001,1.021143191846e+001
   10326,-2.062501113750e+000,-9.720915509878e+001,1.003849054040e+001
   10327,-2.062501113750e+000,-8.967159468258e+001,3.010062158569e+001
   10328,-2.062501113750e+000,-8.973369095945e+001,3.049245968199e+001
   10329,-3.639011661113e+000,-8.937504826250e+001,1.676388489355e+001
   10330,-3.326886391824e+000,-8.937504826250e+001,1.661400247052e+001
   10331,-2.062501113750e+000,-9.633137398781e+001,2.693379471037e+001
   10332,-2.395546447209e+000,-9.635473871268e+001,2.675855927384e+001
   10333,-2.450089779838e+000,-9.627622906724e+001,2.734738161461e+001
   10334,-2.062501113750e+000,-9.532399032549e+001,3.448917217775e+001
   10335,-2.062501113750e+000,-9.538672894377e+001,3.401863254065e+001
   10336,-2.062501113750e+000,-9.329958921204e+001,6.446239267733e+000
   10337,-2.062501113750e+000,-9.342166778623e+001,5.720232895605e+000
   10338,-2.062501113750e+000,-9.405095023411e+001,6.069974175770e+000
   10339,-2.062501113750e+000,-9.134743224013e+001,2.871991747215e+001
   10340,-2.062501113750e+000,-9.121781229539e+001,2.879837172756e+001
   10341,-2.062501113750e+000,-9.047244275159e+001,3.301495196873e+001
   10342,-2.062501113750e+000,-9.017143609344e+001,3.312984569107e+001
   10343,-2.062501113750e+000,-9.040632898576e+001,3.275317922529e+001
   10344,-2.062501113750e+000,-9.010532232761e+001,3.286807294763e+001
   10345,-2.062501113750e+000,-9.339047574066e+001,4.661558534869e+001
   10346,-2.062501113750e+000,-9.395356101865e+001,2.688404081377e+001
   10347,-2.062501113750e+000,-9.381763228142e+001,2.688404081377e+001
   10348,-2.062501113750e+000,-8.937504826250e+001,4.415085391626e+001
   10349,-2.062501113750e+000,-8.937504826250e+001,4.379234752609e+001
   10350,-2.380054540250e+000,-8.937504826250e+001,4.437643114041e+001
   10351,-2.380054540250e+000,-8.937504826250e+001,4.401792475024e+001
   10352,-3.493372951467e+000,-9.716873780358e+001,2.065356609210e+001
   10353,-3.636222504292e+000,-8.937504826250e+001,3.784486374820e+001
   10354,-3.393294405173e+000,-8.937504826250e+001,3.799909371439e+001
   10355,-3.335132248085e+000,-8.937504826250e+001,3.772445811809e+001
   10356,-2.062501113750e+000,-9.274552348540e+001,1.951642003644e+001
   10357,-2.999220731899e+000,-9.488001880647e+001,3.781895857039e+001
   10358,-3.084923789959e+000,-9.483434510344e+001,3.816151134318e+001
   10359,-2.062501113750e+000,-9.300031338043e+001,9.554174083077e+000
   10360,-2.062501113750e+000,-9.320093297235e+001,9.319683695952e+000
   10361,-2.062501113750e+000,-9.164487248516e+001,8.304208968183e+000
   10362,-2.062501113750e+000,-9.375165842603e+001,4.628166142373e+001
   10363,-2.062501113750e+000,-9.115516235821e+001,3.953599831794e+001
   10364,-2.062501113750e+000,-9.284955618731e+001,1.876829114563e+001
   10365,-2.062501113750e+000,-9.474078910430e+001,1.809959609795e+001
   10366,-2.062501113750e+000,-9.484191843933e+001,1.791451593859e+001
   10367,-2.062501113750e+000,-9.493398210834e+001,1.809000696721e+001
   10368,-3.221726347538e+000,-9.488550283818e+001,3.777782833258e+001
   10369,-2.062501113750e+000,-9.516563876920e+001,1.959305634630e+001
   10370,-2.062501113750e+000,-9.438932564262e+001,2.966767972799e+001
   10371,-2.062501113750e+000,-9.437112563279e+001,2.980417980170e+001
   10372,-2.062501113750e+000,-9.495033470700e+001,3.729158931646e+001
   10373,-2.541955975559e+000,-9.489429621377e+001,3.771187801564e+001
   10374,-2.062501113750e+000,-9.132547235612e+001,8.421498445584e+000
   10375,-2.062501113750e+000,-9.134118836327e+001,1.780558545756e+001
   10376,-2.062501113750e+000,-9.117378347214e+001,1.789026040883e+001
   10377,-3.330689182295e+000,-8.937504826250e+001,5.518195029291e+000
   10378,-2.062501113750e+000,-9.157378758176e+001,8.662006401048e+000
   10379,-2.062501113750e+000,-9.035800865451e+001,2.796270251758e+001
   10380,-2.062501113750e+000,-9.067689470190e+001,2.795182625041e+001
   10381,-2.062501113750e+000,-9.059347021049e+001,2.825499802784e+001
   10382,-2.062501113750e+000,-9.485610387994e+001,2.976492789315e+001
   10383,-2.062501113750e+000,-9.468630560063e+001,2.969754960129e+001
   10384,-2.062501113750e+000,-9.484052314386e+001,2.959510456921e+001
   10385,-2.062501113750e+000,-9.003049748813e+001,2.735291420862e+001
   10386,-2.062501113750e+000,-9.005657263370e+001,2.779478247700e+001
   10387,-2.062501113750e+000,-9.039729901303e+001,2.708295141870e+001
   10388,-2.062501113750e+000,-9.042337415860e+001,2.752481968709e+001
   10389,-2.062501113750e+000,-9.476490528618e+001,2.996022311059e+001
   10390,-2.062501113750e+000,-9.459795138926e+001,3.007532176765e+001
   10391,-2.062501113750e+000,-9.561815335827e+001,4.981394914290e+000
   10392,-2.062501113750e+000,-9.551019605827e+001,2.181529296109e+001
   10393,-2.062501113750e+000,-9.594446204959e+001,2.169839522316e+001
   10394,-2.062501113750e+000,-9.564014368330e+001,2.214010740752e+001
   10395,-2.062501113750e+000,-9.607440967462e+001,2.202320966959e+001
   10396,-2.062501113750e+000,-9.554796274533e+001,2.153204280813e+001
   10397,-3.618825974509e+000,-9.702030190345e+001,2.176683534305e+001
   10398,-3.618825974509e+000,-9.697250105143e+001,2.212534173322e+001
   10399,-3.080324837699e+000,-8.937504826250e+001,2.862632550705e+001
   10400,-3.050961466900e+000,-8.937504826250e+001,2.900639149335e+001
   10401,-2.694899127960e+000,-8.937504826250e+001,2.887615315741e+001
   10402,-2.062501113750e+000,-8.937504826250e+001,3.975915063666e+001
   10403,-2.062501113750e+000,-8.937504826250e+001,4.011765702683e+001
   10404,-2.382837067870e+000,-8.937504826250e+001,3.955749989630e+001
   10405,-2.382837067870e+000,-8.937504826250e+001,3.991600628647e+001
   10406,-2.062501113750e+000,-9.369731008881e+001,1.930618529298e+001
   10407,-2.062501113750e+000,-9.382889087091e+001,1.954432821616e+001
   10408,-2.062501113750e+000,-9.398137053641e+001,1.933973012260e+001
   10409,-2.062501113750e+000,-9.178966111808e+001,4.640175906395e+001
   10410,-2.062501113750e+000,-9.431369094776e+001,9.275926649874e+000
   10411,-2.062501113750e+000,-9.588726845598e+001,3.853478467565e+000
   10412,-2.062501113750e+000,-9.567586243132e+001,3.594756767087e+000
   10413,-2.062501113750e+000,-9.295003169065e+001,4.635127408027e+001
   10414,-2.062501113750e+000,-9.284257054351e+001,4.619553255702e+001
   10415,-2.062501113750e+000,-9.317580957543e+001,4.634035726884e+001
   10416,-2.062501113750e+000,-9.306834842828e+001,4.618461574559e+001
   10417,-2.062501113750e+000,-9.148715464292e+001,4.647517528678e+001
   10418,-2.062501113750e+000,-9.296896387152e+001,4.648112883771e+001
   10419,-2.062501113750e+000,-9.437707069012e+001,3.399499026072e+001
   10420,-3.615507326744e+000,-8.937504826250e+001,4.240593109785e+001
   10421,-3.035489520629e+000,-8.937504826250e+001,1.426346083148e+001
   10422,-2.062501113750e+000,-9.285441724037e+001,4.424025186531e+001
   10423,-3.210473135805e+000,-9.704534083205e+001,2.157904337854e+001
   10424,-2.062501113750e+000,-9.421117742104e+001,1.937305438398e+001
   10425,-2.062501113750e+000,-9.432839587490e+001,1.957765247754e+001
   10426,-2.062501113750e+000,-9.051936306004e+001,1.696151227630e+001
   10427,-2.062501113750e+000,-9.183944949424e+001,7.548960978290e+000
   10428,-2.062501113750e+000,-9.171642729931e+001,7.962593748296e+000
   10429,-2.062501113750e+000,-9.086119785395e+001,1.711483567146e+001
   10430,-2.062501113750e+000,-9.070665887108e+001,1.721134074581e+001
   10431,-2.062501113750e+000,-9.088437611550e+001,1.724462963795e+001
   10432,-2.062501113750e+000,-9.883596275605e+001,4.923149513096e+000
   10433,-2.062501113750e+000,-9.834448719330e+001,5.049176110853e+000
   10434,-2.062501113750e+000,-9.029459739220e+001,2.130193211445e+001
   10435,-3.513433291125e+000,-9.676659295021e+001,2.366965249240e+001
   10436,-2.062501113750e+000,-9.369524496220e+001,3.552377430095e+001
   10437,-3.188105503702e+000,-9.847517515807e+001,1.085528593342e+001
   10438,-2.062501113750e+000,-9.796598741618e+001,9.791807985969e+000
   10439,-2.062501113750e+000,-9.361985316455e+001,4.644979881193e+000
   10440,-2.062501113750e+000,-9.410485769909e+001,4.848651015534e+000
   10441,-2.062501113750e+000,-9.350742537496e+001,5.184213145591e+000
   10442,-2.450089779838e+000,-9.621647800222e+001,2.779551460233e+001
   10443,-2.915605462466e+000,-9.622508067517e+001,2.773099455517e+001
   10444,-2.062501113750e+000,-9.801113809741e+001,1.116350037456e+001
   10445,-2.062501113750e+000,-9.137189845103e+001,3.735061276454e+001
   10446,-2.062501113750e+000,-9.067996964527e+001,4.221423108496e+001
   10447,-2.062501113750e+000,-9.068033914160e+001,4.257816553749e+001
   10448,-2.062501113750e+000,-9.006463930398e+001,4.240236022597e+001
   10449,-2.062501113750e+000,-9.006500880032e+001,4.276629467850e+001
   10450,-2.062501113750e+000,-9.292516750031e+001,4.771754296020e+000
   10451,-2.062501113750e+000,-9.281273971073e+001,5.310987560418e+000
   10452,-2.062501113750e+000,-9.323838214507e+001,4.431576857241e+000
   10453,-3.590969460320e+000,-9.486346588054e+001,3.794310551487e+001
   10454,-3.538148421317e+000,-9.454878380541e+001,4.030322107839e+001
   10455,-3.538148421317e+000,-9.450098295339e+001,4.066172746856e+001
   10456,-2.966949237991e+000,-9.959303050028e+001,2.471370866867e+000
   10457,-2.575384803855e+000,-9.891226642651e+001,7.577101420146e+000
   10458,-2.062501113750e+000,-9.076444829273e+001,1.937796169788e+001
   10459,-2.062501113750e+000,-9.162676226557e+001,9.603781938736e+000
   10460,-2.062501113750e+000,-9.149679679149e+001,9.465820662089e+000
   10461,-2.062501113750e+000,-9.149527667433e+001,9.633422548938e+000
   10462,-2.062501113750e+000,-9.337569590738e+001,2.840319392710e+001
   10463,-2.550219232609e+000,-9.404840003288e+001,4.405609937237e+001
   10464,-3.023226096641e+000,-9.408097259486e+001,4.381180515753e+001
   10465,-3.004517527617e+000,-9.402545123217e+001,4.422821537770e+001
   10466,-3.186024878900e+000,-9.729470746759e+001,1.970879361204e+001
   10467,-2.062501113750e+000,-9.613490622087e+001,1.825525274055e+001
   10468,-2.062501113750e+000,-9.590235313294e+001,1.830818567698e+001
   10469,-2.062501113750e+000,-9.654616814373e+001,1.793424245409e+001
   10470,-2.062501113750e+000,-9.644500044810e+001,1.817848022190e+001
   10471,-3.020457281116e+000,-8.937504826250e+001,5.402530087204e+000
   10472,-2.673946582722e+000,-8.937504826250e+001,5.285314211963e+000
   10473,-2.062501113750e+000,-9.207356634732e+001,3.709149379580e+001
   10474,-2.062501113750e+000,-9.198016883848e+001,3.728962085265e+001
   10475,-2.062501113750e+000,-9.078046152265e+001,1.781494695037e+001
   10476,-2.062501113750e+000,-9.054259789604e+001,1.779656508229e+001
   10477,-2.062501113750e+000,-9.062738106548e+001,1.756803455184e+001
   10478,-2.062501113750e+000,-8.973878492172e+001,9.166938554454e+000
   10479,-2.062501113750e+000,-8.937504826250e+001,9.286107472119e+000
   10480,-2.062501113750e+000,-8.937504826250e+001,8.927601081948e+000
   10481,-2.062501113750e+000,-9.522310735207e+001,2.182311130965e+000
   10482,-2.062501113750e+000,-9.094039221252e+001,1.799075335216e+001
   10483,-2.062501113750e+000,-9.069927562097e+001,1.806457701287e+001
   10484,-2.062501113750e+000,-9.442743891048e+001,3.103599513664e+001
   10485,-2.062501113750e+000,-9.483094807875e+001,3.094433100121e+001
   10486,-2.062501113750e+000,-9.471354252513e+001,3.136918614892e+001
   10487,-2.062501113750e+000,-9.168213883622e+001,9.404521952004e+000
   10488,-2.062501113750e+000,-9.064402730300e+001,1.179284233703e+001
   10489,-2.062501113750e+000,-9.075574618755e+001,1.224110763907e+001
   10490,-3.120952617291e+000,-9.787090248831e+001,1.538733095665e+001
   10491,-3.502915479759e+000,-9.784466988194e+001,1.558407550436e+001
   10492,-3.001137933330e+000,-9.781395023743e+001,1.581447283820e+001
   10493,-2.421641187642e+000,-9.611260741596e+001,2.857454399928e+001
   10494,-2.062501113750e+000,-9.614002519955e+001,2.836891062233e+001
   10495,-2.062501113750e+000,-8.966527196535e+001,5.506100615051e+000
   10496,-2.062501113750e+000,-8.998627109764e+001,5.693900062001e+000
   10497,-2.062501113750e+000,-9.308814583861e+001,4.577568081876e+001
   10498,-2.062501113750e+000,-9.303540295183e+001,4.544169296255e+001
   10499,-2.062501113750e+000,-9.328023322371e+001,4.526186545765e+001
   10500,-2.864134998325e+000,-9.606467415325e+001,2.893404346958e+001
   10501,-2.062501113750e+000,-8.965118966948e+001,4.403219762709e+000
   10502,-2.062501113750e+000,-8.965118966948e+001,4.044713372538e+000
   10503,-2.062501113750e+000,-9.078198480201e+001,1.588155932211e+001
   10504,-2.062501113750e+000,-9.119735565666e+001,4.645191788397e+001
   10505,-2.062501113750e+000,-9.217873933407e+001,4.533684307668e+001
   10506,-2.062501113750e+000,-9.215188695811e+001,4.583573724913e+001
   10507,-2.062501113750e+000,-9.169663973385e+001,4.541271301475e+001
   10508,-2.062501113750e+000,-9.081654391377e+001,1.611822044642e+001
   10509,-2.062501113750e+000,-9.059847957578e+001,1.600402113083e+001
   10510,-2.062501113750e+000,-9.074929380642e+001,1.028554936953e+001
   10511,-2.062501113750e+000,-9.525520060653e+001,3.500509506997e+001
   10512,-3.097776690852e+000,-9.838470109794e+001,1.153384138438e+001
   10513,-2.876236499686e+000,-9.844014210412e+001,1.111803383802e+001
   10514,-2.062501113750e+000,-9.733569410270e+001,1.940139384872e+001
   10515,-2.062501113750e+000,-9.740448382166e+001,1.888547095649e+001
   10516,-2.372895915941e+000,-9.738223424894e+001,1.905234275189e+001
   10517,-3.593865221853e+000,-9.898645798692e+001,7.020664717024e+000
   10518,-3.007743313771e+000,-9.749235130654e+001,1.822646481991e+001
   10519,-2.062501113750e+000,-9.070758259315e+001,2.603796201003e+001
   10520,-3.594832469946e+000,-8.937504826250e+001,8.769250861845e+000
   10521,-3.329109949745e+000,-8.937504826250e+001,8.894113191262e+000
   10522,-3.379432615003e+000,-8.937504826250e+001,8.633970610081e+000
   10523,-2.062501113750e+000,-9.339713161562e+001,3.648896399199e+001
   10524,-2.062501113750e+000,-9.346369673086e+001,3.666568733502e+001
   10525,-2.062501113750e+000,-9.079237315016e+001,2.181670403537e+001
   10526,-2.062501113750e+000,-9.137183115846e+001,4.289230641608e+001
   10527,-2.062501113750e+000,-9.187021252576e+001,4.294630121518e+001
   10528,-2.601124572741e+000,-9.381039001075e+001,4.584117453836e+001
   10529,-2.387423705424e+000,-9.379680951964e+001,4.594302822167e+001
   10530,-2.062501113750e+000,-9.328739790322e+001,1.952094157798e+001
   10531,-2.062501113750e+000,-9.287803705638e+001,4.467945327149e+001
   10532,-2.062501113750e+000,-9.356193578937e+001,4.605460908053e+001
   10533,-2.062501113750e+000,-9.052831237132e+001,2.523710087189e+001
   10534,-2.062501113750e+000,-9.029518641167e+001,2.497437929431e+001
   10535,-2.062501113750e+000,-9.693650467717e+001,1.066616235635e+001
   10536,-2.062501113750e+000,-9.709281263775e+001,1.077200599719e+001
   10537,-2.062501113750e+000,-9.702356417337e+001,8.688762024556e+000
   10538,-2.062501113750e+000,-9.663902936965e+001,8.791402760151e+000
   10539,-2.062501113750e+000,-9.712037177336e+001,8.256384714825e+000
   10540,-2.062501113750e+000,-9.673583696965e+001,8.359025450420e+000
   10541,-3.539258997808e+000,-9.490960330950e+001,3.759707479767e+001
   10542,-2.062501113750e+000,-9.753223516938e+001,7.388970917799e+000
   10543,-2.062501113750e+000,-9.710915423387e+001,7.711871673115e+000
   10544,-2.062501113750e+000,-9.754345270888e+001,7.933483959509e+000
   10545,-2.062501113750e+000,-9.050797271818e+001,1.492140028624e+001
   10546,-3.618332416707e+000,-9.950555952206e+001,3.127403203468e+000
   10547,-3.312442866070e+000,-9.953836781085e+001,2.881341037569e+000
   10548,-3.355509179430e+000,-9.948789599393e+001,3.259879664492e+000
   10549,-2.062501113750e+000,-9.426619240163e+001,2.699087035226e+001
   10550,-2.062501113750e+000,-9.449286486430e+001,2.692083248673e+001
   10551,-2.062501113750e+000,-9.758283616429e+001,8.359418663734e+000
   10552,-2.431013069697e+000,-9.845761972967e+001,1.098695164642e+001
   10553,-2.894953252000e+000,-9.849332256761e+001,1.071918036186e+001
   10554,-3.645977756835e+000,-8.937504826250e+001,3.927292953280e+001
   10555,-2.062501113750e+000,-9.746722243994e+001,1.841493131939e+001
   10556,-2.062501113750e+000,-9.073677349720e+001,3.176682551572e+001
   10557,-2.062501113750e+000,-9.073677349720e+001,3.147757535952e+001
   10558,-2.062501113750e+000,-9.039316939853e+001,3.161213799071e+001
   10559,-2.062501113750e+000,-9.028769377135e+001,3.598577684862e+001
   10560,-2.062501113750e+000,-9.031360906415e+001,3.572876106429e+001
   10561,-2.062501113750e+000,-9.054322883715e+001,3.588424591356e+001
   10562,-2.062501113750e+000,-9.056914412995e+001,3.562723012923e+001
   10563,-3.608516993248e+000,-9.737851878128e+001,1.908020875933e+001
   10564,-2.062501113750e+000,-9.086672342241e+001,3.594675386130e+001
   10565,-2.062501113750e+000,-9.070435914052e+001,3.582100124840e+001
   10566,-2.062501113750e+000,-9.070885728483e+001,3.603422311291e+001
   10567,-2.062501113750e+000,-8.937504826250e+001,1.417075703820e+001
   10568,-2.062501113750e+000,-8.937504826250e+001,1.450685677899e+001
   10569,-3.522758280874e+000,-9.835558452698e+001,1.175221566656e+001
   10570,-3.127309895817e+000,-9.833399181082e+001,1.191416103781e+001
   10571,-3.493225075909e+000,-9.840629381411e+001,1.137189601312e+001
   10572,-2.062501113750e+000,-9.558232224238e+001,2.083350111700e+001
   10573,-3.502299940928e+000,-9.398277720729e+001,4.454827056426e+001
   10574,-3.010260355640e+000,-9.396081389357e+001,4.471299541717e+001
   10575,-3.462917260171e+000,-9.392085994854e+001,4.501265000491e+001
   10576,-2.970877674883e+000,-9.389889663482e+001,4.517737485783e+001
   10577,-2.062501113750e+000,-9.790059862710e+001,1.199254640183e+001
   10578,-2.062501113750e+000,-9.828631425324e+001,1.227174271966e+001
   10579,-2.062501113750e+000,-9.007959250045e+001,1.305202740955e+001
   10580,-2.062501113750e+000,-9.012195321748e+001,1.344962581440e+001
   10581,-2.062501113750e+000,-9.277608371867e+001,4.634606143581e+001
   10582,-3.316279516683e+000,-9.421618771332e+001,4.279769176908e+001
   10583,-2.964339934388e+000,-9.420805398870e+001,4.285869470367e+001
   10584,-2.062501113750e+000,-9.389305318001e+001,3.647020569450e+001
   10585,-3.690665086055e+000,-8.937504826250e+001,1.503254574989e+001
   10586,-3.447444172986e+000,-8.937504826250e+001,1.518098707535e+001
   10587,-2.062501113750e+000,-9.918213264003e+001,2.968300591601e+000
   10588,-3.060982157073e+000,-8.937504826250e+001,3.655693918904e+001
   10589,-3.031058379745e+000,-8.937504826250e+001,3.616433596016e+001
   10590,-2.062501113750e+000,-9.292342662038e+001,4.375643812085e+001
   10591,-3.540704061878e+000,-9.470965818999e+001,3.909666319405e+001
   10592,-3.153386828290e+000,-9.473744473986e+001,3.888826406998e+001
   10593,-2.062501113750e+000,-9.572767500792e+001,2.597727884100e+001
   10594,-2.062501113750e+000,-9.538820038659e+001,2.587550733805e+001
   10595,-2.062501113750e+000,-9.778412445894e+001,1.603816617688e+001
   10596,-3.100003745227e+000,-9.775214498204e+001,1.627801225366e+001
   10597,-3.502915479759e+000,-9.779382530706e+001,1.596540981600e+001
   10598,-2.831114270559e+000,-9.759848446277e+001,1.743046614815e+001
   10599,-2.917690850391e+000,-9.754084940947e+001,1.786272904791e+001
   10600,-2.062501113750e+000,-9.784985063047e+001,1.554521989040e+001
   10601,-2.062501113750e+000,-9.790966777740e+001,1.509659128846e+001
   10602,-2.062501113750e+000,-9.525883513102e+001,2.477265350110e+001
   10603,-2.062501113750e+000,-9.679912053302e+001,1.000972020848e+001
   10604,-3.015139206642e+000,-9.478764286734e+001,3.851177811392e+001
   10605,-3.521184877002e+000,-9.476591906956e+001,3.867470659725e+001
   10606,-3.590969460320e+000,-9.481262130566e+001,3.832443982651e+001
   10607,-2.062501113750e+000,-9.291736069167e+001,4.157585815975e+001
   10608,-2.062501113750e+000,-9.306488739203e+001,4.102170410241e+001
   10609,-2.393606164389e+000,-8.937504826250e+001,4.471318999312e+001
   10610,-2.062501113750e+000,-8.937504826250e+001,4.450936030643e+001
   10611,-3.650238867145e+000,-8.937504826250e+001,4.384289086587e+001
   10612,-2.125141082426e+000,-9.569173780279e+001,9.442168474216e+000
   10613,-2.125141082426e+000,-9.587838048723e+001,9.463726024764e+000
   10614,-2.125141082426e+000,-9.578465224207e+001,9.630154279497e+000
   10615,-2.062501113750e+000,-9.599877497834e+001,2.535772229184e+001
   10616,-2.683200306045e+000,-8.937504826250e+001,3.972848575001e+001
   10617,-2.395546447209e+000,-9.641150222446e+001,2.633283293551e+001
   10618,-2.846173928048e+000,-9.639558384794e+001,2.645222075942e+001
   10619,-2.062501113750e+000,-9.058053882389e+001,2.195727303057e+001
   10620,-2.062501113750e+000,-9.078821481373e+001,2.207883084185e+001
   10621,-2.062501113750e+000,-9.073905790657e+001,2.236709707453e+001
   10622,-2.062501113750e+000,-9.065108197731e+001,2.261856677890e+001
   10623,-2.062501113750e+000,-9.039009074388e+001,2.246440169196e+001
   10624,-2.062501113750e+000,-9.104782506014e+001,2.877133252812e+001
   10625,-3.513029807218e+000,-9.515892032315e+001,3.572719719533e+001
   10626,-3.513029807218e+000,-9.510807574826e+001,3.610853150697e+001
   10627,-3.067240549285e+000,-8.937504826250e+001,4.026140640350e+001
   10628,-2.062501113750e+000,-9.420462155230e+001,2.715399218457e+001
   10629,-2.062501113750e+000,-9.414652350990e+001,2.735567595130e+001
   10630,-2.062501113750e+000,-9.402923198246e+001,2.717793856970e+001
   10631,-2.062501113750e+000,-9.040323930400e+001,3.102775263379e+001
   10632,-2.062501113750e+000,-9.010704851467e+001,3.118956723730e+001
   10633,-2.062501113750e+000,-9.039410929904e+001,3.132827612780e+001
   10634,-2.062501113750e+000,-9.009791850971e+001,3.149009073131e+001
   10635,-2.062501113750e+000,-9.385143846027e+001,1.914072759268e+001
   10636,-2.062501113750e+000,-9.413549890787e+001,1.917427242229e+001
   10637,-3.030760368487e+000,-9.508304534743e+001,3.629625951319e+001
   10638,-3.044001206963e+000,-9.513574897266e+001,3.590098232401e+001
   10639,-3.499788968742e+000,-9.505537212304e+001,3.650380869615e+001
   10640,-3.577691483504e+000,-9.747860160404e+001,1.832958758862e+001
   10641,-3.577691483504e+000,-9.752645532158e+001,1.797068470708e+001
   10642,-2.062501113750e+000,-9.468346380282e+001,1.959512293611e+001
   10643,-2.062501113750e+000,-9.451873788198e+001,1.959424398698e+001
   10644,-2.062501113750e+000,-9.066540696581e+001,2.721493648203e+001
   10645,-2.062501113750e+000,-9.088976715473e+001,2.746133224346e+001
   10646,-2.062501113750e+000,-9.095540765542e+001,2.722942253291e+001
   10647,-2.062501113750e+000,-9.536240087057e+001,2.674535477534e+001
   10648,-2.757975834874e+000,-9.377291994029e+001,4.612220006675e+001
   10649,-2.062501113750e+000,-8.968166060295e+001,1.539091371684e+001
   10650,-3.589126506333e+000,-9.629943580164e+001,2.717333110664e+001
   10651,-3.606925336883e+000,-9.633394284034e+001,2.691452831642e+001
   10652,-3.330421262554e+000,-8.937504826250e+001,3.145831993526e+001
   10653,-3.036454770789e+000,-8.937504826250e+001,4.149015325709e+001
   10654,-3.034612181021e+000,-8.937504826250e+001,4.184850916529e+001
   10655,-3.334646510259e+000,-8.937504826250e+001,4.168835045325e+001
   10656,-2.383493117125e+000,-8.937504826250e+001,3.237888495548e+001
   10657,-2.062501113750e+000,-9.272210326140e+001,5.781967762530e+000
   10658,-3.061496362842e+000,-8.937504826250e+001,4.657479314724e+001
   10659,-3.369555529194e+000,-8.937504826250e+001,4.657479314724e+001
   10660,-2.062501113750e+000,-9.118778951842e+001,2.706757531481e+001
   10661,-2.062501113750e+000,-9.247646054911e+001,4.780260205723e+000
   10662,-2.062501113750e+000,-9.245425822799e+001,4.366147025490e+000
   10663,-2.062501113750e+000,-9.063604400387e+001,5.691487207446e+000
   10664,-2.062501113750e+000,-9.077003650852e+001,6.057112227761e+000
   10665,-2.062501113750e+000,-9.277195196433e+001,9.508324846846e+000
   10666,-2.062501113750e+000,-9.619494582865e+001,2.151465252208e+001
   10667,-2.062501113750e+000,-9.134684794337e+001,1.971100169592e+001
   10668,-2.667284456800e+000,-8.937504826250e+001,3.146524325004e+001
   10669,-2.062501113750e+000,-9.824419621101e+001,9.966594587746e+000
   10670,-2.388888166954e+000,-8.937504826250e+001,4.366570912979e+001
   10671,-3.644823471294e+000,-8.937504826250e+001,1.558653021710e+001
   10672,-2.062501113750e+000,-9.002050136253e+001,1.711028421812e+001
   10673,-2.062501113750e+000,-9.003254446761e+001,1.744318499297e+001
   10674,-2.062501113750e+000,-9.391822393204e+001,2.703383447492e+001
   10675,-2.062501113750e+000,-8.967168949991e+001,2.641259291850e+001
   10676,-2.062501113750e+000,-9.001202777498e+001,2.695011183764e+001
   10677,-2.062501113750e+000,-9.000373925831e+001,2.656810992104e+001
   10678,-2.062501113750e+000,-9.134963485927e+001,2.854770506331e+001
   10679,-2.062501113750e+000,-9.116247848865e+001,2.842079274595e+001
   10680,-2.062501113750e+000,-9.118009344742e+001,2.820839456383e+001
   10681,-2.062501113750e+000,-9.053281780201e+001,2.690929580994e+001
   10682,-3.690665086055e+000,-8.937504826250e+001,1.532383219191e+001
   10683,-2.062501113750e+000,-9.200251112987e+001,2.743260712443e+001
   10684,-2.062501113750e+000,-9.195259858421e+001,2.721107445148e+001
   10685,-2.062501113750e+000,-9.221497528342e+001,2.727263776636e+001
   10686,-2.062501113750e+000,-9.073629539232e+001,3.481828679077e+001
   10687,-2.062501113750e+000,-9.078512975987e+001,3.456439294552e+001
   10688,-2.062501113750e+000,-9.207222874072e+001,2.709404734712e+001
   10689,-2.062501113750e+000,-9.233460543992e+001,2.715561066199e+001
   10690,-2.387636945611e+000,-8.937504826250e+001,3.577965887328e+001
   10691,-2.695188614787e+000,-8.937504826250e+001,3.560712821031e+001
   10692,-2.684147920215e+000,-8.937504826250e+001,3.597315377623e+001
   10693,-3.068279352681e+000,-8.937504826250e+001,3.544946515403e+001
   10694,-2.062501113750e+000,-9.019582257266e+001,3.816504136735e+001
   10695,-2.062501113750e+000,-9.051844650716e+001,3.792311914139e+001
   10696,-2.062501113750e+000,-9.070108770750e+001,3.831151271026e+001
   10697,-2.062501113750e+000,-9.038833289407e+001,3.470338037423e+001
   10698,-2.062501113750e+000,-9.008699371187e+001,3.485542905335e+001
   10699,-2.062501113750e+000,-9.012848596426e+001,3.446113409294e+001
   10700,-3.344870175132e+000,-8.937504826250e+001,3.401026361565e+001
   10701,-3.614614481396e+000,-8.937504826250e+001,3.414135152365e+001
   10702,-3.353723582165e+000,-8.937504826250e+001,3.429957771949e+001
   10703,-2.062501113750e+000,-9.078512975987e+001,3.427839279108e+001
   10704,-2.062501113750e+000,-9.043716726162e+001,3.444948652898e+001
   10705,-2.062501113750e+000,-9.769490863683e+001,2.477196813975e+000
   10706,-2.062501113750e+000,-9.758685263434e+001,2.758484395208e+000
   10707,-2.062501113750e+000,-9.269758750941e+001,3.772529080263e+001
   10708,-2.062501113750e+000,-9.291264610236e+001,3.791338290758e+001
   10709,-2.391560298434e+000,-8.937504826250e+001,4.060094097669e+001
   10710,-2.443526579933e+000,-8.937504826250e+001,4.097852138493e+001
   10711,-2.776416125927e+000,-8.937504826250e+001,4.084795225128e+001
   10712,-2.783709775336e+000,-8.937504826250e+001,3.481647209000e+001
   10713,-2.062501113750e+000,-9.871439520005e+001,3.623401498166e+000
   10714,-2.000141014926e+000,-9.578680895395e+001,9.630154279497e+000
   10715,-2.000141014926e+000,-9.568412519652e+001,9.447059171480e+000
   10716,-2.000141014926e+000,-9.587201332783e+001,9.463257071099e+000
   10717,-3.016569595500e+000,-9.524799427862e+001,3.505914252930e+001
   10718,-3.506036356629e+000,-9.521236378214e+001,3.532637125287e+001
   10719,-3.506036356629e+000,-9.526021749968e+001,3.496746837133e+001
   10720,-2.062501113750e+000,-9.839782791411e+001,2.174612388828e+000
   10721,-2.831522367647e+000,-9.644386551579e+001,2.609010825051e+001
   10722,-3.179827382400e+000,-9.641769753399e+001,2.628636811400e+001
   10723,-2.062501113750e+000,-9.645393636120e+001,2.601457690991e+001
   10724,-2.738265408873e+000,-8.937504826250e+001,1.850515971499e+001
   10725,-2.062501113750e+000,-9.493019418958e+001,2.714988905625e+000
   10726,-2.062501113750e+000,-9.521239570248e+001,2.697752923950e+000
   10727,-3.531005650691e+000,-9.918924571189e+001,5.499756779800e+000
   10728,-2.062501113750e+000,-8.974960962382e+001,3.991927576103e+001
   10729,-2.062501113750e+000,-8.974960962382e+001,3.956076937086e+001
   10730,-2.062501113750e+000,-9.007176603629e+001,3.972518175520e+001
   10731,-2.062501113750e+000,-8.937504826250e+001,1.959316618954e+001
   10732,-2.062501113750e+000,-9.056094998871e+001,4.028105205544e+001
   10733,-2.062501113750e+000,-9.053414829608e+001,3.993632807893e+001
   10734,-2.062501113750e+000,-9.009856772892e+001,4.006990573170e+001
   10735,-2.062501113750e+000,-9.962543527388e+001,2.228335064867e+000
   10736,-2.062501113750e+000,-8.967365462488e+001,1.032097944275e+001
   10737,-2.062501113750e+000,-8.967365462488e+001,9.917659753805e+000
   10738,-2.062501113750e+000,-8.937504826250e+001,1.009274685000e+001
   10739,-2.391208344505e+000,-8.937504826250e+001,3.920278852593e+001
   10740,-2.062501113750e+000,-9.685601368236e+001,3.953703429231e+000
   10741,-2.062501113750e+000,-9.651021455653e+001,4.082310884611e+000
   10742,-2.062501113750e+000,-9.194716191046e+001,2.446856075352e+000
   10743,-2.062501113750e+000,-9.208958839139e+001,2.184822738284e+000
   10744,-2.062501113750e+000,-9.039813753155e+001,3.191334363078e+001
   10745,-3.356435049259e+000,-8.937504826250e+001,3.718826898432e+000
   10746,-2.062501113750e+000,-9.873129746776e+001,5.436372823388e+000
   10747,-2.062501113750e+000,-9.823982190501e+001,5.562399421145e+000
   10748,-2.062501113750e+000,-9.934446980036e+001,4.335576116269e+000
   10749,-2.062501113750e+000,-9.897749353202e+001,2.296101110030e+000
   10750,-2.062501113750e+000,-9.923292104531e+001,2.587387552044e+000
   10751,-2.062501113750e+000,-9.934448739436e+001,2.228012915626e+000
   10752,-2.062501113750e+000,-8.937504826250e+001,4.045375676762e+001
   10753,-2.437209943943e+000,-8.937504826250e+001,3.275307750459e+001
   10754,-2.730230678658e+000,-8.937504826250e+001,3.254393055005e+001
   10755,-2.685294419221e+000,-8.937504826250e+001,4.386278094426e+001
   10756,-2.676460792517e+000,-8.937504826250e+001,4.421499656470e+001
   10757,-2.388367555065e+000,-8.937504826250e+001,3.373848799622e+000
   10758,-2.388367555065e+000,-8.937504826250e+001,3.732355189793e+000
   10759,-2.730481449569e+000,-8.937504826250e+001,2.109709253503e+001
   10760,-3.096274860825e+000,-8.937504826250e+001,2.108998939315e+001
   10761,-3.502299940928e+000,-9.403362178218e+001,4.416693625262e+001
   10762,-2.062501113750e+000,-9.095252829621e+001,4.044798923243e+001
   10763,-2.062501113750e+000,-9.076593748059e+001,4.080977308955e+001
   10764,-2.379715596495e+000,-8.937504826250e+001,4.073565497944e+000
   10765,-2.877598865848e+000,-9.425971846067e+001,4.247121116395e+001
   10766,-2.062501113750e+000,-9.386424984523e+001,2.717583726949e+001
   10767,-2.062501113750e+000,-9.380132390743e+001,2.734392291133e+001
   10768,-3.665360008958e+000,-8.937504826250e+001,4.101285341503e+001
   10769,-3.665360008958e+000,-8.937504826250e+001,4.128173320766e+001
   10770,-3.396209818686e+000,-8.937504826250e+001,4.111705160169e+001
   10771,-2.062501113750e+000,-9.438312041077e+001,2.190900001811e+000
   10772,-2.062501113750e+000,-9.466487047806e+001,2.185412552254e+000
   10773,-2.062501113750e+000,-9.452151403174e+001,2.439586080454e+000
   10774,-3.691410408694e+000,-8.937504826250e+001,4.357891373243e+001
   10775,-2.062501113750e+000,-9.011102743068e+001,1.237385176914e+001
   10776,-2.062501113750e+000,-9.040639121909e+001,1.230116475716e+001
   10777,-2.727517580473e+000,-8.937504826250e+001,2.365961043418e+001
   10778,-2.062501113750e+000,-9.037811833185e+001,4.296566597474e+001
   10779,-2.062501113750e+000,-9.050935535439e+001,3.049343988483e+001
   10780,-3.451126345819e+000,-8.937504826250e+001,1.229838729538e+001
   10781,-3.749836524911e+000,-8.937504826250e+001,4.657077204991e+001
   10782,-2.062501113750e+000,-9.000867535383e+001,2.517662605819e+001
   10783,-3.337601152167e+000,-8.937504826250e+001,2.063644323107e+001
   10784,-3.521823509535e+000,-9.816573980670e+001,1.317605106867e+001
   10785,-3.521823509535e+000,-9.811489523182e+001,1.355738538031e+001
   10786,-2.062501113750e+000,-9.814377096006e+001,6.099493144609e+000
   10787,-2.062501113750e+000,-9.808826164920e+001,6.642508844858e+000
   10788,-2.062501113750e+000,-9.638126574007e+001,1.585256729923e+001
   10789,-3.059520580117e+000,-9.962357298120e+001,2.242302259985e+000
   10790,-2.062501113750e+000,-9.435469677795e+001,3.146958061599e+001
   10791,-2.062501113750e+000,-8.971686281912e+001,2.130551409443e+001
   10792,-2.062501113750e+000,-8.937504826250e+001,2.149773138732e+001
   10793,-2.062501113750e+000,-8.937504826250e+001,2.111681834777e+001
   10794,-2.062501113750e+000,-9.005450621418e+001,3.665227363591e+001
   10795,-2.062501113750e+000,-9.796941884243e+001,1.464845830075e+001
   10796,-2.402634383847e+000,-9.794667460588e+001,1.481904007481e+001
   10797,-2.666038783452e+000,-9.790300095295e+001,1.514659247181e+001
   10798,-3.133125105644e+000,-9.792501423220e+001,1.498149287747e+001
   10799,-2.062501113750e+000,-9.638813749959e+001,2.650806837204e+001
   10800,-2.062501113750e+000,-9.597585167039e+001,2.643220139870e+001
   10801,-2.062501113750e+000,-9.607992709462e+001,2.613186098562e+001
   10802,-2.062501113750e+000,-9.051454001250e+001,1.519827190609e+001
   10803,-2.062501113750e+000,-9.026186391413e+001,1.531119225231e+001
   10804,-2.062501113750e+000,-8.937504826250e+001,1.854005366841e+001
   10805,-2.062501113750e+000,-8.937504826250e+001,1.889856005858e+001
   10806,-3.054288917850e+000,-8.937504826250e+001,3.453035405845e+001
   10807,-3.407743329080e+000,-8.937504826250e+001,3.457723738572e+001
   10808,-2.062501113750e+000,-9.657650203869e+001,2.509533432875e+001
   10809,-3.594907188501e+000,-8.937504826250e+001,3.700202490521e+001
   10810,-2.062501113750e+000,-9.002072245019e+001,6.440742487268e+000
   10811,-2.062501113750e+000,-8.998582582180e+001,6.072838951799e+000
   10812,-3.232424914286e+000,-9.808397259011e+001,1.378930519316e+001
   10813,-3.218398087099e+000,-9.802848445589e+001,1.420546619976e+001
   10814,-2.603508126005e+000,-9.499412727909e+001,3.696314502579e+001
   10815,-2.603508126005e+000,-9.505387834412e+001,3.651501203807e+001
   10816,-2.062501113750e+000,-9.501912442596e+001,3.677566642424e+001
   10817,-2.062501113750e+000,-9.507887549099e+001,3.632753343653e+001
   10818,-2.062501113750e+000,-9.445071104788e+001,3.752557303855e+001
   10819,-2.379899865447e+000,-8.937504826250e+001,5.129954417080e+000
   10820,-2.062501113750e+000,-8.937504826250e+001,5.320130530851e+000
   10821,-3.509348954061e+000,-9.924479224286e+001,5.083157797532e+000
   10822,-2.676795284138e+000,-8.937504826250e+001,8.155928789546e+000
   10823,-2.392094018745e+000,-8.937504826250e+001,6.977738122078e+000
   10824,-2.720525762493e+000,-8.937504826250e+001,7.083058030620e+000
   10825,-2.483595749380e+000,-9.374046508610e+001,4.636561147317e+001
   10826,-2.062501113750e+000,-9.280415506267e+001,4.660279526679e+001
   10827,-2.062501113750e+000,-9.255415492767e+001,4.660279526679e+001
   10828,-2.062501113750e+000,-9.830992238254e+001,9.473648301261e+000
   10829,-2.062501113750e+000,-9.862409940815e+001,9.738354057842e+000
   10830,-3.053578908747e+000,-8.937504826250e+001,4.576505565801e+001
   10831,-2.062501113750e+000,-9.915020945302e+001,5.792528721268e+000
   10832,-2.670505186021e+000,-9.912650709361e+001,5.970296416900e+000
   10833,-2.062501113750e+000,-9.922191073106e+001,5.254769136012e+000
   10834,-2.670505186021e+000,-9.919820837164e+001,5.432536831643e+000
   10835,-2.380818561980e+000,-8.937504826250e+001,8.040652237036e+000
   10836,-2.380818561980e+000,-8.937504826250e+001,7.682145846865e+000
   10837,-2.515842167055e+000,-9.377125630205e+001,4.613467735360e+001
   10838,-2.062501113750e+000,-8.937504826250e+001,4.244611360338e+000
   10839,-2.062501113750e+000,-8.937504826250e+001,4.603117750509e+000
   10840,-2.062501113750e+000,-8.937504826250e+001,5.678636921022e+000
   10841,-2.062501113750e+000,-9.072611924208e+001,2.295203830873e+001
   10842,-2.062501113750e+000,-9.065100948385e+001,2.324695118711e+001
   10843,-3.690932052470e+000,-8.937504826250e+001,6.760207934578e+000
   10844,-3.131852494162e+000,-9.922408074078e+001,5.238494063067e+000
   10845,-2.062501113750e+000,-9.865959618973e+001,5.974132408645e+000
   10846,-2.665860423485e+000,-8.937504826250e+001,4.263191029053e+000
   10847,-3.019610840757e+000,-8.937504826250e+001,4.120037949656e+000
   10848,-3.631040313220e+000,-8.937504826250e+001,4.751249334651e+000
   10849,-2.062501113750e+000,-8.998819958067e+001,2.483691389762e+001
   10850,-2.062501113750e+000,-8.937504826250e+001,1.818154727824e+001
   10851,-2.062501113750e+000,-8.937504826250e+001,1.784544753745e+001
   10852,-2.062501113750e+000,-8.970954446812e+001,1.796732218355e+001
   10853,-2.062501113750e+000,-9.816924650199e+001,4.207606147399e+000
   10854,-2.062501113750e+000,-9.323326942981e+001,4.006497428919e+000
   10855,-2.062501113750e+000,-9.293035973807e+001,4.048523659822e+000
   10856,-2.391476896355e+000,-9.761630340484e+001,1.729682408263e+001
   10857,-3.593587372992e+000,-8.937504826250e+001,5.062438238194e+000
   10858,-3.599169362379e+000,-8.937504826250e+001,1.101447753288e+001
   10859,-3.333619924004e+000,-8.937504826250e+001,1.086918788964e+001
   10860,-2.062501113750e+000,-9.887409756720e+001,2.665359342243e+000
   10861,-2.062501113750e+000,-9.886120854142e+001,3.149346519179e+000
   10862,-3.505590376058e+000,-9.772747993491e+001,1.646300010715e+001
   10863,-3.505590376058e+000,-9.767370397638e+001,1.686631979609e+001
   10864,-3.614878139607e+000,-8.937504826250e+001,1.043391039885e+001
   10865,-3.642952672215e+000,-8.937504826250e+001,1.070928328588e+001
   10866,-2.062501113750e+000,-8.971484551729e+001,1.612155706301e+001
   10867,-2.062501113750e+000,-8.937504826250e+001,1.627698208046e+001
   10868,-2.062501113750e+000,-8.971484551729e+001,1.578545732223e+001
   10869,-2.062501113750e+000,-8.937504826250e+001,1.594088233967e+001
   10870,-2.062501113750e+000,-9.284627913288e+001,2.718781350464e+001
   10871,-2.062501113750e+000,-9.404004379878e+001,1.885998139285e+001
   10872,-3.041424149043e+000,-8.937504826250e+001,1.583532582839e+001
   10873,-3.334697949655e+000,-8.937504826250e+001,3.597897655486e+001
   10874,-2.062501113750e+000,-9.049490794497e+001,2.066643499419e+001
   10875,-2.062501113750e+000,-9.025597056520e+001,2.063850136124e+001
   10876,-3.078513159516e+000,-8.937504826250e+001,1.492699864302e+001
   10877,-2.769399156486e+000,-8.937504826250e+001,1.520371093970e+001
   10878,-2.062501113750e+000,-9.085510803233e+001,1.693024909379e+001
   10879,-2.062501113750e+000,-9.928471873533e+001,4.783709103983e+000
   10880,-2.062501113750e+000,-8.967015976667e+001,1.649419328027e+001
   10881,-2.062501113750e+000,-8.937504826250e+001,1.665789512001e+001
   10882,-3.231160465985e+000,-9.534402342807e+001,3.433892390841e+001
   10883,-3.631032008872e+000,-9.536631241525e+001,3.417175650458e+001
   10884,-3.631032008872e+000,-9.531253645672e+001,3.457507619352e+001
   10885,-3.350831550987e+000,-8.937504826250e+001,4.258400143500e+001
   10886,-3.634949930157e+000,-8.937504826250e+001,1.617218421780e+001
   10887,-2.379715596495e+000,-8.937504826250e+001,4.432071888116e+000
   10888,-2.666044692437e+000,-8.937504826250e+001,4.602567167846e+000
   10889,-2.379899865447e+000,-8.937504826250e+001,4.771448026909e+000
   10890,-3.070553706462e+000,-9.769624159665e+001,1.669728764406e+001
   10891,-2.062501113750e+000,-8.937504826250e+001,7.515982170649e+000
   10892,-2.062501113750e+000,-9.162868811696e+001,1.825117344025e+001
   10893,-2.062501113750e+000,-8.968602450129e+001,1.322868969098e+001
   10894,-2.062501113750e+000,-8.972838521832e+001,1.362628809582e+001
   10895,-2.062501113750e+000,-8.937504826250e+001,3.075167758361e+001
   10896,-2.062501113750e+000,-8.937504826250e+001,3.115499727256e+001
   10897,-3.322824660868e+000,-8.937504826250e+001,1.631358823677e+001
   10898,-2.062501113750e+000,-8.966482668950e+001,6.624458934577e+000
   10899,-2.062501113750e+000,-9.002472645750e+001,2.185900255663e+001
   10900,-2.062501113750e+000,-9.027566810991e+001,2.211726204589e+001
   10901,-3.575968545173e+000,-9.691815199185e+001,2.253295968006e+001
   10902,-3.575968545173e+000,-9.686132570227e+001,2.295915685190e+001
   10903,-3.188632148319e+000,-9.689093616851e+001,2.273707835509e+001
   10904,-3.644932949781e+000,-8.937504826250e+001,2.246054610320e+001
   10905,-3.498629126759e+000,-9.639315512449e+001,2.647043618527e+001
   10906,-3.197052353052e+000,-9.635686265608e+001,2.674262969831e+001
   10907,-2.062501113750e+000,-9.084355479601e+001,1.987956803916e+001
   10908,-2.062501113750e+000,-9.079548046037e+001,1.966802985525e+001
   10909,-2.062501113750e+000,-9.103178637219e+001,1.973134318573e+001
   10910,-2.062501113750e+000,-9.098371203655e+001,1.951980500182e+001
   10911,-3.028197256647e+000,-8.937504826250e+001,2.272686979133e+001
   10912,-3.331467331550e+000,-8.937504826250e+001,2.261476946068e+001
   10913,-3.322888675605e+000,-8.937504826250e+001,2.290635212079e+001
   10914,-2.062501113750e+000,-9.512445747201e+001,1.912824106047e+001
   10915,-2.062501113750e+000,-9.520833222974e+001,3.119778402776e+001
   10916,-3.595036492359e+000,-8.937504826250e+001,2.277228721409e+001
   10917,-3.376650121642e+000,-8.937504826250e+001,2.204381876926e+001
   10918,-3.594859275614e+000,-8.937504826250e+001,2.217158508983e+001
   10919,-3.331290114805e+000,-8.937504826250e+001,2.230535377844e+001
   10920,-3.038100065549e+000,-8.937504826250e+001,4.283093835924e+001
   10921,-2.900717260676e+000,-9.631707420250e+001,2.704104310019e+001
   10922,-2.062501113750e+000,-9.088358770298e+001,2.937899925789e+001
   10923,-3.649979005008e+000,-8.937504826250e+001,2.959556512113e+001
   10924,-3.354775158272e+000,-8.937504826250e+001,2.970796069570e+001
   10925,-2.062501113750e+000,-9.069859533813e+001,1.836714771933e+001
   10926,-2.062501113750e+000,-9.049832321482e+001,1.860498634144e+001
   10927,-3.044135081828e+000,-8.937504826250e+001,1.067889662043e+001
   10928,-2.062501113750e+000,-9.329018661404e+001,1.847847678411e+001
   10929,-3.387288964065e+000,-8.937504826250e+001,3.028085875471e+001
   10930,-2.695282355407e+000,-8.937504826250e+001,3.401748725164e+001
   10931,-2.751820620581e+000,-8.937504826250e+001,3.441640335574e+001
   10932,-2.062501113750e+000,-9.515651027993e+001,1.790497763990e+001
   10933,-2.062501113750e+000,-9.502036339284e+001,1.790497763990e+001
   10934,-3.051255284896e+000,-8.937504826250e+001,3.418562701679e+001
   10935,-2.062501113750e+000,-9.362624356030e+001,2.746382155965e+001
   10936,-2.062501113750e+000,-9.467130398588e+001,1.791451593859e+001
   10937,-2.693851218639e+000,-8.937504826250e+001,3.368225803600e+001
   10938,-3.049824148129e+000,-8.937504826250e+001,3.385039780115e+001
   10939,-3.526539248122e+000,-9.789702584645e+001,1.519140577058e+001
   10940,-2.062501113750e+000,-9.079515023849e+001,1.011436558443e+001
   10941,-2.062501113750e+000,-9.292310004308e+001,2.749357674260e+001
   10942,-2.062501113750e+000,-8.996796210235e+001,4.572345405855e+000
   10943,-2.062501113750e+000,-8.996423335289e+001,4.940103553286e+000
   10944,-2.062501113750e+000,-8.966318828450e+001,4.772896163676e+000
   10945,-3.272836733100e+000,-8.937504826250e+001,2.908554226643e+000
   10946,-3.093568968341e+000,-8.937504826250e+001,2.699600473718e+000
   10947,-2.890181837160e+000,-8.937504826250e+001,2.905769030560e+000
   10948,-3.032791606222e+000,-8.937504826250e+001,3.758077930538e+000
   10949,-3.049962643211e+000,-8.937504826250e+001,3.446660340321e+000
   10950,-3.343185662983e+000,-8.937504826250e+001,1.176237771320e+001
   10951,-3.608564426016e+000,-8.937504826250e+001,1.160972626193e+001
   10952,-2.062501113750e+000,-9.321452617169e+001,1.797901264440e+001
   10953,-2.688177803872e+000,-8.937504826250e+001,2.586952116415e+001
   10954,-2.727705934620e+000,-8.937504826250e+001,2.625526749884e+001
   10955,-3.069887560770e+000,-8.937504826250e+001,2.604867081803e+001
   10956,-3.449626280648e+000,-8.937504826250e+001,4.085722872348e+001
   10957,-3.692768382281e+000,-8.937504826250e+001,4.070145176501e+001
   10958,-3.761062513268e+000,-8.937504826250e+001,4.636802958454e+001
   10959,-2.062501113750e+000,-9.515900840275e+001,1.939372766567e+001
   10960,-3.408863317337e+000,-8.937504826250e+001,2.943659289835e+001
   10961,-2.062501113750e+000,-9.106868687611e+001,1.991921557114e+001
   10962,-2.062501113750e+000,-9.121563127272e+001,1.979126968536e+001
   10963,-3.085633286297e+000,-8.937504826250e+001,1.783970272004e+001
   10964,-2.771899270657e+000,-8.937504826250e+001,1.812530137455e+001
   10965,-3.136964424119e+000,-8.937504826250e+001,1.811621762864e+001
   10966,-2.062501113750e+000,-9.438810657811e+001,2.998795980373e+001
   10967,-3.693939053380e+000,-8.937504826250e+001,1.792385778082e+001
   10968,-2.062501113750e+000,-9.220374497322e+001,3.690463757120e+001
   10969,-2.062501113750e+000,-9.299111966744e+001,3.848579197927e+001
   10970,-2.062501113750e+000,-8.937504826250e+001,1.302801791953e+001
   10971,-2.062501113750e+000,-8.937504826250e+001,1.264710487997e+001
   10972,-2.062501113750e+000,-9.085888192086e+001,2.056993327685e+001
   10973,-3.335015441360e+000,-8.937504826250e+001,1.600962771857e+001
   10974,-2.062501113750e+000,-9.089658188929e+001,3.623124957212e+001
   10975,-2.062501113750e+000,-9.087401135876e+001,3.610311496247e+001
   10976,-2.062501113750e+000,-9.071614522119e+001,3.619058421408e+001
   10977,-2.062501113750e+000,-9.265008761257e+001,3.829633705425e+001
   10978,-3.336586984668e+000,-8.937504826250e+001,1.146749092167e+001
   10979,-3.399406659957e+000,-8.937504826250e+001,1.779255096315e+001
   10980,-3.450737797779e+000,-8.937504826250e+001,1.806906587175e+001
   10981,-2.062501113750e+000,-9.013493555937e+001,3.216630597803e+001
   10982,-2.062501113750e+000,-9.012996742635e+001,3.186510033797e+001
   10983,-3.636524669242e+000,-8.937504826250e+001,1.129491047288e+001
   10984,-2.062501113750e+000,-9.095066814634e+001,3.640876783097e+001
   10985,-2.062501113750e+000,-9.079922165014e+001,3.638454764619e+001
   10986,-2.062501113750e+000,-9.085330790718e+001,3.656206590504e+001
   10987,-2.062501113750e+000,-9.104425346344e+001,3.655197203504e+001
   10988,-2.062501113750e+000,-9.670774389416e+001,2.753966709444e+000
   10989,-2.062501113750e+000,-9.702450376262e+001,2.835078869379e+000
   10990,-2.062501113750e+000,-9.683628562231e+001,2.483509335621e+000
   10991,-2.062501113750e+000,-9.363683652121e+001,3.667269327818e+001
   10992,-2.638122493644e+000,-8.937504826250e+001,2.861483874991e+000
   10993,-2.420457887677e+000,-8.937504826250e+001,3.005469705492e+000
   10994,-2.725006346846e+000,-8.937504826250e+001,1.044930081316e+001
   10995,-2.062501113750e+000,-9.102923421066e+001,1.858411482520e+001
   10996,-2.062501113750e+000,-9.398449714777e+001,3.410570297376e+001
   10997,-2.732586022090e+000,-8.937504826250e+001,1.484758305356e+001
   10998,-2.439769991013e+000,-8.937504826250e+001,1.504221948355e+001
   10999,-2.389179448096e+000,-8.937504826250e+001,1.467601392681e+001
   11000,-2.062501113750e+000,-9.636982772927e+001,8.805175736828e+000
   11001,-2.062501113750e+000,-9.650542490715e+001,9.079910654932e+000
   11002,-2.062501113750e+000,-9.677462654753e+001,9.066137678255e+000
   11003,-2.062501113750e+000,-9.812158919224e+001,2.183692004137e+000
   11004,-2.062501113750e+000,-9.800009061230e+001,2.441499193306e+000
   11005,-2.062501113750e+000,-9.802872852282e+001,8.604823668549e+000
   11006,-2.062501113750e+000,-9.839944850795e+001,8.504987024882e+000
   11007,-3.220398618431e+000,-9.538691414645e+001,3.401724352057e+001
   11008,-3.296492063134e+000,-9.543577903216e+001,3.365075687774e+001
   11009,-2.062501113750e+000,-9.711426971824e+001,2.475714203237e+000
   11010,-2.062501113750e+000,-9.730248785855e+001,2.827283736994e+000
   11011,-2.062501113750e+000,-9.119787327494e+001,6.258945973330e+000
   11012,-2.062501113750e+000,-9.076375983684e+001,6.435753754783e+000
   11013,-2.677647956647e+000,-9.448305763388e+001,4.079616736487e+001
   11014,-3.212958066139e+000,-9.447489569192e+001,4.085738192956e+001
   11015,-3.139864596904e+000,-9.452289546999e+001,4.049738359402e+001
   11016,-3.010868076298e+000,-9.874134244504e+001,8.859031281119e+000
   11017,-2.062501113750e+000,-9.401910011037e+001,5.384670765547e+000
   11018,-2.557558489311e+000,-9.877813073389e+001,8.583119114762e+000
   11019,-2.387636945611e+000,-8.937504826250e+001,3.618297856223e+001
   11020,-2.714071697544e+000,-8.937504826250e+001,3.636575700511e+001
   11021,-2.710465266054e+000,-8.937504826250e+001,3.672170888881e+001
   11022,-3.220361000238e+000,-8.937504826250e+001,3.160787763227e+000
   11023,-2.062501113750e+000,-9.477328642133e+001,2.642150099853e+001
   11024,-2.062501113750e+000,-9.483458136098e+001,2.626066462977e+001
   11025,-2.062501113750e+000,-8.937504826250e+001,3.554670055215e+001
   11026,-2.062501113750e+000,-9.073771339770e+001,3.119371349661e+001
   11027,-2.062501113750e+000,-9.738947126662e+001,1.632658629593e+001
   11028,-2.062501113750e+000,-9.742241895068e+001,1.586763313075e+001
   11029,-2.062501113750e+000,-9.262620909191e+001,2.750814365254e+001
   11030,-2.062501113750e+000,-9.649279286012e+001,2.176977187025e+001
   11031,-2.062501113750e+000,-9.594016575926e+001,2.233096468230e+001
   11032,-2.062501113750e+000,-9.629879787973e+001,2.252565987068e+001
   11033,-2.062501113750e+000,-9.643304179510e+001,2.221790485796e+001
   11034,-2.062501113750e+000,-9.553846379343e+001,2.131619211943e+001
   11035,-2.062501113750e+000,-9.073503390393e+001,3.400145676314e+001
   11036,-2.062501113750e+000,-9.073503390393e+001,3.371545660870e+001
   11037,-3.376478687760e+000,-8.937504826250e+001,8.324330797888e+000
   11038,-2.062501113750e+000,-9.410187670870e+001,2.188636737858e+000
   11039,-2.679041188951e+000,-8.937504826250e+001,3.901231009935e+000
   11040,-2.062501113750e+000,-9.203975984385e+001,6.651523671433e+000
   11041,-2.743858832571e+000,-8.937504826250e+001,2.185864258712e+000
   11042,-3.004625075367e+000,-8.937504826250e+001,2.421052750950e+000
   11043,-2.801237944186e+000,-8.937504826250e+001,2.627221307793e+000
   11044,-3.342071402160e+000,-8.937504826250e+001,9.197542782393e+000
   11045,-3.642779590389e+000,-8.937504826250e+001,9.007650112593e+000
   11046,-2.062501113750e+000,-9.308979443092e+001,3.634123654827e+000
   11047,-2.062501113750e+000,-9.177862453186e+001,1.888162816849e+001
   11048,-3.693102255648e+000,-8.937504826250e+001,8.456221089399e+000
   11049,-3.041700025120e+000,-8.937504826250e+001,1.457087075688e+001
   11050,-3.340239638084e+000,-8.937504826250e+001,2.321126715304e+001
   11051,-3.636354293836e+000,-8.937504826250e+001,2.304341520532e+001
   11052,-2.062501113750e+000,-9.469751317387e+001,5.243903405861e+000
   11053,-2.062501113750e+000,-9.472936329762e+001,5.929206816083e+000
   11054,-3.639956679719e+000,-8.937504826250e+001,1.418975429441e+001
   11055,-3.603173954222e+000,-8.937504826250e+001,1.389793102683e+001
   11056,-3.331625222028e+000,-8.937504826250e+001,1.343722285821e+001
   11057,-3.020008119064e+000,-9.709142573184e+001,2.123340663013e+001
   11058,-3.030198912506e+000,-9.703915382091e+001,2.162544596209e+001
   11059,-2.062501113750e+000,-9.552093703556e+001,2.177471940424e+000
   11060,-3.513433291125e+000,-9.681444666775e+001,2.331074961085e+001
   11061,-3.126096894271e+000,-9.684405713399e+001,2.308867111405e+001
   11062,-2.062501113750e+000,-9.594598330201e+001,2.716525357144e+001
   11063,-2.062501113750e+000,-9.549989063591e+001,2.728223355240e+001
   11064,-2.062501113750e+000,-9.563797208022e+001,2.691748311386e+001
   11065,-3.513517328548e+000,-9.620246330473e+001,2.790062483344e+001
   11066,-2.062501113750e+000,-9.498081868458e+001,2.639719284906e+001
   11067,-2.062501113750e+000,-9.485260652629e+001,2.663285879223e+001
   11068,-2.062501113750e+000,-9.513416438299e+001,2.657350840367e+001
   11069,-2.062501113750e+000,-9.500595222470e+001,2.680917434684e+001
   11070,-2.062501113750e+000,-9.636587556807e+001,1.556424235024e+001
   11071,-2.062501113750e+000,-8.969844772974e+001,2.760071689502e+001
   11072,-2.062501113750e+000,-9.645856239443e+001,1.765597006676e+001
   11073,-2.062501113750e+000,-9.671339764638e+001,1.758835964771e+001
   11074,-2.062501113750e+000,-9.530103254619e+001,2.699686392006e+001
   11075,-2.062501113750e+000,-9.494458390033e+001,2.706068349156e+001
   11076,-2.062501113750e+000,-9.516295110189e+001,2.736161435860e+001
   11077,-2.062501113750e+000,-9.131808057873e+001,3.717081363503e+001
   11078,-3.522912022624e+000,-9.594005821624e+001,2.986866299717e+001
   11079,-3.522912022624e+000,-9.598785906826e+001,2.951015660700e+001
   11080,-2.062501113750e+000,-9.178112765720e+001,3.724910052204e+001
   11081,-2.062501113750e+000,-9.156788769841e+001,3.720669213188e+001
   11082,-2.062501113750e+000,-9.054540792403e+001,2.997674099119e+001
   11083,-2.062501113750e+000,-9.054988769981e+001,2.639986438618e+001
   11084,-2.062501113750e+000,-9.150239019526e+001,2.863325881807e+001
   11085,-2.062501113750e+000,-9.119467690415e+001,2.863436371739e+001
   11086,-3.225689372863e+000,-9.797253899124e+001,1.462505718466e+001
   11087,-3.526539248122e+000,-9.794482669847e+001,1.483289938041e+001
   11088,-3.393043012874e+000,-8.937504826250e+001,2.635132383722e+001
   11089,-3.344565948254e+000,-8.937504826250e+001,2.660934362719e+001
   11090,-3.081292993344e+000,-8.937504826250e+001,2.635471482422e+001
   11091,-2.062501113750e+000,-9.443627563905e+001,1.830148486872e+001
   11092,-2.062501113750e+000,-9.463405078150e+001,1.833217336938e+001
   11093,-2.062501113750e+000,-9.958659708161e+001,2.519621506881e+000
   11094,-2.062501113750e+000,-9.133101993537e+001,9.729699482690e+000
   11095,-2.062501113750e+000,-9.116322361978e+001,9.649363902610e+000
   11096,-2.062501113750e+000,-9.198883794762e+001,2.693241470327e+001
   11097,-2.062501113750e+000,-9.217944076015e+001,2.691164708884e+001
   11098,-2.062501113750e+000,-9.425870420604e+001,2.979413735759e+000
   11099,-2.062501113750e+000,-9.427389652475e+001,3.364211282263e+000
   11100,-2.062501113750e+000,-9.188932582761e+001,2.706910599719e+001
   11101,-3.690877062622e+000,-8.937504826250e+001,2.647277308858e+001
   11102,-3.135241979504e+000,-8.937504826250e+001,1.228432285078e+001
   11103,-3.078826364436e+000,-8.937504826250e+001,1.201387046059e+001
   11104,-3.667476088801e+000,-8.937504826250e+001,2.105227424698e+001
   11105,-3.394694253114e+000,-8.937504826250e+001,2.091300944005e+001
   11106,-2.062501113750e+000,-9.695628580771e+001,2.206260325854e+000
   11107,-3.631020357967e+000,-9.409792446655e+001,4.368466611981e+001
   11108,-3.689657962092e+000,-8.937504826250e+001,3.900844028933e+001
   11109,-2.062501113750e+000,-9.165188310563e+001,2.861796958446e+001
   11110,-2.062501113750e+000,-9.050739920993e+001,2.434674488267e+000
   11111,-2.062501113750e+000,-9.060977978245e+001,2.198674164186e+000
   11112,-2.062501113750e+000,-9.075705200325e+001,2.435946515414e+000
   11113,-3.390724315633e+000,-8.937504826250e+001,3.883803953069e+001
   11114,-3.375899145614e+000,-8.937504826250e+001,3.915000939009e+001
   11115,-2.062501113750e+000,-9.151604200305e+001,1.786968829027e+001
   11116,-3.635720274903e+000,-8.937504826250e+001,2.075348704697e+001
   11117,-2.558534884791e+000,-9.528784024566e+001,3.476029777649e+001
   11118,-2.558534884791e+000,-9.521912652088e+001,3.527565071236e+001
   11119,-2.062501113750e+000,-8.969152220338e+001,3.129576829228e+001
   11120,-2.062501113750e+000,-8.969152220338e+001,3.165427468245e+001
   11121,-2.062501113750e+000,-9.283150884005e+001,2.805314519833e+001
   11122,-2.062501113750e+000,-8.937504826250e+001,2.624794105709e+001
   11123,-2.396580537448e+000,-8.937504826250e+001,2.604945112974e+001
   11124,-2.062501113750e+000,-8.937504826250e+001,2.586702801753e+001
   11125,-3.037007756374e+000,-9.518919243165e+001,3.550015638155e+001
   11126,-2.062501113750e+000,-9.221820931196e+001,2.444669564827e+000
   11127,-2.062501113750e+000,-9.206950862265e+001,2.721045421288e+000
   11128,-3.199382034088e+000,-9.652185172203e+001,2.550521170370e+001
   11129,-3.623906578321e+000,-9.655222704898e+001,2.527739675160e+001
   11130,-3.691177044699e+000,-8.937504826250e+001,2.418377438957e+001
   11131,-3.397648811800e+000,-8.937504826250e+001,2.432425316450e+001
   11132,-2.062501113750e+000,-9.346851656197e+001,2.859786631768e+001
   11133,-2.062501113750e+000,-9.357529786630e+001,2.847017636882e+001
   11134,-2.062501113750e+000,-9.650705010739e+001,6.798807354204e+000
   11135,-2.062501113750e+000,-9.595115613690e+001,6.553552180778e+000
   11136,-2.062501113750e+000,-9.652321449185e+001,7.407367769492e+000
   11137,-2.062501113750e+000,-9.596732052136e+001,7.162112596066e+000
   11138,-3.218826377075e+000,-9.868945451891e+001,9.248190727139e+000
   11139,-2.062501113750e+000,-9.017065507566e+001,3.345713918307e+001
   11140,-2.062501113750e+000,-9.035180469837e+001,6.639819415481e+000
   11141,-2.062501113750e+000,-9.035808137005e+001,6.261177888460e+000
   11142,-3.394183791775e+000,-8.937504826250e+001,2.717112865483e+001
   11143,-2.062501113750e+000,-9.017063054092e+001,4.530170001670e+001
   11144,-2.062501113750e+000,-9.860408687886e+001,6.517148108894e+000
   11145,-3.014033940867e+000,-9.807986929487e+001,1.382007990742e+001
   11146,-2.062501113750e+000,-9.688003238313e+001,1.016171785641e+001
   11147,-3.338809968253e+000,-8.937504826250e+001,3.568966804321e+001
   11148,-3.599749394426e+000,-8.937504826250e+001,3.583416695390e+001
   11149,-3.631365691857e+000,-8.937504826250e+001,4.183603340558e+001
   11150,-3.631966722979e+000,-8.937504826250e+001,4.213309883729e+001
   11151,-3.335247541382e+000,-8.937504826250e+001,4.198541588497e+001
   11152,-2.062501113750e+000,-9.303300477559e+001,3.679738525681e+001
   11153,-2.062501113750e+000,-9.315863624707e+001,3.672772743035e+001
   11154,-2.062501113750e+000,-9.466262482067e+001,3.666582220225e+001
   11155,-2.062501113750e+000,-9.639371974854e+001,8.536159737602e+000
   11156,-3.672724983270e+000,-9.963739870326e+001,2.138609344481e+000
   11157,-2.062501113750e+000,-9.869209361966e+001,2.174612388828e+000
   11158,-3.620270161317e+000,-9.540920313363e+001,3.385007611674e+001
   11159,-2.869720706038e+000,-9.796868788513e+001,1.465394048047e+001
   11160,-2.062501113750e+000,-8.937504826250e+001,3.364213535437e+001
   11161,-2.398141087237e+000,-8.937504826250e+001,3.350267212140e+001
   11162,-2.062501113750e+000,-9.681067822101e+001,1.479843136172e+001
   11163,-2.062501113750e+000,-9.683190892572e+001,1.452707050140e+001
   11164,-2.062501113750e+000,-9.640400892199e+001,1.527824219580e+001
   11165,-2.062501113750e+000,-9.270121030552e+001,1.903739392481e+001
   11166,-2.062501113750e+000,-9.287875945835e+001,1.928600196989e+001
   11167,-2.062501113750e+000,-9.294245891242e+001,4.259897190568e+001
   11168,-2.062501113750e+000,-9.340368024578e+001,4.244033706656e+001
   11169,-2.062501113750e+000,-9.055292511601e+001,1.626852342176e+001
   11170,-2.062501113750e+000,-9.033097253433e+001,1.600224463164e+001
   11171,-2.062501113750e+000,-9.218371950640e+001,1.797902082647e+001
   11172,-3.331709840187e+000,-8.937504826250e+001,4.538979873368e+001
   11173,-2.062501113750e+000,-9.129583956248e+001,9.376264537133e+000
   11174,-2.062501113750e+000,-8.966549600895e+001,8.076989024923e+000
   11175,-2.770353432623e+000,-8.937504826250e+001,1.229441038336e+001
   11176,-2.062501113750e+000,-9.112652312974e+001,9.463530843902e+000
   11177,-2.062501113750e+000,-9.623959603875e+001,9.043568662134e+000
   11178,-2.062501113750e+000,-9.626348805803e+001,8.774552662909e+000
   11179,-2.062501113750e+000,-9.952977079203e+001,2.945818678716e+000
   11180,-2.062501113750e+000,-8.984859263777e+001,1.176274992541e+001
   11181,-2.062501113750e+000,-9.063205106046e+001,9.961174800726e+000
   11182,-2.062501113750e+000,-9.594249878578e+001,2.263024073161e+001
   11183,-2.062501113750e+000,-9.630113090626e+001,2.282493591999e+001
   11184,-2.062501113750e+000,-9.052239462926e+001,1.019829901044e+001
   11185,-3.647611211359e+000,-8.937504826250e+001,3.445015438240e+001
   11186,-3.183909699865e+000,-9.426127330217e+001,4.245954985269e+001
   11187,-2.420457887677e+000,-8.937504826250e+001,2.646963315321e+000
   11188,-2.062501113750e+000,-9.613111752882e+001,2.361342119818e+001
   11189,-2.062501113750e+000,-9.676478397543e+001,2.368321980323e+001
   11190,-2.062501113750e+000,-9.623540473473e+001,2.331788220648e+001
   11191,-2.062501113750e+000,-9.639915713999e+001,2.082188452316e+001
   11192,-2.062501113750e+000,-9.109500461197e+001,9.244376526668e+000
   11193,-2.062501113750e+000,-9.240152555377e+001,2.768944383078e+001
   11194,-2.062501113750e+000,-9.216662097484e+001,2.753794675855e+001
   11195,-2.062501113750e+000,-9.237908512839e+001,2.737797740047e+001
   11196,-2.062501113750e+000,-9.319210496746e+001,2.790324174887e+001
   11197,-2.062501113750e+000,-9.052722358030e+001,2.219966590341e+001
   11198,-3.035759904360e+000,-8.937504826250e+001,3.584840866176e+001
   11199,-2.062501113750e+000,-8.972644805751e+001,3.419889867927e+001
   11200,-2.062501113750e+000,-9.014746853867e+001,3.412604347662e+001
   11201,-2.062501113750e+000,-9.078025595808e+001,2.408368026077e+001
   11202,-2.062501113750e+000,-9.079541723201e+001,2.441225297185e+001
   11203,-3.344520639073e+000,-8.937504826250e+001,2.487605580057e+001
   11204,-2.062501113750e+000,-9.082274344571e+001,2.489930322881e+001
   11205,-2.062501113750e+000,-9.079541723201e+001,2.467625311441e+001
   11206,-3.075594596475e+000,-8.937504826250e+001,3.025153897803e+001
   11207,-3.085570757154e+000,-8.937504826250e+001,2.994365751665e+001
   11208,-3.611854154718e+000,-8.937504826250e+001,2.874888446555e+001
   11209,-3.375918040321e+000,-8.937504826250e+001,3.686833232915e+001
   11210,-3.327780899850e+000,-8.937504826250e+001,3.712673315071e+001
   11211,-2.062501113750e+000,-9.417251544488e+001,3.287490948639e+001
   11212,-2.062501113750e+000,-9.298144857855e+001,1.951959259845e+001
   11213,-2.062501113750e+000,-9.122151946550e+001,3.649633424046e+000
   11214,-2.062501113750e+000,-9.083768485811e+001,3.571826674286e+001
   11215,-2.062501113750e+000,-8.991743804404e+001,1.888736184358e+001
   11216,-2.062501113750e+000,-9.243890457361e+001,6.965477222771e+000
   11217,-2.733196008014e+000,-8.937504826250e+001,4.274621854516e+001
   11218,-2.435469637651e+000,-9.419201359835e+001,4.297899763130e+001
   11219,-3.028060768053e+000,-9.813535742908e+001,1.340391890082e+001
   11220,-2.062501113750e+000,-8.962858099360e+001,1.905808973053e+001
   11221,-2.062501113750e+000,-9.054772698146e+001,3.609746777807e+001
   11222,-2.531817047046e+000,-9.583801677329e+001,3.063397381929e+001
   11223,-2.970623755015e+000,-9.586323087647e+001,3.044486804542e+001
   11224,-2.531817047046e+000,-9.589478028506e+001,3.020824748096e+001
   11225,-2.062501113750e+000,-9.073551523171e+001,3.257835063225e+001
   11226,-2.062501113750e+000,-9.039687926607e+001,3.243561859112e+001
   11227,-2.437209943943e+000,-8.937504826250e+001,3.311158389476e+001
   11228,-3.506508529631e+000,-9.571841485215e+001,3.153098822780e+001
   11229,-2.062501113750e+000,-9.720575586377e+001,1.762644911552e+001
   11230,-2.062501113750e+000,-9.700088126566e+001,1.737452937682e+001
   11231,-2.062501113750e+000,-9.692637168798e+001,1.789599436592e+001
   11232,-2.732920075345e+000,-8.937504826250e+001,3.329116980937e+001
   11233,-2.062501113750e+000,-9.856129140388e+001,1.020941408987e+001
   11234,-3.395062255995e+000,-8.937504826250e+001,1.257174216493e+001
   11235,-3.634949930157e+000,-8.937504826250e+001,1.646347065981e+001
   11236,-2.392094018745e+000,-8.937504826250e+001,7.336244512249e+000
   11237,-2.667292348216e+000,-9.727591310398e+001,1.984975133913e+001
   11238,-2.062501113750e+000,-9.035929545124e+001,1.004510822674e+001
   11239,-2.062501113750e+000,-9.027009658156e+001,9.658373992676e+000
   11240,-2.062501113750e+000,-9.053688182569e+001,9.766947102535e+000
   11241,-2.062501113750e+000,-9.325211589113e+001,7.475290165005e+000
   11242,-3.644823471294e+000,-8.937504826250e+001,1.587781665911e+001
   11243,-2.062501113750e+000,-9.529211985216e+001,2.590357413489e+001
   11244,-2.062501113750e+000,-9.548382270175e+001,2.607050019576e+001
   11245,-2.062501113750e+000,-9.524760089463e+001,2.606081646690e+001
   11246,-2.062501113750e+000,-9.620881491851e+001,2.785298773011e+001
   11247,-2.062501113750e+000,-9.626856598354e+001,2.740485474239e+001
   11248,-2.062501113750e+000,-9.246988310655e+001,6.495224796504e+000
   11249,-2.062501113750e+000,-9.278967519387e+001,4.440082766944e+000
   11250,-2.677305279080e+000,-8.937504826250e+001,1.663566732550e+001
   11251,-3.028152635610e+000,-8.937504826250e+001,1.679359013388e+001
   11252,-3.228566254911e+000,-9.529061580919e+001,3.473948105001e+001
   11253,-2.062501113750e+000,-9.362765868654e+001,3.715805032526e+001
   11254,-2.062501113750e+000,-8.937504826250e+001,3.595002024110e+001
   11255,-2.062501113750e+000,-8.970016683912e+001,3.616142854855e+001
   11256,-2.062501113750e+000,-8.970016683912e+001,3.575810885961e+001
   11257,-2.062501113750e+000,-9.132612091442e+001,3.678852227145e+001
   11258,-3.048871455980e+000,-8.937504826250e+001,2.727898340687e+001
   11259,-3.025072624427e+000,-8.937504826250e+001,4.622614016060e+001
   11260,-3.612387454838e+000,-8.937504826250e+001,2.334608203897e+001
   11261,-2.062501113750e+000,-9.180331683213e+001,2.688670573892e+001
   11262,-2.439735236857e+000,-8.937504826250e+001,1.835824576447e+001
   11263,-2.390496119025e+000,-8.937504826250e+001,1.873042022922e+001
   11264,-2.062501113750e+000,-9.107009700033e+001,2.892303492392e+001
