    4225,-1.937501046250e+000,-9.019757464200e+001,1.568710683637e+001
    4226,-1.937501046250e+000,-9.003017093801e+001,1.120473304831e+001
    4227,-1.937501046250e+000,-9.013251691106e+001,4.588214875747e+001
    4228,-1.937501046250e+000,-8.998147865769e+001,4.559655319555e+001
    4229,-1.937501046250e+000,-9.043318607833e+001,4.588807708636e+001
    4230,-1.937501046250e+000,-9.384853590283e+001,8.960650502394e+000
    4231,-1.937501046250e+000,-9.357109003861e+001,8.968886924253e+000
    4232,-1.937501046250e+000,-9.398215250667e+001,8.684460889768e+000
    4233,-1.937501046250e+000,-9.024335688158e+001,9.179363330815e+000
    4234,-1.937501046250e+000,-9.018791036392e+001,8.791403708993e+000
    4235,-1.937501046250e+000,-9.016187384219e+001,8.461381084643e+000
    4236,-1.937501046250e+000,-9.014403144707e+001,8.095490917719e+000
    4237,-1.937501046250e+000,-9.048315572797e+001,8.622428010318e+000
    4238,-1.937501046250e+000,-9.015073096130e+001,7.744255098031e+000
    4239,-1.937501046250e+000,-9.014659664681e+001,7.380506723306e+000
    4240,-1.937501046250e+000,-9.046381872047e+001,7.941169566281e+000
    4241,-1.937501046250e+000,-9.015722230215e+001,6.998387692953e+000
    4242,-1.937501046250e+000,-9.016068729720e+001,6.626618757673e+000
    4243,-1.937501046250e+000,-9.048114389004e+001,7.207814716240e+000
    4244,-1.937501046250e+000,-9.016696396887e+001,6.247977230652e+000
    4245,-1.937501046250e+000,-9.016740924472e+001,5.869038340854e+000
    4246,-1.937501046250e+000,-9.049804621706e+001,6.447054158865e+000
    4247,-1.937501046250e+000,-9.016386087078e+001,5.457090643218e+000
    4248,-1.937501046250e+000,-9.016177718992e+001,5.082392582014e+000
    4249,-1.937501046250e+000,-9.050077451480e+001,5.656464934207e+000
    4250,-1.937501046250e+000,-9.015284278329e+001,4.686365224291e+000
    4251,-1.937501046250e+000,-9.014084416828e+001,4.316688823325e+000
    4252,-1.937501046250e+000,-9.048829173422e+001,4.848489878848e+000
    4253,-1.937501046250e+000,-9.008768376343e+001,3.933485956206e+000
    4254,-1.937501046250e+000,-9.006510351425e+001,3.588148436602e+000
    4255,-1.937501046250e+000,-9.042619692275e+001,4.069259654007e+000
    4256,-1.937501046250e+000,-9.333791602255e+001,4.629058093308e+001
    4257,-1.937501046250e+000,-9.316139283989e+001,4.630765862828e+001
    4258,-1.937501046250e+000,-9.338339967628e+001,4.606795288896e+001
    4259,-1.937501046250e+000,-9.298869477777e+001,4.631024905425e+001
    4260,-1.937501046250e+000,-9.281474680578e+001,4.630503640979e+001
    4261,-1.937501046250e+000,-9.305393169274e+001,4.615191710504e+001
    4262,-1.937501046250e+000,-9.501145292804e+001,9.035287160930e+000
    4263,-1.937501046250e+000,-9.473819160896e+001,9.004350013590e+000
    4264,-1.937501046250e+000,-9.515971545932e+001,8.790859517052e+000
    4265,-1.937501046250e+000,-9.370983268051e+001,4.659535451513e+001
    4266,-1.937501046250e+000,-9.721445100300e+001,9.738060219110e+000
    4267,-1.937501046250e+000,-9.707443748239e+001,9.545840080131e+000
    4268,-1.937501046250e+000,-9.732380562463e+001,1.030571263656e+001
    4269,-1.937501046250e+000,-9.728369627531e+001,1.009842402457e+001
    4270,-1.937501046250e+000,-9.622987011368e+001,1.770555589761e+001
    4271,-1.937501046250e+000,-9.633412113152e+001,1.750830270752e+001
    4272,-1.937501046250e+000,-9.566737282060e+001,1.812293383203e+001
    4273,-1.937501046250e+000,-9.589614933012e+001,1.800272660185e+001
    4274,-1.937501046250e+000,-9.526481168596e+001,1.828272946060e+001
    4275,-1.937501046250e+000,-9.545457273503e+001,1.825059072086e+001
    4276,-1.937501046250e+000,-9.518605128696e+001,1.844944608164e+001
    4277,-1.937501046250e+000,-9.393336711444e+001,1.841062639604e+001
    4278,-1.937501046250e+000,-9.415587644458e+001,1.842609249076e+001
    4279,-1.937501046250e+000,-9.079856599202e+001,1.785606195227e+001
    4280,-1.937501046250e+000,-9.095077134996e+001,1.800519907143e+001
    4281,-1.937501046250e+000,-9.056318560418e+001,1.739966515826e+001
    4282,-1.937501046250e+000,-9.064188826708e+001,1.758805002169e+001
    4283,-1.937501046250e+000,-9.091017835933e+001,9.568629713873e+000
    4284,-1.937501046250e+000,-9.076524615340e+001,9.711794770104e+000
    4285,-1.937501046250e+000,-9.497222324462e+001,2.680738973080e+001
    4286,-1.937501046250e+000,-9.508228156106e+001,2.659850793055e+001
    4287,-1.937501046250e+000,-9.441270396157e+001,2.712836923962e+001
    4288,-1.937501046250e+000,-9.463937642423e+001,2.705833137410e+001
    4289,-1.937501046250e+000,-9.402132455537e+001,2.716217127732e+001
    4290,-1.937501046250e+000,-9.419390345512e+001,2.714315353980e+001
    4291,-1.937501046250e+000,-9.275085022122e+001,2.751936510728e+001
    4292,-1.937501046250e+000,-9.304774117238e+001,2.750479819735e+001
    4293,-1.937501046250e+000,-9.074656715667e+001,2.692695837556e+001
    4294,-1.937501046250e+000,-9.090432856020e+001,2.705081184680e+001
    4295,-1.937501046250e+000,-9.055382275394e+001,2.642104611920e+001
    4296,-1.937501046250e+000,-9.061397799287e+001,2.662131770347e+001
    4297,-1.937501046250e+000,-9.052503003855e+001,2.602501974820e+001
    4298,-1.937501046250e+000,-9.055588604748e+001,2.619323485204e+001
    4299,-1.937501046250e+000,-9.031783181290e+001,2.598704718131e+001
    4300,-1.937501046250e+000,-9.100046303753e+001,1.954485563074e+001
    4301,-1.937501046250e+000,-9.085351864091e+001,1.967280151651e+001
    4302,-1.937501046250e+000,-9.137734828230e+001,1.935605392397e+001
    4303,-1.937501046250e+000,-9.120027161805e+001,1.943843111785e+001
    4304,-1.937501046250e+000,-9.172860301275e+001,1.941647205261e+001
    4305,-1.937501046250e+000,-9.535955795282e+001,1.938193529666e+001
    4306,-1.937501046250e+000,-9.515427330053e+001,1.931288722235e+001
    4307,-1.937501046250e+000,-9.578688088069e+001,1.970796083047e+001
    4308,-1.937501046250e+000,-9.562249005933e+001,1.953007108930e+001
    4309,-1.937501046250e+000,-9.593311496697e+001,2.032983526808e+001
    4310,-1.937501046250e+000,-9.590833414539e+001,2.011489312035e+001
    4311,-1.937501046250e+000,-9.469848139933e+001,2.953334359597e+001
    4312,-1.937501046250e+000,-9.874743738369e+001,2.836521674027e+000
    4313,-1.937501046250e+000,-9.371337339974e+001,3.668627668377e+001
    4314,-1.937501046250e+000,-9.378951141298e+001,3.650553442367e+001
    4315,-1.937501046250e+000,-9.341038241858e+001,3.704601206395e+001
    4316,-1.937501046250e+000,-9.356177511851e+001,3.693395131271e+001
    4317,-1.937501046250e+000,-9.299859893883e+001,3.715343853044e+001
    4318,-1.937501046250e+000,-9.315761291692e+001,3.708934451618e+001
    4319,-1.937501046250e+000,-9.339757260608e+001,3.723418842029e+001
    4320,-1.937501046250e+000,-9.295329693275e+001,3.737725126409e+001
    4321,-1.937501046250e+000,-9.071350958122e+001,3.678300687713e+001
    4322,-1.937501046250e+000,-9.086189538730e+001,3.693747076853e+001
    4323,-1.937501046250e+000,-9.056114028901e+001,3.631896141299e+001
    4324,-1.937501046250e+000,-9.061522654605e+001,3.649647967184e+001
    4325,-1.937501046250e+000,-9.021269471483e+001,3.466180854469e+001
    4326,-1.937501046250e+000,-9.099630743439e+001,2.859266523683e+001
    4327,-1.937501046250e+000,-9.084674635175e+001,2.872939837397e+001
    4328,-1.937501046250e+000,-9.131829989483e+001,2.834643970624e+001
    4329,-1.937501046250e+000,-9.116334193970e+001,2.843309836032e+001
    4330,-1.937501046250e+000,-9.096410901890e+001,2.837909426539e+001
    4331,-1.937501046250e+000,-9.137135799205e+001,2.808967387079e+001
    4332,-1.937501046250e+000,-9.267456110789e+001,2.809440956739e+001
    4333,-1.937501046250e+000,-9.242924038745e+001,2.811304352010e+001
    4334,-1.937501046250e+000,-9.277329064660e+001,2.783083153760e+001
    4335,-1.937501046250e+000,-9.476814879136e+001,2.931381492009e+001
    4336,-1.937501046250e+000,-9.474380520136e+001,2.910661492963e+001
    4337,-1.937501046250e+000,-9.866084216169e+001,3.312894133887e+000
    4338,-1.937501046250e+000,-9.839846284000e+001,3.710922950419e+000
    4339,-1.937501046250e+000,-9.826735296783e+001,4.225913488469e+000
    4340,-1.937501046250e+000,-9.776118487558e+001,4.362150569369e+000
    4341,-1.937501046250e+000,-9.816413396339e+001,3.415596418136e+000
    4342,-1.937501046250e+000,-9.774480919180e+001,1.066019911583e+001
    4343,-1.937501046250e+000,-9.760231617020e+001,1.106600472498e+001
    4344,-1.937501046250e+000,-9.679393434994e+001,1.744202776938e+001
    4345,-1.937501046250e+000,-9.671942477226e+001,1.796349275848e+001
    4346,-1.937501046250e+000,-9.010329675787e+001,2.704869067750e+000
    4347,-1.937501046250e+000,-9.038259890050e+001,2.723587506833e+000
    4348,-1.937501046250e+000,-9.050139045419e+001,3.051738286258e+000
    4349,-1.937501046250e+000,-8.995118516337e+001,2.936099418874e+000
    4350,-1.937501046250e+000,-9.020928769947e+001,4.103529738303e+001
    4351,-1.937501046250e+000,-9.023121146273e+001,4.066517796645e+001
    4352,-1.937501046250e+000,-9.073734462161e+001,4.050497099982e+001
    4353,-1.937501046250e+000,-9.059323797295e+001,4.124277857926e+001
    4354,-1.937501046250e+000,-9.165418840258e+001,4.567256545733e+001
    4355,-1.937501046250e+000,-9.134388309344e+001,4.572272427735e+001
    4356,-1.937501046250e+000,-9.041743541352e+001,1.071002382164e+001
    4357,-1.937501046250e+000,-9.008441519938e+001,1.688697001255e+001
    4358,-1.937501046250e+000,-9.040068536995e+001,1.678182512198e+001
    4359,-1.937501046250e+000,-9.051551269361e+001,1.698789888604e+001
    4360,-1.937501046250e+000,-9.007811788858e+001,1.721378170205e+001
    4361,-1.937501046250e+000,-9.040162519542e+001,2.973593155662e+001
    4362,-1.937501046250e+000,-9.459364490934e+001,8.717580553508e+000
    4363,-1.937501046250e+000,-9.613669395636e+001,2.045805853575e+001
    4364,-1.937501046250e+000,-9.653166779358e+001,1.693315497421e+001
    4365,-1.937501046250e+000,-9.749634287386e+001,1.044707154355e+001
    4366,-1.937501046250e+000,-9.246437550130e+001,1.853617120135e+001
    4367,-1.937501046250e+000,-9.275535492635e+001,1.850953368065e+001
    4368,-1.937501046250e+000,-9.739595567301e+001,1.145801874147e+001
    4369,-1.937501046250e+000,-9.744096199990e+001,1.124853579745e+001
    4370,-1.937501046250e+000,-9.492648186946e+001,2.888796619188e+001
    4371,-1.937501046250e+000,-9.465258614971e+001,1.831159956360e+001
    4372,-1.937501046250e+000,-9.475227070423e+001,1.846877788595e+001
    4373,-1.937501046250e+000,-9.444477935914e+001,1.834206469878e+001
    4374,-1.937501046250e+000,-9.018408418857e+001,1.089537993784e+001
    4375,-1.937501046250e+000,-9.191457069524e+001,1.867054209288e+001
    4376,-1.937501046250e+000,-9.218865827011e+001,1.858201588159e+001
    4377,-1.937501046250e+000,-9.306984169332e+001,1.848802339198e+001
    4378,-1.937501046250e+000,-9.334030721076e+001,1.848127390722e+001
    4379,-1.937501046250e+000,-9.680878500669e+001,1.695184562337e+001
    4380,-1.937501046250e+000,-9.741745490363e+001,1.169515661921e+001
    4381,-1.937501046250e+000,-9.369635531597e+001,1.846292118450e+001
    4382,-1.937501046250e+000,-9.122230084533e+001,1.814098236031e+001
    4383,-1.937501046250e+000,-9.139715448510e+001,1.820508519303e+001
    4384,-1.937501046250e+000,-9.052903868449e+001,9.736719153082e+000
    4385,-1.937501046250e+000,-9.063877023987e+001,9.943345721449e+000
    4386,-1.937501046250e+000,-9.624865492831e+001,2.111978306721e+001
    4387,-1.937501046250e+000,-9.052545288166e+001,1.714609885397e+001
    4388,-1.937501046250e+000,-9.036629191794e+001,1.731610184931e+001
    4389,-1.937501046250e+000,-9.562620907796e+001,1.837785633759e+001
    4390,-1.937501046250e+000,-9.056478491262e+001,2.005182171129e+001
    4391,-1.937501046250e+000,-9.037755191320e+001,2.008606876141e+001
    4392,-1.937501046250e+000,-9.177148125464e+001,2.727703820947e+001
    4393,-1.937501046250e+000,-9.182139380030e+001,2.749857088242e+001
    4394,-1.937501046250e+000,-9.158823361223e+001,2.722953979947e+001
    4395,-1.937501046250e+000,-9.130264003562e+001,9.325670602007e+000
    4396,-1.937501046250e+000,-9.113332360287e+001,9.412936908776e+000
    4397,-1.937501046250e+000,-9.225679720621e+001,2.770937737968e+001
    4398,-1.937501046250e+000,-9.246926135975e+001,2.754940802160e+001
    4399,-1.937501046250e+000,-9.509880731546e+001,2.639752444721e+001
    4400,-1.937501046250e+000,-9.516030641858e+001,2.622088824648e+001
    4401,-1.937501046250e+000,-9.051710796703e+001,1.834353063687e+001
    4402,-1.937501046250e+000,-9.031821034829e+001,1.809744442221e+001
    4403,-1.937501046250e+000,-9.525215301387e+001,2.657384000181e+001
    4404,-1.937501046250e+000,-9.141567326590e+001,2.734712414742e+001
    4405,-1.937501046250e+000,-9.597004289160e+001,1.990065889250e+001
    4406,-1.937501046250e+000,-9.605265932945e+001,1.961978061295e+001
    4407,-1.937501046250e+000,-9.617411259415e+001,2.002671290283e+001
    4408,-1.937501046250e+000,-9.423598743480e+001,1.886261345838e+001
    4409,-1.937501046250e+000,-9.010697504860e+001,2.033443650783e+001
    4410,-1.937501046250e+000,-9.249925318034e+001,1.906132885852e+001
    4411,-1.937501046250e+000,-9.235125502226e+001,1.883780312198e+001
    4412,-1.937501046250e+000,-9.048149905429e+001,2.065178405410e+001
    4413,-1.937501046250e+000,-9.044273995065e+001,2.082666045924e+001
    4414,-1.937501046250e+000,-9.064182828085e+001,1.986049147559e+001
    4415,-1.937501046250e+000,-9.280452140628e+001,1.904056648683e+001
    4416,-1.937501046250e+000,-9.059375394521e+001,1.964895329168e+001
    4417,-1.937501046250e+000,-9.294145902042e+001,1.877044815308e+001
    4418,-1.937501046250e+000,-9.490745917923e+001,1.933892726869e+001
    4419,-1.937501046250e+000,-9.472320503386e+001,1.931068418364e+001
    4420,-1.937501046250e+000,-9.467696886736e+001,1.909794277805e+001
    4421,-1.937501046250e+000,-9.087865984156e+001,9.349475396639e+000
    4422,-1.937501046250e+000,-9.380556280131e+001,3.629381681359e+001
    4423,-1.937501046250e+000,-9.385665628082e+001,3.613257575460e+001
    4424,-1.937501046250e+000,-9.092045086888e+001,2.724050078657e+001
    4425,-1.937501046250e+000,-9.132210725138e+001,3.718283614655e+001
    4426,-1.937501046250e+000,-9.138361314120e+001,3.741047867888e+001
    4427,-1.937501046250e+000,-9.113951785389e+001,3.709846578233e+001
    4428,-1.937501046250e+000,-9.043705239087e+001,3.576296182860e+001
    4429,-1.937501046250e+000,-9.015571122315e+001,3.599474739000e+001
    4430,-1.937501046250e+000,-9.213628800281e+001,4.559669551927e+001
    4431,-1.937501046250e+000,-9.199120373043e+001,4.521576809371e+001
    4432,-1.937501046250e+000,-9.430869072049e+001,2.840283530815e+001
    4433,-1.937501046250e+000,-9.422457787473e+001,2.823449288311e+001
    4434,-1.937501046250e+000,-9.465783342616e+001,2.836969261283e+001
    4435,-1.937501046250e+000,-9.150702134024e+001,1.841734748803e+001
    4436,-1.937501046250e+000,-9.056566194898e+001,1.012146088813e+001
    4437,-1.937501046250e+000,-9.405758082071e+001,3.611690782681e+001
    4438,-1.937501046250e+000,-9.536105219818e+001,2.623152344760e+001
    4439,-1.937501046250e+000,-9.032257071474e+001,2.051425438838e+001
    4440,-1.937501046250e+000,-9.509681898422e+001,1.915685101198e+001
    4441,-1.937501046250e+000,-9.396959005854e+001,3.648378910009e+001
    4442,-1.937501046250e+000,-9.084849553741e+001,3.716576176542e+001
    4443,-1.937501046250e+000,-9.059702901619e+001,2.870524992199e+001
    4444,-1.937501046250e+000,-9.064670085436e+001,2.889598715406e+001
    4445,-1.937501046250e+000,-9.036214546831e+001,2.916113710669e+001
    4446,-1.937501046250e+000,-9.010650742228e+001,2.903084890489e+001
    4447,-1.937501046250e+000,-9.198546540160e+001,2.821634654706e+001
    4448,-1.937501046250e+000,-9.184282793595e+001,2.798928276482e+001
    4449,-1.937501046250e+000,-9.222043120089e+001,2.819197888261e+001
    4450,-1.937501046250e+000,-9.252937503172e+001,8.810339539639e+000
    4451,-1.937501046250e+000,-9.655784202926e+001,9.256692310975e+000
    4452,-1.937501046250e+000,-9.650476609632e+001,9.026985053128e+000
    4453,-1.937501046250e+000,-9.676388328213e+001,9.342993329365e+000
    4454,-1.937501046250e+000,-9.777597914934e+001,9.134203147807e+000
    4455,-1.937501046250e+000,-9.774620408896e+001,9.654731436472e+000
    4456,-1.937501046250e+000,-9.776280247318e+001,1.305844013449e+001
    4457,-1.937501046250e+000,-9.324964499769e+001,4.556767176184e+001
    4458,-1.937501046250e+000,-9.327249216176e+001,4.586703918279e+001
    4459,-1.937501046250e+000,-9.733008679081e+001,8.888798142992e+000
    4460,-1.937501046250e+000,-9.650592430732e+001,1.851657991539e+001
    4461,-1.937501046250e+000,-9.642209722857e+001,1.902253654018e+001
    4462,-1.937501046250e+000,-9.580620216564e+001,2.553292866238e+001
    4463,-1.937501046250e+000,-9.648343995712e+001,2.255953998921e+001
    4464,-1.937501046250e+000,-9.631269605878e+001,2.367027792245e+001
    4465,-2.062501113750e+000,-9.480746768984e+001,1.936726473612e+000
    4466,-1.937501046250e+000,-9.228289259857e+001,2.793980981442e+001
    4467,-1.937501046250e+000,-9.012998266485e+001,2.867527819209e+001
    4468,-1.937501046250e+000,-9.708114916497e+001,9.266173796691e+000
    4469,-1.937501046250e+000,-9.597447355966e+001,1.909455745250e+001
    4470,-1.937501046250e+000,-9.631712098745e+001,1.935506163859e+001
    4471,-1.937501046250e+000,-9.036623507567e+001,1.020580810873e+001
    4472,-1.937501046250e+000,-9.012491184536e+001,1.005708122549e+001
    4473,-1.937501046250e+000,-9.515024688009e+001,3.244450541658e+001
    4474,-1.937501046250e+000,-9.640974033549e+001,2.026733580868e+001
    4475,-1.937501046250e+000,-9.248189929681e+001,3.752778714188e+001
    4476,-1.937501046250e+000,-8.998497239512e+001,3.238396622612e+000
    4477,-1.937501046250e+000,-9.327792557503e+001,8.740279717977e+000
    4478,-1.937501046250e+000,-9.005078277389e+001,4.527024781337e+001
    4479,-1.937501046250e+000,-9.258392927983e+001,4.629662589456e+001
    4480,-1.937501046250e+000,-9.059966882500e+001,3.734757801798e+001
    4481,-1.937501046250e+000,-9.024262906501e+001,3.720599558259e+001
    4482,-1.937501046250e+000,-9.021527311103e+001,3.685093952773e+001
    4483,-1.937501046250e+000,-9.011699007587e+001,3.656441232245e+001
    4484,-1.937501046250e+000,-9.013729617436e+001,3.620061475406e+001
    4485,-1.937501046250e+000,-9.056508467518e+001,2.766389756617e+001
    4486,-1.937501046250e+000,-9.026364865437e+001,2.749597752559e+001
    4487,-1.937501046250e+000,-9.100525288579e+001,1.935483881972e+001
    4488,-1.937501046250e+000,-9.024517894122e+001,2.709317515462e+001
    4489,-1.937501046250e+000,-9.011258977742e+001,2.678753448253e+001
    4490,-1.937501046250e+000,-9.010430126075e+001,2.640553256593e+001
    4491,-1.937501046250e+000,-9.029290539878e+001,3.336304972898e+000
    4492,-1.937501046250e+000,-9.181476738203e+001,1.892192289203e+001
    4493,-1.937501046250e+000,-9.173078395010e+001,1.916472427297e+001
    4494,-1.937501046250e+000,-9.165380028620e+001,1.870881718269e+001
    4495,-1.937501046250e+000,-9.036733514521e+001,2.638692212434e+001
    4496,-1.937501046250e+000,-9.056070236540e+001,1.783768008418e+001
    4497,-1.937501046250e+000,-9.031651805573e+001,9.455722114349e+000
    4498,-1.937501046250e+000,-9.058235342386e+001,9.228809418203e+000
    4499,-1.937501046250e+000,-9.155181603564e+001,1.921194576148e+001
    4500,-1.937501046250e+000,-9.047871998164e+001,4.518955130570e+001
    4501,-1.937501046250e+000,-9.103345665973e+001,4.587408083695e+001
    4502,-1.937501046250e+000,-9.074154374948e+001,4.590059429984e+001
    4503,-1.937501046250e+000,-9.057989359162e+001,4.558183393749e+001
    4504,-1.937501046250e+000,-9.119867769649e+001,4.544299459137e+001
    4505,-1.937501046250e+000,-9.647144908170e+001,2.005310158084e+001
    4506,-1.937501046250e+000,-9.044835134495e+001,2.848680954938e+001
    4507,-1.937501046250e+000,-9.265041610467e+001,4.614609701577e+001
    4508,-1.937501046250e+000,-9.746094863754e+001,9.829384352913e+000
    4509,-1.937501046250e+000,-9.651681713682e+001,1.742333712021e+001
    4510,-1.937501046250e+000,-9.098890958570e+001,1.824147530365e+001
    4511,-1.937501046250e+000,-9.435113311223e+001,2.729149107193e+001
    4512,-1.937501046250e+000,-9.491085492025e+001,2.705889887552e+001
    4513,-1.937501046250e+000,-9.517425893509e+001,2.702633262988e+001
    4514,-1.937501046250e+000,-9.484141211470e+001,2.727727427318e+001
    4515,-1.937501046250e+000,-9.176538610068e+001,9.146583424954e+000
    4516,-1.937501046250e+000,-9.154843919794e+001,9.207545591997e+000
    4517,-1.937501046250e+000,-9.134760424743e+001,9.075657581532e+000
    4518,-1.937501046250e+000,-9.188208945201e+001,8.889691432506e+000
    4519,-1.937501046250e+000,-9.366445063958e+001,2.718967296192e+001
    4520,-1.937501046250e+000,-9.385634241815e+001,2.716006997711e+001
    4521,-1.937501046250e+000,-9.560656521203e+001,1.927894675827e+001
    4522,-1.937501046250e+000,-9.047259003566e+001,3.671823954633e+001
    4523,-1.937501046250e+000,-9.380194038898e+001,3.694318133912e+001
    4524,-1.937501046250e+000,-9.055881498857e+001,2.906951538007e+001
    4525,-2.062501113750e+000,-9.709290286107e+001,1.936726473612e+000
    4526,-2.386730788834e+000,-9.966431641938e+001,1.936726473612e+000
    4527,-2.062501113750e+000,-9.966431641938e+001,1.936726473612e+000
    4528,-1.937501046250e+000,-9.370181556587e+001,3.813587670654e+001
    4529,-1.937501046250e+000,-9.368561224860e+001,3.859922908109e+001
    4530,-1.937501046250e+000,-9.019004214220e+001,9.687273065694e+000
    4531,-1.937501046250e+000,-9.362728798421e+001,2.742197141999e+001
    4532,-1.937501046250e+000,-9.369799522209e+001,3.779223993808e+001
    4533,-1.937501046250e+000,-9.388950801420e+001,3.751860471923e+001
    4534,-1.937501046250e+000,-9.345882931564e+001,3.746449118690e+001
    4535,-1.937501046250e+000,-9.320551406506e+001,3.883615462770e+001
    4536,-1.937501046250e+000,-9.396735046856e+001,2.730417407189e+001
    4537,-1.937501046250e+000,-9.425694491236e+001,1.862820462701e+001
    4538,-1.937501046250e+000,-9.011585061110e+001,1.746734800634e+001
    4539,-1.937501046250e+000,-9.010636455429e+001,2.617772129877e+001
    4540,-1.937501046250e+000,-9.574642939659e+001,1.863377279025e+001
    4541,-1.937501046250e+000,-9.595922948216e+001,1.850611590142e+001
    4542,-1.937501046250e+000,-9.080549866740e+001,9.073116613105e+000
    4543,-1.937501046250e+000,-9.062091038869e+001,1.869680282846e+001
    4544,-1.937501046250e+000,-9.082118251200e+001,1.845896420636e+001
    4545,-1.937501046250e+000,-9.109271200737e+001,1.859474749524e+001
    4546,-1.937501046250e+000,-9.060627836335e+001,1.902228142881e+001
    4547,-1.937501046250e+000,-9.424365714255e+001,2.748724396333e+001
    4548,-1.937501046250e+000,-9.446245764900e+001,2.747245966316e+001
    4549,-1.937501046250e+000,-9.204798801965e+001,2.778831274219e+001
    4550,-1.937501046250e+000,-9.514292746983e+001,1.896843897405e+001
    4551,-1.937501046250e+000,-9.489611334853e+001,1.899447902039e+001
    4552,-1.937501046250e+000,-9.064839684233e+001,2.832022076928e+001
    4553,-1.937501046250e+000,-9.008608701742e+001,2.563654373789e+001
    4554,-1.937501046250e+000,-9.054650804915e+001,1.934679489614e+001
    4555,-1.937501046250e+000,-9.550082908013e+001,2.643864250592e+001
    4556,-1.937501046250e+000,-9.559320251004e+001,2.629730943505e+001
    4557,-1.937501046250e+000,-9.472307735297e+001,1.890953074012e+001
    4558,-1.937501046250e+000,-9.325354357257e+001,2.767132934579e+001
    4559,-1.937501046250e+000,-9.499346389982e+001,2.994619432826e+001
    4560,-1.937501046250e+000,-9.508466249358e+001,2.975089911082e+001
    4561,-1.937501046250e+000,-9.537852104895e+001,1.881816209602e+001
    4562,-1.937501046250e+000,-9.571154145315e+001,1.894642165986e+001
    4563,-1.937501046250e+000,-9.109375062850e+001,8.915393485163e+000
    4564,-1.937501046250e+000,-9.079744421080e+001,8.794727506727e+000
    4565,-1.937501046250e+000,-9.077140768907e+001,8.464704882377e+000
    4566,-1.937501046250e+000,-9.133954979082e+001,8.797268475154e+000
    4567,-1.937501046250e+000,-9.181673254358e+001,2.775885033008e+001
    4568,-1.937501046250e+000,-9.081543134765e+001,2.816065389277e+001
    4569,-1.937501046250e+000,-9.005479792843e+001,2.600565762290e+001
    4570,-1.937501046250e+000,-9.010288924823e+001,2.089195232842e+001
    4571,-1.937501046250e+000,-9.403712786224e+001,2.811715025111e+001
    4572,-1.937501046250e+000,-9.385656795228e+001,2.798380057540e+001
    4573,-1.937501046250e+000,-9.425296794865e+001,2.806982527561e+001
    4574,-1.937501046250e+000,-9.452489034936e+001,1.877858566640e+001
    4575,-1.937501046250e+000,-9.266858031143e+001,8.519872151228e+000
    4576,-1.937501046250e+000,-9.230998077398e+001,8.531382905079e+000
    4577,-1.937501046250e+000,-9.706321038522e+001,5.092375511396e+000
    4578,-1.937501046250e+000,-9.694844652286e+001,5.665396541240e+000
    4579,-1.937501046250e+000,-9.701953259055e+001,8.685951392226e+000
    4580,-1.937501046250e+000,-9.678961844511e+001,6.281737203133e+000
    4581,-1.937501046250e+000,-9.671709232144e+001,6.863153048807e+000
    4582,-1.937501046250e+000,-9.634697758323e+001,5.890415780615e+000
    4583,-1.937501046250e+000,-9.673325670590e+001,7.471713464095e+000
    4584,-1.937501046250e+000,-9.674447424540e+001,8.016226505806e+000
    4585,-1.937501046250e+000,-9.620431388994e+001,7.115316857796e+000
    4586,-1.937501046250e+000,-9.151770302361e+001,4.003061467289e+001
    4587,-1.937501046250e+000,-9.158817952729e+001,3.961140961475e+001
    4588,-1.937501046250e+000,-9.575987453538e+001,2.681175432779e+001
    4589,-1.937501046250e+000,-9.119865668930e+001,4.459818774901e+001
    4590,-1.937501046250e+000,-9.117403455888e+001,4.419627959300e+001
    4591,-1.937501046250e+000,-9.560165561911e+001,2.580197616426e+001
    4592,-1.937501046250e+000,-9.262377076450e+001,3.958247575790e+001
    4593,-1.937501046250e+000,-9.266229702123e+001,4.001007343835e+001
    4594,-1.937501046250e+000,-9.404167072196e+001,3.710698687065e+001
    4595,-1.937501046250e+000,-9.173401304761e+001,3.778972132988e+001
    4596,-1.937501046250e+000,-9.201446282468e+001,3.783191735466e+001
    4597,-1.937501046250e+000,-9.520735386138e+001,2.793998418949e+001
    4598,-1.937501046250e+000,-9.486683580932e+001,2.820054399273e+001
    4599,-1.937501046250e+000,-9.526524575218e+001,2.910431464195e+001
    4600,-1.937501046250e+000,-9.515432988561e+001,2.953137043493e+001
    4601,-1.937501046250e+000,-9.140721802703e+001,1.866872828718e+001
    4602,-1.937501046250e+000,-9.239745046695e+001,3.781254136036e+001
    4603,-1.937501046250e+000,-9.267734193122e+001,3.776173587414e+001
    4604,-1.937501046250e+000,-9.385427532200e+001,2.746390443448e+001
    4605,-1.937501046250e+000,-9.401925745922e+001,2.746600573470e+001
    4606,-1.937501046250e+000,-9.413058199599e+001,2.764697432592e+001
    4607,-1.937501046250e+000,-9.367919497487e+001,2.758380308280e+001
    4608,-1.937501046250e+000,-9.247802533930e+001,4.042053023078e+001
    4609,-1.937501046250e+000,-9.184848260727e+001,4.220616184466e+001
    4610,-1.937501046250e+000,-9.179727193395e+001,4.278531367595e+001
    4611,-1.937501046250e+000,-9.087729129159e+001,3.750857303178e+001
    4612,-1.937501046250e+000,-9.155507281933e+001,3.312054522298e+000
    4613,-1.937501046250e+000,-9.184334075558e+001,3.286074541762e+000
    4614,-1.937501046250e+000,-9.212950333792e+001,3.308772341350e+000
    4615,-1.937501046250e+000,-9.240795902902e+001,3.318546979086e+000
    4616,-1.937501046250e+000,-9.197425396379e+001,3.585675043494e+000
    4617,-1.937501046250e+000,-9.272346359572e+001,3.355750755297e+000
    4618,-1.937501046250e+000,-9.302163515125e+001,3.381651492251e+000
    4619,-1.937501046250e+000,-9.257592111284e+001,3.645576619293e+000
    4620,-1.937501046250e+000,-9.339443616188e+001,3.451506128182e+000
    4621,-1.937501046250e+000,-9.372272282648e+001,3.449339296652e+000
    4622,-1.937501046250e+000,-9.326422669017e+001,3.752635031434e+000
    4623,-1.937501046250e+000,-9.406974496273e+001,3.383302491714e+000
    4624,-1.937501046250e+000,-9.431587965460e+001,3.305618510986e+000
    4625,-1.937501046250e+000,-9.398404983705e+001,3.756452862427e+000
    4626,-1.937501046250e+000,-9.456658143698e+001,3.363879342483e+000
    4627,-2.062501113750e+000,-8.965073738142e+001,1.936726473612e+000
    4628,-2.062501113750e+000,-8.937504826250e+001,1.936726473612e+000
    4629,-1.937501046250e+000,-9.493246182040e+001,3.393820544773e+000
    4630,-1.937501046250e+000,-9.520314189486e+001,3.391186840301e+000
    4631,-1.937501046250e+000,-9.469695235673e+001,3.720357259780e+000
    4632,-1.937501046250e+000,-9.550728454242e+001,3.328071781332e+000
    4633,-1.937501046250e+000,-9.583673893388e+001,3.328925212592e+000
    4634,-1.937501046250e+000,-9.536697538771e+001,3.687183403102e+000
    4635,-1.937501046250e+000,-9.613472522172e+001,3.370493542864e+000
    4636,-1.937501046250e+000,-9.643025968447e+001,3.415076187550e+000
    4637,-1.937501046250e+000,-9.596910432311e+001,3.665636674407e+000
    4638,-1.937501046250e+000,-9.675521949717e+001,3.602340274324e+000
    4639,-1.937501046250e+000,-9.705422785729e+001,3.637572941978e+000
    4640,-1.937501046250e+000,-9.659205042365e+001,3.894469091453e+000
    4641,-1.937501046250e+000,-9.111597944038e+001,3.815106101932e+001
    4642,-1.937501046250e+000,-9.141033239834e+001,3.827620925166e+001
    4643,-1.937501046250e+000,-9.153256485886e+001,3.796009384888e+001
    4644,-1.937501046250e+000,-9.423019286533e+001,3.631031493352e+001
    4645,-1.937501046250e+000,-9.430213223917e+001,3.615515127032e+001
    4646,-1.937501046250e+000,-9.421414147700e+001,3.652203254361e+001
    4647,-1.937501046250e+000,-9.479322430173e+001,8.431418168796e+000
    4648,-1.937501046250e+000,-9.449600782484e+001,8.401028744659e+000
    4649,-1.937501046250e+000,-9.049786101547e+001,2.692037406359e+001
    4650,-1.937501046250e+000,-9.548430332573e+001,2.663962598926e+001
    4651,-1.937501046250e+000,-9.474403483053e+001,1.867512190875e+001
    4652,-1.937501046250e+000,-9.569727793427e+001,2.599696902197e+001
    4653,-1.937501046250e+000,-9.551119846912e+001,2.694695182368e+001
    4654,-1.937501046250e+000,-9.123949095333e+001,1.888621718989e+001
    4655,-1.937501046250e+000,-9.419326900319e+001,3.685931224171e+001
    4656,-1.937501046250e+000,-9.005650552209e+001,2.051319662415e+001
    4657,-1.937501046250e+000,-9.544983014474e+001,2.719846096840e+001
    4658,-1.937501046250e+000,-9.445387180999e+001,3.668583807514e+001
    4659,-1.937501046250e+000,-9.016153262335e+001,1.782943249163e+001
    4660,-1.937501046250e+000,-9.354991280274e+001,2.777849428775e+001
    4661,-1.937501046250e+000,-9.612870241805e+001,1.794979366542e+001
    4662,-1.937501046250e+000,-9.640528303503e+001,1.790009580808e+001
    4663,-1.937501046250e+000,-9.416760960207e+001,8.335577627625e+000
    4664,-1.937501046250e+000,-9.385333367629e+001,8.332847388023e+000
    4665,-1.937501046250e+000,-9.436718899446e+001,8.049415242913e+000
    4666,-1.937501046250e+000,-9.137952921965e+001,1.910430614434e+001
    4667,-1.937501046250e+000,-9.080155172834e+001,8.128234230824e+000
    4668,-1.937501046250e+000,-9.080825124258e+001,7.776998411137e+000
    4669,-1.937501046250e+000,-9.111584021117e+001,8.300533727232e+000
    4670,-1.937501046250e+000,-9.084487352965e+001,7.430068757237e+000
    4671,-1.937501046250e+000,-9.085549918499e+001,7.047949726883e+000
    4672,-1.937501046250e+000,-9.118260653752e+001,7.617133421780e+000
    4673,-1.937501046250e+000,-9.092588298348e+001,6.648887904434e+000
    4674,-1.937501046250e+000,-9.093215965516e+001,6.270246377412e+000
    4675,-1.937501046250e+000,-9.128961262308e+001,6.871141945431e+000
    4676,-1.937501046250e+000,-9.098790743881e+001,5.836138115475e+000
    4677,-1.937501046250e+000,-9.098435906487e+001,5.424190417839e+000
    4678,-1.937501046250e+000,-9.141574420523e+001,6.037971861044e+000
    4679,-1.937501046250e+000,-9.088797850924e+001,4.998253791570e+000
    4680,-1.937501046250e+000,-9.087904410261e+001,4.602226433847e+000
    4681,-1.937501046250e+000,-9.137511143325e+001,5.177926972838e+000
    4682,-1.937501046250e+000,-9.077469546819e+001,4.149887116547e+000
    4683,-1.937501046250e+000,-9.072153506335e+001,3.766684249429e+000
    4684,-1.937501046250e+000,-9.117438224321e+001,4.299651029269e+000
    4685,-1.937501046250e+000,-9.244645095469e+001,4.563879232809e+001
    4686,-1.937501046250e+000,-9.607156225147e+001,1.819726651233e+001
    4687,-1.937501046250e+000,-9.471417817307e+001,2.756278871958e+001
    4688,-1.937501046250e+000,-9.498565666909e+001,2.756335622100e+001
    4689,-1.937501046250e+000,-9.114481105780e+001,2.748689654800e+001
    4690,-1.937501046250e+000,-9.135003276521e+001,2.757903385797e+001
    4691,-1.937501046250e+000,-9.106502319999e+001,1.903032535239e+001
    4692,-1.937501046250e+000,-9.619178257009e+001,1.845318296499e+001
    4693,-1.937501046250e+000,-9.377690014053e+001,2.782042730225e+001
    4694,-1.937501046250e+000,-9.460670220339e+001,2.775854161098e+001
    4695,-1.937501046250e+000,-9.057955533780e+001,3.611309404893e+001
    4696,-1.937501046250e+000,-9.039272204928e+001,3.622584497699e+001
    4697,-1.937501046250e+000,-9.057226740144e+001,3.595673294776e+001
    4698,-1.937501046250e+000,-9.343083606346e+001,8.391705728826e+000
    4699,-1.937501046250e+000,-9.304088505760e+001,8.450254796638e+000
    4700,-1.937501046250e+000,-9.282149079986e+001,8.171298162078e+000
    4701,-1.937501046250e+000,-9.361629315885e+001,8.042822466683e+000
    4702,-1.937501046250e+000,-9.661825707663e+001,1.820773052629e+001
    4703,-1.937501046250e+000,-9.650028299836e+001,1.954775970063e+001
    4704,-1.937501046250e+000,-9.533458780301e+001,2.765446974309e+001
    4705,-1.937501046250e+000,-9.680430075610e+001,1.720950684932e+001
    4706,-1.937501046250e+000,-9.728995458864e+001,1.056303602173e+001
    4707,-1.937501046250e+000,-9.311572224034e+001,4.594841297291e+001
    4708,-2.062501113750e+000,-9.824871765150e+001,1.936726473612e+000
    4709,-2.062501113750e+000,-9.852440677042e+001,1.936726473612e+000
    4710,-1.937501046250e+000,-9.495045770784e+001,1.859972295966e+001
    4711,-1.937501046250e+000,-9.517781541327e+001,1.865579010444e+001
    4712,-1.937501046250e+000,-9.220990545909e+001,3.806586608692e+001
    4713,-1.937501046250e+000,-9.194763596212e+001,8.612137858736e+000
    4714,-1.937501046250e+000,-9.165894991986e+001,8.679978997753e+000
    4715,-1.937501046250e+000,-9.140509630094e+001,8.519714901384e+000
    4716,-1.937501046250e+000,-9.208684124184e+001,8.321670470326e+000
    4717,-1.937501046250e+000,-9.301455364230e+001,3.760755403070e+001
    4718,-1.937501046250e+000,-9.320605981397e+001,3.750782363914e+001
    4719,-1.937501046250e+000,-9.293010481245e+001,3.789230824919e+001
    4720,-1.937501046250e+000,-9.209235633322e+001,4.476324388314e+001
    4721,-1.937501046250e+000,-9.161025673300e+001,4.483911382120e+001
    4722,-1.937501046250e+000,-9.109750408651e+001,4.505071195958e+001
    4723,-1.937501046250e+000,-9.740938243903e+001,3.947679206448e+000
    4724,-1.937501046250e+000,-9.726881267290e+001,4.496204541148e+000
    4725,-1.937501046250e+000,-9.435551468243e+001,3.584639513116e+001
    4726,-1.937501046250e+000,-9.190077865445e+001,4.051119594420e+001
    4727,-1.937501046250e+000,-9.226733338375e+001,4.101368397190e+001
    4728,-1.937501046250e+000,-9.211980668340e+001,4.156783802924e+001
    4729,-1.937501046250e+000,-9.130701106807e+001,4.062376841400e+001
    4730,-1.937501046250e+000,-9.086521461947e+001,1.913674986528e+001
    4731,-1.937501046250e+000,-9.085481036818e+001,2.747241049711e+001
    4732,-1.937501046250e+000,-9.294302417822e+001,4.595100339887e+001
    4733,-1.937501046250e+000,-9.220074613535e+001,4.430480474763e+001
    4734,-1.937501046250e+000,-9.586331061099e+001,8.767365132577e+000
    4735,-1.937501046250e+000,-9.567016333821e+001,8.676175231614e+000
    4736,-1.937501046250e+000,-9.671140794867e+001,4.677904148475e+000
    4737,-1.937501046250e+000,-9.688393541268e+001,8.411216474122e+000
    4738,-1.937501046250e+000,-9.663499778684e+001,8.788592127821e+000
    4739,-1.937501046250e+000,-9.273905902823e+001,4.544369871119e+001
    4740,-1.937501046250e+000,-9.264350388667e+001,3.905214066757e+001
    4741,-1.937501046250e+000,-9.213120373215e+001,3.938770711276e+001
    4742,-1.937501046250e+000,-9.160791264945e+001,3.908107452442e+001
    4743,-1.937501046250e+000,-9.271294703271e+001,3.864138598256e+001
    4744,-1.937501046250e+000,-9.490804745571e+001,2.944324374160e+001
    4745,-1.937501046250e+000,-9.207925732852e+001,4.378810982319e+001
    4746,-1.937501046250e+000,-9.093002011876e+001,3.482117562789e+000
    4747,-1.937501046250e+000,-9.124604393300e+001,3.454221756329e+000
    4748,-1.937501046250e+000,-9.754660005997e+001,3.503518970199e+000
    4749,-1.937501046250e+000,-9.782099330459e+001,3.414270624542e+000
    4750,-1.937501046250e+000,-9.078944486410e+001,2.791029332760e+001
    4751,-1.937501046250e+000,-9.102968188806e+001,4.369539168583e+001
    4752,-1.937501046250e+000,-9.098285046064e+001,4.327040599347e+001
    4753,-1.937501046250e+000,-9.128507127040e+001,4.288290555622e+001
    4754,-1.937501046250e+000,-9.156705666496e+001,4.388570170346e+001
    4755,-1.937501046250e+000,-9.157234191709e+001,3.866227422227e+001
    4756,-1.937501046250e+000,-9.271220665227e+001,4.594259288364e+001
    4757,-1.937501046250e+000,-9.398585012441e+001,2.778910937045e+001
    4758,-1.937501046250e+000,-9.058152157331e+001,3.401490100249e+000
    4759,-1.937501046250e+000,-9.134537150849e+001,2.783931330563e+001
    4760,-1.937501046250e+000,-9.110515704066e+001,2.796916682371e+001
    4761,-1.937501046250e+000,-9.635993944168e+001,8.118867241400e+000
    4762,-1.937501046250e+000,-9.636916891844e+001,8.752250135023e+000
    4763,-1.937501046250e+000,-9.542133435228e+001,8.488002451220e+000
    4764,-1.937501046250e+000,-9.515248027919e+001,8.445112911812e+000
    4765,-1.937501046250e+000,-9.118216495245e+001,3.758085119788e+001
    4766,-1.937501046250e+000,-9.143966008965e+001,3.766457309755e+001
    4767,-1.937501046250e+000,-9.078707765280e+001,4.520206851917e+001
    4768,-1.937501046250e+000,-9.198892733557e+001,3.847130705182e+001
    4769,-1.937501046250e+000,-9.505484319469e+001,8.128561102963e+000
    4770,-1.937501046250e+000,-9.566292815808e+001,8.330428626374e+000
    4771,-1.937501046250e+000,-9.439769982023e+001,2.792769023108e+001
    4772,-1.937501046250e+000,-9.464942034430e+001,2.801801928750e+001
    4773,-1.937501046250e+000,-9.161623371660e+001,2.769954090505e+001
    4774,-1.937501046250e+000,-9.327113686731e+001,3.808176317422e+001
    4775,-1.937501046250e+000,-9.620557887648e+001,8.516229308242e+000
    4776,-1.937501046250e+000,-9.607534718597e+001,8.754622233549e+000
    4777,-1.937501046250e+000,-9.421024980774e+001,2.781034759908e+001
    4778,-1.937501046250e+000,-9.581621716340e+001,5.459456945484e+000
    4779,-1.937501046250e+000,-9.565738908565e+001,6.075797607377e+000
    4780,-1.937501046250e+000,-9.557296345936e+001,6.806203752613e+000
    4781,-1.937501046250e+000,-9.558912784382e+001,7.414764167901e+000
    4782,-1.937501046250e+000,-9.504220303953e+001,6.375244917481e+000
    4783,-1.937501046250e+000,-9.193490465769e+001,4.328722191601e+001
    4784,-1.937501046250e+000,-9.093333824004e+001,3.776266745044e+001
    4785,-1.937501046250e+000,-9.116290441941e+001,4.136157599345e+001
    4786,-1.937501046250e+000,-9.112042025245e+001,4.098555227113e+001
    4787,-1.937501046250e+000,-9.238397914585e+001,3.944014651931e+000
    4788,-1.937501046250e+000,-9.269948371255e+001,3.981218428142e+000
    4789,-1.937501046250e+000,-9.303490067843e+001,4.055154169596e+000
    4790,-1.937501046250e+000,-9.340770168906e+001,4.125008805526e+000
    4791,-1.937501046250e+000,-9.284295871144e+001,4.353592202234e+000
    4792,-1.937501046250e+000,-9.378917270853e+001,4.338411829478e+000
    4793,-1.937501046250e+000,-9.413619484478e+001,4.272375024541e+000
    4794,-1.937501046250e+000,-9.355984669679e+001,4.640930967640e+000
    4795,-2.363078776062e+000,-8.937504826250e+001,1.936726473612e+000
    4796,-3.295749279704e+000,-8.937504826250e+001,1.936726473612e+000
    4797,-2.986829612887e+000,-8.937504826250e+001,1.936726473612e+000
    4798,-1.937501046250e+000,-9.458575490116e+001,4.120166638366e+000
    4799,-1.937501046250e+000,-9.495163528457e+001,4.150107840657e+000
    4800,-1.937501046250e+000,-9.439087777263e+001,4.702125605417e+000
    4801,-1.937501046250e+000,-9.543351088576e+001,4.124899125841e+000
    4802,-1.937501046250e+000,-9.573765353332e+001,4.061784066873e+000
    4803,-1.937501046250e+000,-9.532231343019e+001,4.524708504427e+000
    4804,-1.937501046250e+000,-9.606611770920e+001,8.121239339926e+000
    4805,-1.937501046250e+000,-9.143524034021e+001,8.183244249831e+000
    4806,-1.937501046250e+000,-9.150679515436e+001,7.841629029945e+000
    4807,-1.937501046250e+000,-9.154341744144e+001,7.494699376045e+000
    4808,-1.937501046250e+000,-9.179605124413e+001,8.060810204096e+000
    4809,-1.937501046250e+000,-9.163383104327e+001,7.117526584788e+000
    4810,-1.937501046250e+000,-9.170421484176e+001,6.718464762338e+000
    4811,-1.937501046250e+000,-9.195801966011e+001,7.342022192952e+000
    4812,-1.937501046250e+000,-9.237191497784e+001,3.845193105753e+001
    4813,-1.937501046250e+000,-9.215839605599e+001,7.980055250439e+000
    4814,-1.937501046250e+000,-9.581728872328e+001,7.933066559532e+000
    4815,-1.937501046250e+000,-9.615499734618e+001,4.886787454167e+000
    4816,-1.937501046250e+000,-9.546540884859e+001,5.072169280928e+000
    4817,-1.937501046250e+000,-9.518593829270e+001,7.623953454349e+000
    4818,-1.937501046250e+000,-9.141876262278e+001,4.174267350073e+001
    4819,-1.937501046250e+000,-9.137906249512e+001,3.705144477938e+000
    4820,-1.937501046250e+000,-9.255216988580e+001,7.892526129223e+000
    4821,-1.937501046250e+000,-9.226137988810e+001,7.631665862994e+000
    4822,-1.937501046250e+000,-9.235179348993e+001,7.254493071736e+000
    4823,-1.937501046250e+000,-9.292447463197e+001,7.822908774633e+000
    4824,-1.937501046250e+000,-9.204736581172e+001,3.943793078549e+000
    4825,-1.937501046250e+000,-9.217092841142e+001,4.279434887399e+000
    4826,-1.937501046250e+000,-9.176120322937e+001,3.921095278962e+000
    4827,-1.937501046250e+000,-9.145217434304e+001,4.063262512993e+000
    4828,-1.937501046250e+000,-9.155652297746e+001,4.515601830293e+000
    4829,-1.937501046250e+000,-9.191533863271e+001,4.929936583908e+000
    4830,-1.937501046250e+000,-9.219313073254e+001,4.693548067632e+000
    4831,-1.937501046250e+000,-9.201171918833e+001,5.355873210176e+000
    4832,-1.937501046250e+000,-9.636059963386e+001,4.290616483919e+000
    4833,-1.937501046250e+000,-9.293392515623e+001,3.823594501766e+001
    4834,-1.937501046250e+000,-9.444821560231e+001,5.785606131932e+000
    4835,-1.937501046250e+000,-9.436378997602e+001,6.516012277168e+000
    4836,-1.937501046250e+000,-9.603563982116e+001,4.103352397145e+000
    4837,-1.937501046250e+000,-9.186533495536e+001,6.260961674225e+000
    4838,-1.937501046250e+000,-9.192108273901e+001,5.826853412288e+000
    4839,-1.937501046250e+000,-9.246130993847e+001,5.578863023358e+000
    4840,-1.937501046250e+000,-9.220955337554e+001,6.507346313583e+000
    4841,-1.937501046250e+000,-9.482668231523e+001,7.610258711332e+000
    4842,-1.937501046250e+000,-9.449828409246e+001,7.544807594299e+000
    4843,-1.937501046250e+000,-9.434248712811e+001,7.152057407924e+000
    4844,-1.937501046250e+000,-9.388299380733e+001,7.591213939505e+000
    4845,-1.937501046250e+000,-9.346049619450e+001,7.650072280309e+000
    4846,-1.937501046250e+000,-9.374849969089e+001,6.562418622374e+000
    4847,-1.937501046250e+000,-9.252974406667e+001,4.693769641013e+000
    4848,-1.937501046250e+000,-9.286516103255e+001,4.767705382467e+000
    4849,-2.689208452172e+000,-8.937504826250e+001,1.936726473612e+000
    4850,-1.937501046250e+000,-9.319117528045e+001,7.371300247454e+000
    4851,-2.062501113750e+000,-9.938332558663e+001,1.936726473612e+000
    4852,-1.937501046250e+000,-9.324663205202e+001,4.981108406419e+000
    4853,-1.937501046250e+000,-9.453397319104e+001,5.249586381919e+000
    4854,-1.937501046250e+000,-9.498353324741e+001,5.097377995744e+000
    4855,-1.937501046250e+000,-9.278191675262e+001,7.098194196807e+000
    4856,-1.937501046250e+000,-9.247855652464e+001,6.808550526765e+000
    4857,-1.937501046250e+000,-9.263967663824e+001,6.351047438653e+000
    4858,-1.937501046250e+000,-9.331793831516e+001,6.925357702483e+000
    4859,-1.937501046250e+000,-9.385556012753e+001,5.390353741605e+000
    4860,-1.937501046250e+000,-9.307023801397e+001,5.988108358545e+000
    4861,-1.937501046250e+000,-9.316087446329e+001,5.517128156432e+000
    4862,-2.062501113750e+000,-9.423221115153e+001,1.936726473612e+000
    4863,-2.062501113750e+000,-9.395652203261e+001,1.936726473612e+000
    4864,-1.937501046250e+000,-9.333924116307e+001,6.289312571727e+000
    4865,-2.062501113750e+000,-9.452647685709e+001,1.936726473612e+000
    4866,-2.062501113750e+000,-9.766285768555e+001,1.936726473612e+000
    4867,-2.062501113750e+000,-9.795445194595e+001,1.936726473612e+000
    4868,-2.187501181250e+000,-9.914205309503e+001,2.228012915626e+000
    4869,-2.187501181250e+000,-9.878322961692e+001,2.305984705824e+000
    4870,-2.187501181250e+000,-9.848896391136e+001,2.305984705824e+000
    4871,-2.187501181250e+000,-9.817096571138e+001,2.183692004137e+000
    4872,-2.187501181250e+000,-9.787670000583e+001,2.183692004137e+000
    4873,-2.187501181250e+000,-9.836183545211e+001,2.552950236349e+000
    4874,-2.187501181250e+000,-9.757151803036e+001,2.219389624806e+000
    4875,-2.187501181250e+000,-9.727725232481e+001,2.219389624806e+000
    4876,-2.187501181250e+000,-9.773865527666e+001,2.466355155331e+000
    4877,-2.187501181250e+000,-9.698441429506e+001,2.206260325854e+000
    4878,-2.187501181250e+000,-9.669014858951e+001,2.206260325854e+000
    4879,-2.187501181250e+000,-9.714063527145e+001,2.488923477048e+000
    4880,-2.187501181250e+000,-9.640294840196e+001,2.193131003155e+000
    4881,-2.187501181250e+000,-9.610868269640e+001,2.193131003155e+000
    4882,-2.187501181250e+000,-9.656059705415e+001,2.462664855397e+000
    4883,-2.187501181250e+000,-9.580350661005e+001,2.177471940424e+000
    4884,-2.187501181250e+000,-9.551422845883e+001,2.177471940424e+000
    4885,-2.187501181250e+000,-9.596822078025e+001,2.433876469968e+000
    4886,-2.187501181250e+000,-9.521639877534e+001,2.182311130965e+000
    4887,-2.187501181250e+000,-9.492213306978e+001,2.182311130965e+000
    4888,-2.187501181250e+000,-9.536521501041e+001,2.423056597778e+000
    4889,-2.187501181250e+000,-9.463352436633e+001,2.190900001811e+000
    4890,-2.187501181250e+000,-9.433925866078e+001,2.190900001811e+000
    4891,-2.187501181250e+000,-9.477877662347e+001,2.436484659165e+000
    4892,-2.187501181250e+000,-9.405839010421e+001,2.193940789321e+000
    4893,-2.187501181250e+000,-9.376412439866e+001,2.193940789321e+000
    4894,-2.187501181250e+000,-9.420929936345e+001,2.448114317521e+000
    4895,-2.187501181250e+000,-9.344243343715e+001,2.189042419154e+000
    4896,-2.187501181250e+000,-9.314816773160e+001,2.189042419154e+000
    4897,-2.187501181250e+000,-9.360673984538e+001,2.446256734863e+000
    4898,-2.187501181250e+000,-9.285853662013e+001,2.188978138054e+000
    4899,-2.187501181250e+000,-9.256427091458e+001,2.188978138054e+000
    4900,-2.187501181250e+000,-9.299541777241e+001,2.441294083596e+000
    4901,-2.187501181250e+000,-9.228159114190e+001,2.184822738284e+000
    4902,-2.187501181250e+000,-9.199231299068e+001,2.184822738284e+000
    4903,-2.187501181250e+000,-9.242310688827e+001,2.437074402727e+000
    4904,-2.187501181250e+000,-9.171739333803e+001,2.170461203750e+000
    4905,-2.187501181250e+000,-9.142312763248e+001,2.170461203750e+000
    4906,-2.187501181250e+000,-9.186550746294e+001,2.418557468422e+000
    4907,-2.187501181250e+000,-9.110867396991e+001,2.173998824840e+000
    4908,-2.187501181250e+000,-9.081440826435e+001,2.173998824840e+000
    4909,-2.187501181250e+000,-9.127613414772e+001,2.407733554978e+000
    4910,-2.187501181250e+000,-9.056475547104e+001,2.172726797692e+000
    4911,-2.187501181250e+000,-9.027048976548e+001,2.172726797692e+000
    4912,-2.187501181250e+000,-9.071202769184e+001,2.409999148921e+000
    4913,-2.187501181250e+000,-8.978932648122e+001,2.205606266240e+000
    4914,-2.187501181250e+000,-9.884604785500e+001,3.975206819329e+000
    4915,-2.187501181250e+000,-9.891476157978e+001,3.459853883458e+000
    4916,-2.187501181250e+000,-9.847579737736e+001,5.871883466937e+000
    4917,-2.187501181250e+000,-9.854749865540e+001,5.334123881680e+000
    4918,-2.187501181250e+000,-9.822853864191e+001,7.884490241048e+000
    4919,-2.187501181250e+000,-9.830023991994e+001,7.346730655792e+000
    4920,-2.187501181250e+000,-9.817520498603e+001,9.425013961742e+000
    4921,-2.187501181250e+000,-9.810947881450e+001,9.917960248228e+000
    4922,-2.187501181250e+000,-9.783828581459e+001,1.142133364671e+001
    4923,-2.187501181250e+000,-9.788907421987e+001,1.104042060715e+001
    4924,-2.187501181250e+000,-9.736190899178e+001,1.211130368583e+001
    4925,-2.187501181250e+000,-9.742166005681e+001,1.166317069812e+001
    4926,-2.187501181250e+000,-9.722415788464e+001,1.314443698945e+001
    4927,-2.187501181250e+000,-9.728390894966e+001,1.269630400173e+001
    4928,-2.187501181250e+000,-9.708471922494e+001,1.419022693718e+001
    4929,-2.187501181250e+000,-9.714745784322e+001,1.371968730008e+001
    4930,-2.187501181250e+000,-9.719653699330e+001,1.590783396283e+001
    4931,-2.187501181250e+000,-9.726226316483e+001,1.541488767634e+001
    4932,-2.187501181250e+000,-9.712521916022e+001,1.777278099385e+001
    4933,-2.187501181250e+000,-9.718497022525e+001,1.732464800613e+001
    4934,-2.187501181250e+000,-9.677033825000e+001,1.956125492574e+001
    4935,-2.187501181250e+000,-9.683905197479e+001,1.904590198987e+001
    4936,-2.187501181250e+000,-9.635602566806e+001,2.244577531762e+001
    4937,-2.187501181250e+000,-9.641577673309e+001,2.199764232990e+001
    4938,-2.187501181250e+000,-9.586154959363e+001,2.336399917195e+001
    4939,-2.187501181250e+000,-9.592727576517e+001,2.287105288547e+001
    4940,-2.187501181250e+000,-9.586647186210e+001,2.620539215940e+001
    4941,-2.187501181250e+000,-9.592024782062e+001,2.580207247046e+001
    4942,-2.187501181250e+000,-9.559935319412e+001,2.777653994935e+001
    4943,-2.187501181250e+000,-9.565910425915e+001,2.732840696164e+001
    4944,-2.187501181250e+000,-9.550931762503e+001,2.976216478488e+001
    4945,-2.187501181250e+000,-9.556309358355e+001,2.935884509594e+001
    4946,-2.187501181250e+000,-9.513030212397e+001,3.143930383126e+001
    4947,-2.187501181250e+000,-9.519304074225e+001,3.096876419416e+001
    4948,-2.187501181250e+000,-9.466971773744e+001,3.230273809338e+001
    4949,-2.187501181250e+000,-9.473245635572e+001,3.183219845628e+001
    4950,-2.187501181250e+000,-9.453239996386e+001,3.333262139524e+001
    4951,-2.187501181250e+000,-9.459215102889e+001,3.288448840752e+001
    4952,-2.187501181250e+000,-9.446677507794e+001,3.603998245041e+001
    4953,-2.187501181250e+000,-9.452055103647e+001,3.563666276147e+001
    4954,-2.187501181250e+000,-9.433452388713e+001,3.783280846366e+001
    4955,-2.187501181250e+000,-9.439128739891e+001,3.740708212533e+001
    4956,-2.187501181250e+000,-9.406487132964e+001,3.975983572953e+001
    4957,-2.187501181250e+000,-9.412462239467e+001,3.931170274181e+001
    4958,-2.187501181250e+000,-9.370930324738e+001,4.156010276079e+001
    4959,-2.187501181250e+000,-9.377204186566e+001,4.108956312369e+001
    4960,-2.187501181250e+000,-9.351065114627e+001,4.365313518851e+001
    4961,-2.187501181250e+000,-9.357936487105e+001,4.313778225264e+001
    4962,-2.187501181250e+000,-9.335770966521e+001,4.538278971704e+001
    4963,-2.187501181250e+000,-9.340551051723e+001,4.502428332687e+001
    4964,-2.187501181250e+000,-9.339568217748e+001,4.634793470628e+001
    4965,-2.187501181250e+000,-9.341958260349e+001,4.616868151119e+001
    4966,-2.187501181250e+000,-9.334485912605e+001,4.662835881592e+001
    4967,-2.187501181250e+000,-9.336278444556e+001,4.649391891961e+001
    4968,-2.187501181250e+000,-9.322256549402e+001,4.636070817352e+001
    4969,-2.187501181250e+000,-9.320085904829e+001,4.662835881592e+001
    4970,-2.187501181250e+000,-9.302485895325e+001,4.662835881592e+001
    4971,-2.187501181250e+000,-9.258197866539e+001,4.649329141402e+001
    4972,-2.187501181250e+000,-9.283197880039e+001,4.649329141402e+001
    4973,-2.187501181250e+000,-9.136302957590e+001,4.647517528678e+001
    4974,-2.187501181250e+000,-9.164502972818e+001,4.647517528678e+001
    4975,-2.187501181250e+000,-9.022290214158e+001,4.649870319556e+001
    4976,-2.187501181250e+000,-9.051490229926e+001,4.649870319556e+001
    4977,-2.187501181250e+000,-8.969132694182e+001,4.653383506948e+001
    4978,-2.187501181250e+000,-8.997332709410e+001,4.653383506948e+001
    4979,-2.187501181250e+000,-9.013218060113e+001,4.628251302005e+001
    4980,-2.187501181250e+000,-8.969132694182e+001,4.617532867931e+001
    4981,-2.187501181250e+000,-8.978488674569e+001,4.477172180791e+001
    4982,-2.187501181250e+000,-8.978488674569e+001,4.517504149685e+001
    4983,-2.187501181250e+000,-8.983971370094e+001,4.333381121685e+001
    4984,-2.187501181250e+000,-8.983971370094e+001,4.366991095764e+001
    4985,-2.187501181250e+000,-8.985627453694e+001,4.184438701942e+001
    4986,-2.187501181250e+000,-8.985627453694e+001,4.222530005897e+001
    4987,-2.187501181250e+000,-8.983801700175e+001,4.099092196350e+001
    4988,-2.187501181250e+000,-8.983801700175e+001,4.141664830183e+001
    4989,-2.187501181250e+000,-8.982220474247e+001,3.956505663083e+001
    4990,-2.187501181250e+000,-8.982220474247e+001,3.992356302100e+001
    4991,-2.187501181250e+000,-8.995423838257e+001,3.797160724457e+001
    4992,-2.187501181250e+000,-8.995423838257e+001,3.841974023229e+001
    4993,-2.187501181250e+000,-8.987469380356e+001,3.648038744900e+001
    4994,-2.187501181250e+000,-8.987469380356e+001,3.686130048856e+001
    4995,-2.187501181250e+000,-8.990663462714e+001,3.499729614503e+001
    4996,-2.187501181250e+000,-8.990663462714e+001,3.537820918459e+001
    4997,-2.187501181250e+000,-8.992106881116e+001,3.356928015171e+001
    4998,-2.187501181250e+000,-8.992106881116e+001,3.390537989250e+001
    4999,-2.187501181250e+000,-8.991141276936e+001,3.200903174182e+001
    5000,-2.187501181250e+000,-8.991141276936e+001,3.236753813200e+001
    5001,-2.187501181250e+000,-8.991557464129e+001,3.064547652863e+001
    5002,-2.187501181250e+000,-8.991557464129e+001,3.104879621758e+001
    5003,-2.187501181250e+000,-8.976167658875e+001,2.906830898035e+001
    5004,-2.187501181250e+000,-8.976167658875e+001,2.944922201991e+001
    5005,-2.187501181250e+000,-8.985817323396e+001,2.762955905651e+001
    5006,-2.187501181250e+000,-8.985817323396e+001,2.798806544669e+001
    5007,-2.187501181250e+000,-8.986677324721e+001,2.605107115627e+001
    5008,-2.187501181250e+000,-8.986677324721e+001,2.643198419583e+001
    5009,-2.187501181250e+000,-8.980574509493e+001,2.466407530144e+001
    5010,-2.187501181250e+000,-8.980574509493e+001,2.502258169161e+001
    5011,-2.187501181250e+000,-8.990100907885e+001,2.309037006635e+001
    5012,-2.187501181250e+000,-8.990100907885e+001,2.347128310590e+001
    5013,-2.187501181250e+000,-8.978665893834e+001,2.168424002367e+001
    5014,-2.187501181250e+000,-8.978665893834e+001,2.204274641384e+001
    5015,-2.187501181250e+000,-8.986994413608e+001,2.026783039875e+001
    5016,-2.187501181250e+000,-8.986994413608e+001,2.067115008769e+001
    5017,-2.187501181250e+000,-8.978890538043e+001,1.872783217164e+001
    5018,-2.187501181250e+000,-8.978890538043e+001,1.906393191243e+001
    5019,-2.187501181250e+000,-8.986873034174e+001,1.730248179260e+001
    5020,-2.187501181250e+000,-8.986873034174e+001,1.768339483215e+001
    5021,-2.187501181250e+000,-8.979903646732e+001,1.581858087255e+001
    5022,-2.187501181250e+000,-8.979903646732e+001,1.615468061333e+001
    5023,-2.187501181250e+000,-8.989151148593e+001,1.433532710086e+001
    5024,-2.187501181250e+000,-8.989151148593e+001,1.469383349103e+001
    5025,-2.187501181250e+000,-8.989361632915e+001,1.287376228749e+001
    5026,-2.187501181250e+000,-8.989361632915e+001,1.327708197644e+001
    5027,-2.187501181250e+000,-8.989402689800e+001,1.147628543549e+001
    5028,-2.187501181250e+000,-8.989402689800e+001,1.181238517628e+001
    5029,-2.187501181250e+000,-8.990803823077e+001,9.905686755056e+000
    5030,-2.187501181250e+000,-8.990803823077e+001,1.030900644400e+001
    5031,-2.187501181250e+000,-8.982265151623e+001,8.447147304355e+000
    5032,-2.187501181250e+000,-8.982265151623e+001,8.783247045140e+000
    5033,-2.187501181250e+000,-8.985137291313e+001,7.012603385188e+000
    5034,-2.187501181250e+000,-8.985137291313e+001,7.371109775359e+000
    5035,-2.187501181250e+000,-8.982104746229e+001,5.530336627187e+000
    5036,-2.187501181250e+000,-8.982104746229e+001,5.866436367973e+000
    5037,-2.187501181250e+000,-8.980482214785e+001,4.066467251903e+000
    5038,-2.187501181250e+000,-8.980482214785e+001,4.424973642074e+000
    5039,-2.187501181250e+000,-8.975985343081e+001,2.608987886274e+000
    5040,-2.187501181250e+000,-8.975985343081e+001,2.967494276445e+000
    5041,-2.187501181250e+000,-9.619754106635e+001,9.614051530853e+000
    5042,-2.187501181250e+000,-9.633895254421e+001,9.641736392770e+000
    5043,-2.187501181250e+000,-9.653101627138e+001,9.727930279659e+000
    5044,-2.187501181250e+000,-9.667132781661e+001,9.827743518965e+000
    5045,-2.187501181250e+000,-9.679912053302e+001,1.000972020848e+001
    5046,-2.187501181250e+000,-9.687986917983e+001,1.016110030192e+001
    5047,-2.187501181250e+000,-9.695055591423e+001,1.036176280024e+001
    5048,-2.187501181250e+000,-9.695979490780e+001,1.050744622988e+001
    5049,-2.187501181250e+000,-9.180542611565e+001,9.550745278268e+000
    5050,-2.187501181250e+000,-9.197580635457e+001,9.550745278268e+000
    5051,-2.187501181250e+000,-9.221398336043e+001,9.522434503646e+000
    5052,-2.187501181250e+000,-9.244475153213e+001,9.522434503646e+000
    5053,-2.187501181250e+000,-9.209897969217e+001,9.323174516915e+000
    5054,-2.187501181250e+000,-9.270509389590e+001,9.508324846846e+000
    5055,-2.187501181250e+000,-9.296389932210e+001,9.508324846846e+000
    5056,-2.187501181250e+000,-9.259749906180e+001,9.280754085492e+000
    5057,-2.187501181250e+000,-9.327057681055e+001,9.515514877875e+000
    5058,-2.187501181250e+000,-9.357251647445e+001,9.515514877875e+000
    5059,-2.187501181250e+000,-9.316451891402e+001,9.273834459721e+000
    5060,-2.187501181250e+000,-9.385784830513e+001,9.520564257606e+000
    5061,-2.187501181250e+000,-9.416194468091e+001,9.520564257606e+000
    5062,-2.187501181250e+000,-9.375652823315e+001,9.286073870481e+000
    5063,-2.187501181250e+000,-9.443104143204e+001,9.534290631738e+000
    5064,-2.187501181250e+000,-9.473945123160e+001,9.534290631738e+000
    5065,-2.187501181250e+000,-9.431095681496e+001,9.304849624344e+000
    5066,-2.187501181250e+000,-9.500796821324e+001,9.552538914017e+000
    5067,-2.187501181250e+000,-9.526893035133e+001,9.552538914017e+000
    5068,-2.187501181250e+000,-9.484857054773e+001,9.336824280756e+000
    5069,-2.187501181250e+000,-9.550902253234e+001,9.562019459719e+000
    5070,-2.187501181250e+000,-9.569018633068e+001,9.562019459719e+000
    5071,-2.187501181250e+000,-9.535717971038e+001,9.364553108736e+000
    5072,-2.187501181250e+000,-9.587682901513e+001,9.583577010267e+000
    5073,-2.187501181250e+000,-9.601701528766e+001,9.583577010267e+000
    5074,-2.187501181250e+000,-9.615108303899e+001,9.447623276120e+000
    5075,-2.187501181250e+000,-9.578391457585e+001,9.395591204986e+000
    5076,-2.187501181250e+000,-9.088493781292e+001,1.039822636862e+001
    5077,-2.187501181250e+000,-9.090811607447e+001,1.026843240213e+001
    5078,-2.187501181250e+000,-9.095397250653e+001,1.009724861702e+001
    5079,-2.187501181250e+000,-9.104866006282e+001,9.954082769444e+000
    5080,-2.187501181250e+000,-9.119869294729e+001,9.810361310537e+000
    5081,-2.187501181250e+000,-9.133101993537e+001,9.729699482690e+000
    5082,-2.187501181250e+000,-9.149527667433e+001,9.633422548938e+000
    5083,-2.187501181250e+000,-9.162008407092e+001,9.612043988353e+000
    5084,-2.187501181250e+000,-9.167546064157e+001,9.412784001621e+000
    5085,-2.187501181250e+000,-9.132586185788e+001,9.570359645459e+000
    5086,-2.187501181250e+000,-9.085510803233e+001,1.693024909379e+001
    5087,-2.187501181250e+000,-9.085510803233e+001,1.678399901482e+001
    5088,-2.187501181250e+000,-9.080181319414e+001,1.660277857412e+001
    5089,-2.187501181250e+000,-9.080181319414e+001,1.639802846355e+001
    5090,-2.187501181250e+000,-9.065687208647e+001,1.667926856688e+001
    5091,-2.187501181250e+000,-9.081654391377e+001,1.616697047275e+001
    5092,-2.187501181250e+000,-9.081654391377e+001,1.591347033586e+001
    5093,-2.187501181250e+000,-9.061830796790e+001,1.626699013538e+001
    5094,-2.187501181250e+000,-9.078181129280e+001,1.510048519988e+001
    5095,-2.187501181250e+000,-9.078181129280e+001,1.481123504369e+001
    5096,-2.187501181250e+000,-9.064151189093e+001,1.456695253294e+001
    5097,-2.187501181250e+000,-9.064151189093e+001,1.427445237499e+001
    5098,-2.187501181250e+000,-9.064361673415e+001,1.328546348454e+001
    5099,-2.187501181250e+000,-9.064361673415e+001,1.299621332835e+001
    5100,-2.187501181250e+000,-9.065069417155e+001,1.266281392357e+001
    5101,-2.187501181250e+000,-9.065069417155e+001,1.237356376738e+001
    5102,-2.187501181250e+000,-9.029426176570e+001,1.276702029024e+001
    5103,-2.062501113750e+000,-9.736859197999e+001,1.936726473612e+000
    5104,-2.187501181250e+000,-9.080864716903e+001,1.118067584186e+001
    5105,-2.187501181250e+000,-9.080864716903e+001,1.097592573130e+001
    5106,-2.187501181250e+000,-9.080864716903e+001,1.143742598051e+001
    5107,-2.187501181250e+000,-9.081794343781e+001,1.070389463468e+001
    5108,-2.187501181250e+000,-9.081794343781e+001,1.055764455571e+001
    5109,-2.187501181250e+000,-9.070283211073e+001,1.045586525433e+001
    5110,-2.187501181250e+000,-9.062654146684e+001,1.088731453803e+001
    5111,-2.187501181250e+000,-9.162691108976e+001,1.789746004098e+001
    5112,-2.187501181250e+000,-9.150099337574e+001,1.787568764199e+001
    5113,-2.187501181250e+000,-9.133080922583e+001,1.779113973829e+001
    5114,-2.187501181250e+000,-9.120045135122e+001,1.771167821201e+001
    5115,-2.187501181250e+000,-9.104411792912e+001,1.755697134227e+001
    5116,-2.187501181250e+000,-9.094857157679e+001,1.741299903153e+001
    5117,-2.187501181250e+000,-9.086868841867e+001,1.722630822085e+001
    5118,-2.187501181250e+000,-9.084551015712e+001,1.709651425436e+001
    5119,-2.187501181250e+000,-9.515272296226e+001,1.792550061362e+001
    5120,-2.187501181250e+000,-9.501657607516e+001,1.792550061362e+001
    5121,-2.187501181250e+000,-9.482338307112e+001,1.793508974437e+001
    5122,-2.187501181250e+000,-9.465276861767e+001,1.793508974437e+001
    5123,-2.187501181250e+000,-9.491544674013e+001,1.811058077299e+001
    5124,-2.187501181250e+000,-9.445499347522e+001,1.790440124370e+001
    5125,-2.187501181250e+000,-9.421544388907e+001,1.790440124370e+001
    5126,-2.187501181250e+000,-9.452447859364e+001,1.808948140307e+001
    5127,-2.187501181250e+000,-9.397440819448e+001,1.795966448938e+001
    5128,-2.187501181250e+000,-9.370211442028e+001,1.795966448938e+001
    5129,-2.187501181250e+000,-9.408566775660e+001,1.811405614808e+001
    5130,-2.187501181250e+000,-9.289066410621e+001,1.797831129631e+001
    5131,-2.187501181250e+000,-9.264249762847e+001,1.797831129631e+001
    5132,-2.187501181250e+000,-9.239052490452e+001,1.797902082647e+001
    5133,-2.187501181250e+000,-9.217510261481e+001,1.797902082647e+001
    5134,-2.187501181250e+000,-9.253502679812e+001,1.820732253778e+001
    5135,-2.187501181250e+000,-9.196508130553e+001,1.794974711656e+001
    5136,-2.187501181250e+000,-9.180653050031e+001,1.794974711656e+001
    5137,-2.187501181250e+000,-9.168339204507e+001,1.809719757254e+001
    5138,-2.187501181250e+000,-9.207303276489e+001,1.817875835803e+001
    5139,-2.187501181250e+000,-9.604768302347e+001,1.722947219720e+001
    5140,-2.187501181250e+000,-9.599545720285e+001,1.737626399554e+001
    5141,-2.187501181250e+000,-9.590768010802e+001,1.759391194312e+001
    5142,-2.187501181250e+000,-9.575764906831e+001,1.773208908106e+001
    5143,-2.187501181250e+000,-9.552277267147e+001,1.784885139708e+001
    5144,-2.187501181250e+000,-9.535331886832e+001,1.788932124151e+001
    5145,-2.187501181250e+000,-9.696320260255e+001,1.070497215444e+001
    5146,-2.187501181250e+000,-9.694500259273e+001,1.084147222815e+001
    5147,-2.062501113750e+000,-9.337596378048e+001,1.936726473612e+000
    5148,-2.062501113750e+000,-9.366225632706e+001,1.936726473612e+000
    5149,-2.187501181250e+000,-9.692290258079e+001,1.100722231765e+001
    5150,-2.187501181250e+000,-9.657141011453e+001,1.464407825827e+001
    5151,-2.187501181250e+000,-9.653284342704e+001,1.493332841447e+001
    5152,-2.187501181250e+000,-9.651552269476e+001,1.534065840614e+001
    5153,-2.187501181250e+000,-9.647738934083e+001,1.562665856058e+001
    5154,-2.187501181250e+000,-9.638856151506e+001,1.595328231515e+001
    5155,-2.187501181250e+000,-9.634956149400e+001,1.624578247310e+001
    5156,-2.187501181250e+000,-9.674112324889e+001,1.586530959977e+001
    5157,-2.187501181250e+000,-9.612840875065e+001,1.688364065455e+001
    5158,-2.187501181250e+000,-9.610630873871e+001,1.704939074406e+001
    5159,-2.187501181250e+000,-9.488646418291e+001,2.623566510289e+001
    5160,-2.187501181250e+000,-9.482516924327e+001,2.639650147164e+001
    5161,-2.187501181250e+000,-9.469695708498e+001,2.663216741482e+001
    5162,-2.187501181250e+000,-9.454287999253e+001,2.676262646255e+001
    5163,-2.187501181250e+000,-9.429319664697e+001,2.684171835681e+001
    5164,-2.187501181250e+000,-9.413685801558e+001,2.687586172101e+001
    5165,-2.187501181250e+000,-9.563177371281e+001,2.069777097304e+001
    5166,-2.187501181250e+000,-9.561050703466e+001,2.085727105917e+001
    5167,-2.187501181250e+000,-9.557476381303e+001,2.104394197241e+001
    5168,-2.187501181250e+000,-9.554579713072e+001,2.126119208973e+001
    5169,-2.187501181250e+000,-9.575424361535e+001,2.098307894572e+001
    5170,-2.187501181250e+000,-9.555529608262e+001,2.147704277843e+001
    5171,-2.187501181250e+000,-9.551899606302e+001,2.174929292545e+001
    5172,-2.187501181250e+000,-9.572799934562e+001,2.138560054767e+001
    5173,-2.187501181250e+000,-9.564894368805e+001,2.207410737188e+001
    5174,-2.187501181250e+000,-9.560897699980e+001,2.237385753374e+001
    5175,-2.187501181250e+000,-9.529513515062e+001,2.450040335408e+001
    5176,-2.187501181250e+000,-9.525810179729e+001,2.477815350407e+001
    5177,-2.187501181250e+000,-9.516253295384e+001,2.509114704895e+001
    5178,-2.187501181250e+000,-9.512476626678e+001,2.537439720191e+001
    5179,-2.187501181250e+000,-9.498062049212e+001,2.556979720566e+001
    5180,-2.187501181250e+000,-9.495422047786e+001,2.576779731258e+001
    5181,-2.187501181250e+000,-9.527495985088e+001,2.552155788929e+001
    5182,-2.187501181250e+000,-9.490970152034e+001,2.592503964460e+001
    5183,-2.187501181250e+000,-9.489100151024e+001,2.606528972033e+001
    5184,-2.187501181250e+000,-9.503723883384e+001,2.620181793963e+001
    5185,-2.187501181250e+000,-9.508629511869e+001,2.587420022506e+001
    5186,-2.187501181250e+000,-9.485715349160e+001,1.963177008287e+001
    5187,-2.187501181250e+000,-9.499619531009e+001,1.965849952205e+001
    5188,-2.187501181250e+000,-9.518729347077e+001,1.974730937844e+001
    5189,-2.187501181250e+000,-9.533123573814e+001,1.984952088260e+001
    5190,-2.187501181250e+000,-9.546643264900e+001,2.001896720878e+001
    5191,-2.187501181250e+000,-9.554750486364e+001,2.017509225904e+001
    5192,-2.187501181250e+000,-9.560657710909e+001,2.036983765907e+001
    5193,-2.187501181250e+000,-9.561423147206e+001,2.050933328978e+001
    5194,-2.187501181250e+000,-9.181771125496e+001,1.956609376329e+001
    5195,-2.187501181250e+000,-9.197714605480e+001,1.956609376329e+001
    5196,-2.187501181250e+000,-9.216808501185e+001,1.953113140453e+001
    5197,-2.187501181250e+000,-9.237967138174e+001,1.953113140453e+001
    5198,-2.187501181250e+000,-9.207631192197e+001,1.934721450282e+001
    5199,-2.187501181250e+000,-9.263377012103e+001,1.951642003644e+001
    5200,-2.187501181250e+000,-9.287813747779e+001,1.951642003644e+001
    5201,-2.187501181250e+000,-9.252134961831e+001,1.929754077597e+001
    5202,-2.187501181250e+000,-9.367094611592e+001,1.954432821616e+001
    5203,-2.187501181250e+000,-9.391978360727e+001,1.954432821616e+001
    5204,-2.187501181250e+000,-9.414959049190e+001,1.957765247754e+001
    5205,-2.187501181250e+000,-9.435223659263e+001,1.957765247754e+001
    5206,-2.187501181250e+000,-9.403359574146e+001,1.937197002870e+001
    5207,-2.187501181250e+000,-9.453892945156e+001,1.959512293611e+001
    5208,-2.187501181250e+000,-9.468346380282e+001,1.959512293611e+001
    5209,-2.187501181250e+000,-9.481047803273e+001,1.947688235398e+001
    5210,-2.187501181250e+000,-9.445009548503e+001,1.942276474865e+001
    5211,-2.187501181250e+000,-9.084782010459e+001,2.040799153746e+001
    5212,-2.187501181250e+000,-9.086959250359e+001,2.028207382344e+001
    5213,-2.187501181250e+000,-9.091455527673e+001,2.006148600993e+001
    5214,-2.187501181250e+000,-9.101064869557e+001,1.991444390988e+001
    5215,-2.187501181250e+000,-9.119888027175e+001,1.976621905645e+001
    5216,-2.187501181250e+000,-9.133009694240e+001,1.968595106701e+001
    5217,-2.187501181250e+000,-9.152096327083e+001,1.962043681865e+001
    5218,-2.187501181250e+000,-9.164688098484e+001,1.959866441966e+001
    5219,-2.187501181250e+000,-9.081245809658e+001,2.593576047477e+001
    5220,-2.187501181250e+000,-9.081245809658e+001,2.577901039012e+001
    5221,-2.187501181250e+000,-9.078887145958e+001,2.555355258596e+001
    5222,-2.187501181250e+000,-9.078887145958e+001,2.534180247161e+001
    5223,-2.187501181250e+000,-9.060128041616e+001,2.564604910537e+001
    5224,-2.187501181250e+000,-9.082274344571e+001,2.511930334761e+001
    5225,-2.187501181250e+000,-9.082274344571e+001,2.486630321099e+001
    5226,-2.187501181250e+000,-9.061156576529e+001,2.519809217720e+001
    5227,-2.187501181250e+000,-9.063758977228e+001,2.408794232936e+001
    5228,-2.187501181250e+000,-9.063758977228e+001,2.378269216452e+001
    5229,-2.187501181250e+000,-9.065100948385e+001,2.342020128067e+001
    5230,-2.187501181250e+000,-9.065100948385e+001,2.311495111583e+001
    5231,-2.187501181250e+000,-9.078821481373e+001,2.218058089680e+001
    5232,-2.187501181250e+000,-9.078821481373e+001,2.187258073048e+001
    5233,-2.187501181250e+000,-9.080688912746e+001,2.109196056245e+001
    5234,-2.187501181250e+000,-9.080688912746e+001,2.088296044959e+001
    5235,-2.187501181250e+000,-9.085888192086e+001,2.071843335704e+001
    5236,-2.187501181250e+000,-9.085888192086e+001,2.056993327685e+001
    5237,-2.187501181250e+000,-9.066572190832e+001,2.080438257625e+001
    5238,-2.187501181250e+000,-9.164700398240e+001,2.687358425539e+001
    5239,-2.187501181250e+000,-9.151997719371e+001,2.685141453178e+001
    5240,-2.187501181250e+000,-9.133056172299e+001,2.679291939497e+001
    5241,-2.187501181250e+000,-9.119917069399e+001,2.671183398665e+001
    5242,-2.187501181250e+000,-9.100316173535e+001,2.656718252783e+001
    5243,-2.187501181250e+000,-9.090815439431e+001,2.642080016723e+001
    5244,-2.187501181250e+000,-9.088885138775e+001,2.621786742039e+001
    5245,-2.187501181250e+000,-9.086727634398e+001,2.609250471043e+001
    5246,-2.187501181250e+000,-9.396146844574e+001,2.689980810615e+001
    5247,-2.187501181250e+000,-9.382553970851e+001,2.689980810615e+001
    5248,-2.187501181250e+000,-9.364043698570e+001,2.692264391575e+001
    5249,-2.187501181250e+000,-9.347193028665e+001,2.692264391575e+001
    5250,-2.187501181250e+000,-9.374102863633e+001,2.707243757690e+001
    5251,-2.187501181250e+000,-9.324527333089e+001,2.697070994924e+001
    5252,-2.187501181250e+000,-9.302059773215e+001,2.697070994924e+001
    5253,-2.187501181250e+000,-9.332926895776e+001,2.714333941999e+001
    5254,-2.187501181250e+000,-9.279526944568e+001,2.695841684143e+001
    5255,-2.187501181250e+000,-9.255823668901e+001,2.695841684143e+001
    5256,-2.187501181250e+000,-9.287728371553e+001,2.717911234567e+001
    5257,-2.187501181250e+000,-9.234345394723e+001,2.691164708884e+001
    5258,-2.187501181250e+000,-9.213899915238e+001,2.691164708884e+001
    5259,-2.187501181250e+000,-9.243717268726e+001,2.712004948528e+001
    5260,-2.187501181250e+000,-9.195609623927e+001,2.688670573892e+001
    5261,-2.187501181250e+000,-9.180331683213e+001,2.688670573892e+001
    5262,-2.187501181250e+000,-9.203948703237e+001,2.704833838276e+001
    5263,-2.187501181250e+000,-9.351905483620e+001,3.622019208934e+001
    5264,-2.187501181250e+000,-9.348541433878e+001,3.633290732851e+001
    5265,-2.187501181250e+000,-9.339689857179e+001,3.648945038731e+001
    5266,-2.187501181250e+000,-9.329970637907e+001,3.661458102242e+001
    5267,-2.187501181250e+000,-9.315822313430e+001,3.672807416898e+001
    5268,-2.187501181250e+000,-9.303300477559e+001,3.679738525681e+001
    5269,-2.187501181250e+000,-9.288031000143e+001,3.685601353484e+001
    5270,-2.187501181250e+000,-9.276465038680e+001,3.687429535343e+001
    5271,-2.187501181250e+000,-9.440389553911e+001,2.966573277934e+001
    5272,-2.187501181250e+000,-9.438569552929e+001,2.980223285305e+001
    5273,-2.187501181250e+000,-9.438853991167e+001,2.998470980198e+001
    5274,-2.187501181250e+000,-9.436253989763e+001,3.017970990728e+001
    5275,-2.187501181250e+000,-9.453707551997e+001,2.991480373401e+001
    5276,-2.187501181250e+000,-9.443307224685e+001,3.099374511383e+001
    5277,-2.187501181250e+000,-9.439407222579e+001,3.128624527178e+001
    5278,-2.187501181250e+000,-9.402219716813e+001,3.382295282108e+001
    5279,-2.187501181250e+000,-9.398319714707e+001,3.411545297903e+001
    5280,-2.187501181250e+000,-9.396103000401e+001,3.447751994278e+001
    5281,-2.187501181250e+000,-9.392246331652e+001,3.476677009898e+001
    5282,-2.187501181250e+000,-9.429813421593e+001,3.428783160698e+001
    5283,-2.187501181250e+000,-9.381510119188e+001,3.504932887341e+001
    5284,-2.187501181250e+000,-9.377826783865e+001,3.532557902259e+001
    5285,-2.187501181250e+000,-9.416860494823e+001,3.493245734517e+001
    5286,-2.187501181250e+000,-9.358036347437e+001,3.593335306534e+001
    5287,-2.187501181250e+000,-9.356129679741e+001,3.607635314256e+001
    5288,-2.187501181250e+000,-9.364843038076e+001,2.863391935728e+001
    5289,-2.187501181250e+000,-9.377852939177e+001,2.865721030598e+001
    5290,-2.187501181250e+000,-9.395225791101e+001,2.872666003263e+001
    5291,-2.187501181250e+000,-9.408637802165e+001,2.881226139923e+001
    5292,-2.187501181250e+000,-9.424697093824e+001,2.895802468746e+001
    5293,-2.187501181250e+000,-9.434118054580e+001,2.911388740264e+001
    5294,-2.187501181250e+000,-9.439751033646e+001,2.932284719306e+001
    5295,-2.187501181250e+000,-9.441079227073e+001,2.948265378688e+001
    5296,-2.187501181250e+000,-9.184430973970e+001,2.858663154644e+001
    5297,-2.187501181250e+000,-9.202587882470e+001,2.858663154644e+001
    5298,-2.187501181250e+000,-9.227384518674e+001,2.855369339180e+001
    5299,-2.187501181250e+000,-9.253907845797e+001,2.855369339180e+001
    5300,-2.187501181250e+000,-9.218653629643e+001,2.839030941324e+001
    5301,-2.187501181250e+000,-9.279819783490e+001,2.855089758427e+001
    5302,-2.187501181250e+000,-9.306165101707e+001,2.855089758427e+001
    5303,-2.187501181250e+000,-9.269362203540e+001,2.835457545107e+001
    5304,-2.187501181250e+000,-9.328872756603e+001,2.859786631768e+001
    5305,-2.187501181250e+000,-9.346851656197e+001,2.859786631768e+001
    5306,-2.187501181250e+000,-9.317981796129e+001,2.839874837695e+001
    5307,-2.187501181250e+000,-9.088358770298e+001,2.937899925789e+001
    5308,-2.187501181250e+000,-9.090738150830e+001,2.924754881683e+001
    5309,-2.187501181250e+000,-9.097387325786e+001,2.906655538619e+001
    5310,-2.187501181250e+000,-9.107009700033e+001,2.892303492392e+001
    5311,-2.187501181250e+000,-9.121694884434e+001,2.878606611319e+001
    5312,-2.187501181250e+000,-9.134656878908e+001,2.870761185777e+001
    5313,-2.187501181250e+000,-9.152652039566e+001,2.863954462823e+001
    5314,-2.187501181250e+000,-9.165188310563e+001,2.861796958446e+001
    5315,-2.187501181250e+000,-9.174614330032e+001,2.845458560590e+001
    5316,-2.187501181250e+000,-9.137376505967e+001,2.855399087346e+001
    5317,-2.187501181250e+000,-9.083768485811e+001,3.587426682710e+001
    5318,-2.187501181250e+000,-9.083768485811e+001,3.572476674637e+001
    5319,-2.062501113750e+000,-9.251174325045e+001,1.936726473612e+000
    5320,-2.062501113750e+000,-9.280600895600e+001,1.936726473612e+000
    5321,-2.187501181250e+000,-9.083768485811e+001,3.551676663405e+001
    5322,-2.187501181250e+000,-9.065208664175e+001,3.461761233901e+001
    5323,-2.187501181250e+000,-9.065208664175e+001,3.433161218457e+001
    5324,-2.187501181250e+000,-9.067106921616e+001,3.399652156826e+001
    5325,-2.187501181250e+000,-9.067106921616e+001,3.371052141382e+001
    5326,-2.187501181250e+000,-9.067086289405e+001,3.289559626225e+001
    5327,-2.187501181250e+000,-9.067086289405e+001,3.260634610605e+001
    5328,-2.187501181250e+000,-9.066141317436e+001,3.228878547188e+001
    5329,-2.187501181250e+000,-9.066141317436e+001,3.199953531569e+001
    5330,-2.187501181250e+000,-9.066557504629e+001,3.110855602541e+001
    5331,-2.187501181250e+000,-9.066557504629e+001,3.081280586571e+001
    5332,-2.187501181250e+000,-9.072500905012e+001,3.054093683956e+001
    5333,-2.187501181250e+000,-9.072500905012e+001,3.029068670443e+001
    5334,-2.187501181250e+000,-9.039053495641e+001,3.067072613645e+001
    5335,-2.187501181250e+000,-9.085478655693e+001,2.967933321356e+001
    5336,-2.187501181250e+000,-9.085478655693e+001,2.953958313810e+001
    5337,-2.187501181250e+000,-9.163004634923e+001,3.688244516792e+001
    5338,-2.187501181250e+000,-9.150468363926e+001,3.686087012415e+001
    5339,-2.187501181250e+000,-9.132900651610e+001,3.679676056332e+001
    5340,-2.187501181250e+000,-9.119552487120e+001,3.671467421831e+001
    5341,-2.187501181250e+000,-9.104141527901e+001,3.655279093744e+001
    5342,-2.187501181250e+000,-9.094782996191e+001,3.640958673337e+001
    5343,-2.187501181250e+000,-9.086475353296e+001,3.621562330126e+001
    5344,-2.187501181250e+000,-9.084218300243e+001,3.608748869161e+001
    5345,-2.187501181250e+000,-9.261445128100e+001,3.689665145213e+001
    5346,-2.187501181250e+000,-9.247058732639e+001,3.689665145213e+001
    5347,-2.187501181250e+000,-9.228914992405e+001,3.690463757120e+001
    5348,-2.187501181250e+000,-9.211879673335e+001,3.690463757120e+001
    5349,-2.187501181250e+000,-9.238399368064e+001,3.705126917834e+001
    5350,-2.187501181250e+000,-9.193895472092e+001,3.690265539495e+001
    5351,-2.187501181250e+000,-9.179646089921e+001,3.690265539495e+001
    5352,-2.187501181250e+000,-9.202271426586e+001,3.705727312115e+001
    5353,-2.187501181250e+000,-9.903865713020e+001,2.597271147838e+000
    5354,-2.187501181250e+000,-9.004913158203e+001,2.340108093646e+000
    5355,-2.187501181250e+000,-9.837974643241e+001,6.408977190400e+000
    5356,-2.187501181250e+000,-9.795997214770e+001,5.997244202901e+000
    5357,-2.187501181250e+000,-9.832298292063e+001,6.834703528729e+000
    5358,-2.187501181250e+000,-9.879760735524e+001,4.456709184312e+000
    5359,-2.187501181250e+000,-9.848517886204e+001,4.120084695146e+000
    5360,-2.187501181250e+000,-9.873785629021e+001,4.904842172026e+000
    5361,-2.187501181250e+000,-9.898786872493e+001,2.978184187395e+000
    5362,-2.187501181250e+000,-9.824638072746e+001,5.030868769783e+000
    5363,-2.187501181250e+000,-9.860672650694e+001,3.156912634100e+000
    5364,-2.187501181250e+000,-9.784117820206e+001,7.046365053428e+000
    5365,-2.187501181250e+000,-9.820817103229e+001,8.758557932987e+000
    5366,-2.187501181250e+000,-9.826792209732e+001,8.310424945273e+000
    5367,-2.187501181250e+000,-9.757856154561e+001,1.084500269385e+001
    5368,-2.187501181250e+000,-9.796962301802e+001,1.070396831459e+001
    5369,-2.187501181250e+000,-9.802339897655e+001,1.030064862565e+001
    5370,-2.187501181250e+000,-9.727958389712e+001,1.500755768467e+001
    5371,-2.187501181250e+000,-9.733933496215e+001,1.455942469695e+001
    5372,-2.187501181250e+000,-9.687506386176e+001,1.719297750301e+001
    5373,-2.187501181250e+000,-9.713968952490e+001,1.699676425400e+001
    5374,-2.187501181250e+000,-9.719645303667e+001,1.657103791567e+001
    5375,-2.187501181250e+000,-9.689525103928e+001,1.858920343732e+001
    5376,-2.187501181250e+000,-9.695798965756e+001,1.811866380022e+001
    5377,-2.187501181250e+000,-9.671208043860e+001,2.042072410998e+001
    5378,-2.187501181250e+000,-9.676585639713e+001,2.001740442104e+001
    5379,-2.187501181250e+000,-9.653631288711e+001,2.148908518239e+001
    5380,-2.187501181250e+000,-9.659905150539e+001,2.101854554529e+001
    5381,-2.187501181250e+000,-9.658334022363e+001,2.068894780904e+001
    5382,-2.187501181250e+000,-9.622275457387e+001,2.090436809797e+001
    5383,-2.187501181250e+000,-9.611792970161e+001,2.174252298173e+001
    5384,-2.187501181250e+000,-9.606454962567e+001,2.422942018700e+001
    5385,-2.187501181250e+000,-9.612430069070e+001,2.378128719929e+001
    5386,-2.187501181250e+000,-9.596825958915e+001,2.512675286095e+001
    5387,-2.187501181250e+000,-9.603697331393e+001,2.461139992508e+001
    5388,-2.187501181250e+000,-9.579718570346e+001,2.696365652310e+001
    5389,-2.187501181250e+000,-9.585394921523e+001,2.653793018477e+001
    5390,-2.187501181250e+000,-9.551710453172e+001,2.870775291788e+001
    5391,-2.187501181250e+000,-9.558283070325e+001,2.821480663140e+001
    5392,-2.187501181250e+000,-9.492464899581e+001,3.074571815222e+001
    5393,-2.187501181250e+000,-9.536477176508e+001,3.052863154167e+001
    5394,-2.187501181250e+000,-9.542153527686e+001,3.010290520335e+001
    5395,-2.187501181250e+000,-9.435507220473e+001,3.157874542973e+001
    5396,-2.187501181250e+000,-9.472876551539e+001,3.419847301243e+001
    5397,-2.187501181250e+000,-9.479150413367e+001,3.372793337533e+001
    5398,-2.187501181250e+000,-9.463788464754e+001,3.507589291206e+001
    5399,-2.187501181250e+000,-9.470659837233e+001,3.456053997619e+001
    5400,-2.187501181250e+000,-9.449883939796e+001,3.704533257032e+001
    5401,-2.187501181250e+000,-9.455859046299e+001,3.659719958261e+001
    5402,-2.187501181250e+000,-9.448013111724e+001,3.631094133546e+001
    5403,-2.187501181250e+000,-9.414647127506e+001,3.659961428680e+001
    5404,-2.187501181250e+000,-9.411737862177e+001,3.724762208896e+001
    5405,-2.187501181250e+000,-9.408296722776e+001,3.883627074359e+001
    5406,-2.187501181250e+000,-9.415466850579e+001,3.829851115833e+001
    5407,-2.187501181250e+000,-9.394435362314e+001,4.067920276016e+001
    5408,-2.187501181250e+000,-9.401306734792e+001,4.016384982429e+001
    5409,-2.187501181250e+000,-9.362106158017e+001,4.258811355202e+001
    5410,-2.187501181250e+000,-9.368678775171e+001,4.209516726553e+001
    5411,-2.187501181250e+000,-9.338189070122e+001,4.458508192069e+001
    5412,-2.187501181250e+000,-9.344164176625e+001,4.413694893298e+001
    5413,-2.187501181250e+000,-9.337758946622e+001,4.596325071649e+001
    5414,-2.187501181250e+000,-9.341045255198e+001,4.571677757325e+001
    5415,-2.187501181250e+000,-8.984033654044e+001,4.439715311946e+001
    5416,-2.187501181250e+000,-9.012517495613e+001,4.465951462094e+001
    5417,-2.187501181250e+000,-8.984033654044e+001,4.403864672929e+001
    5418,-2.187501181250e+000,-9.299678760924e+001,4.637162498494e+001
    5419,-2.187501181250e+000,-9.196478097703e+001,4.646883716083e+001
    5420,-2.187501181250e+000,-9.225478113363e+001,4.646883716083e+001
    5421,-2.187501181250e+000,-9.079091475134e+001,4.648383497070e+001
    5422,-2.187501181250e+000,-9.107491490470e+001,4.648383497070e+001
    5423,-2.187501181250e+000,-9.122189522396e+001,4.620898501248e+001
    5424,-2.187501181250e+000,-9.065776810068e+001,4.623251292126e+001
    5425,-2.187501181250e+000,-8.975004520387e+001,4.554054041347e+001
    5426,-2.187501181250e+000,-8.975004520387e+001,4.589904680365e+001
    5427,-2.187501181250e+000,-9.018000191138e+001,4.391621016084e+001
    5428,-2.187501181250e+000,-8.985664403328e+001,4.258923451150e+001
    5429,-2.187501181250e+000,-8.985664403328e+001,4.294774090167e+001
    5430,-2.187501181250e+000,-9.019424320869e+001,4.161972613618e+001
    5431,-2.187501181250e+000,-8.984900643510e+001,4.026828699751e+001
    5432,-2.187501181250e+000,-8.984900643510e+001,4.060438673830e+001
    5433,-2.187501181250e+000,-8.993879523254e+001,3.884291395423e+001
    5434,-2.187501181250e+000,-8.993879523254e+001,3.920142034440e+001
    5435,-2.187501181250e+000,-8.986393087257e+001,3.725677209171e+001
    5436,-2.187501181250e+000,-8.986393087257e+001,3.759287183250e+001
    5437,-2.187501181250e+000,-8.983214938732e+001,3.574913831823e+001
    5438,-2.187501181250e+000,-8.983214938732e+001,3.615245800717e+001
    5439,-2.187501181250e+000,-9.032310671791e+001,3.416761530616e+001
    5440,-2.187501181250e+000,-8.990208623675e+001,3.424047050882e+001
    5441,-2.187501181250e+000,-8.990208623675e+001,3.464379019776e+001
    5442,-2.187501181250e+000,-9.033222692841e+001,3.246361406492e+001
    5443,-2.187501181250e+000,-8.992086248905e+001,3.268509876617e+001
    5444,-2.187501181250e+000,-8.992086248905e+001,3.304360515634e+001
    5445,-2.187501181250e+000,-9.032197094763e+001,3.124311865661e+001
    5446,-2.187501181250e+000,-8.990644463633e+001,3.134931971159e+001
    5447,-2.187501181250e+000,-8.990644463633e+001,3.170782610176e+001
    5448,-2.187501181250e+000,-9.065644504133e+001,3.140907951942e+001
    5449,-2.187501181250e+000,-8.976427287168e+001,2.977130424656e+001
    5450,-2.187501181250e+000,-8.976427287168e+001,3.012981063673e+001
    5451,-2.187501181250e+000,-8.979121631483e+001,2.835784035365e+001
    5452,-2.187501181250e+000,-8.979121631483e+001,2.871634674382e+001
    5453,-2.187501181250e+000,-8.983209808839e+001,2.678437109919e+001
    5454,-2.187501181250e+000,-8.983209808839e+001,2.718769078813e+001
    5455,-2.187501181250e+000,-8.979672445594e+001,2.538369448121e+001
    5456,-2.187501181250e+000,-8.979672445594e+001,2.574220087138e+001
    5457,-2.187501181250e+000,-9.028855011613e+001,2.363388071793e+001
    5458,-2.187501181250e+000,-8.988758936728e+001,2.383377398976e+001
    5459,-2.187501181250e+000,-8.988758936728e+001,2.421468702932e+001
    5460,-2.187501181250e+000,-8.990108157231e+001,2.238988605991e+001
    5461,-2.187501181250e+000,-8.990108157231e+001,2.272598580070e+001
    5462,-2.187501181250e+000,-9.015607971301e+001,2.088071682136e+001
    5463,-2.187501181250e+000,-8.978618390693e+001,2.096787869126e+001
    5464,-2.187501181250e+000,-8.978618390693e+001,2.134879173082e+001
    5465,-2.187501181250e+000,-8.982855696171e+001,1.940441864430e+001
    5466,-2.187501181250e+000,-8.982855696171e+001,1.976292503447e+001
    5467,-2.187501181250e+000,-8.980439450526e+001,1.803300907109e+001
    5468,-2.187501181250e+000,-8.980439450526e+001,1.839151546126e+001
    5469,-2.187501181250e+000,-8.985668723667e+001,1.656626132880e+001
    5470,-2.187501181250e+000,-8.985668723667e+001,1.696958101774e+001
    5471,-2.187501181250e+000,-8.977913478942e+001,1.505103634800e+001
    5472,-2.187501181250e+000,-8.977913478942e+001,1.540954273817e+001
    5473,-2.187501181250e+000,-9.029155882303e+001,1.345880839790e+001
    5474,-2.187501181250e+000,-8.989799082387e+001,1.363547067933e+001
    5475,-2.187501181250e+000,-8.989799082387e+001,1.399397706950e+001
    5476,-2.187501181250e+000,-9.064799122887e+001,1.364385218743e+001
    5477,-2.187501181250e+000,-9.029467233454e+001,1.206414956920e+001
    5478,-2.187501181250e+000,-8.990069376655e+001,1.218185649255e+001
    5479,-2.187501181250e+000,-8.990069376655e+001,1.254036288272e+001
    5480,-2.187501181250e+000,-9.021574630057e+001,1.049023759555e+001
    5481,-2.187501181250e+000,-8.980775639980e+001,1.067729769050e+001
    5482,-2.187501181250e+000,-8.980775639980e+001,1.105821073005e+001
    5483,-2.187501181250e+000,-8.981883936108e+001,9.138039481436e+000
    5484,-2.187501181250e+000,-8.981883936108e+001,9.518952520993e+000
    5485,-2.187501181250e+000,-8.984002611774e+001,7.739584313533e+000
    5486,-2.187501181250e+000,-8.984002611774e+001,8.098090703704e+000
    5487,-2.187501181250e+000,-8.985594409068e+001,6.234339903442e+000
    5488,-2.187501181250e+000,-8.985594409068e+001,6.637659592384e+000
    5489,-2.187501181250e+000,-8.980109339840e+001,4.792731789505e+000
    5490,-2.187501181250e+000,-8.980109339840e+001,5.151238179676e+000
    5491,-2.187501181250e+000,-8.979544380125e+001,3.325871733627e+000
    5492,-2.187501181250e+000,-8.979544380125e+001,3.684378123798e+000
    5493,-2.187501181250e+000,-9.652367254485e+001,9.564291683595e+000
    5494,-2.187501181250e+000,-9.684352898843e+001,9.832462260001e+000
    5495,-2.187501181250e+000,-9.704200843923e+001,1.021510144784e+001
    5496,-2.187501181250e+000,-9.711610286838e+001,1.061328987072e+001
    5497,-2.187501181250e+000,-9.081568291791e+001,1.012526328213e+001
    5498,-2.187501181250e+000,-9.101157223445e+001,9.810358038119e+000
    5499,-2.187501181250e+000,-9.077136413614e+001,1.564394497848e+001
    5500,-2.187501181250e+000,-9.077136413614e+001,1.535469482229e+001
    5501,-2.187501181250e+000,-9.028945397981e+001,1.415854713216e+001
    5502,-2.187501181250e+000,-9.064799122887e+001,1.393310234363e+001
    5503,-2.187501181250e+000,-9.064402730300e+001,1.200409245111e+001
    5504,-2.187501181250e+000,-9.064402730300e+001,1.170509228965e+001
    5505,-2.187501181250e+000,-9.133358848461e+001,1.796036259326e+001
    5506,-2.187501181250e+000,-9.100707091259e+001,1.772110781982e+001
    5507,-2.187501181250e+000,-9.077085433237e+001,1.737971013940e+001
    5508,-2.187501181250e+000,-9.070056904946e+001,1.702675416815e+001
    5509,-2.187501181250e+000,-9.344201210963e+001,1.797901264440e+001
    5510,-2.187501181250e+000,-9.315937806553e+001,1.797901264440e+001
    5511,-2.187501181250e+000,-9.606736144479e+001,1.757746031839e+001
    5512,-2.187501181250e+000,-9.574470795312e+001,1.791187058200e+001
    5513,-2.187501181250e+000,-9.530923565023e+001,1.806481227013e+001
    5514,-2.187501181250e+000,-9.684727180695e+001,1.513135585352e+001
    5515,-2.187501181250e+000,-9.660997680203e+001,1.435482810208e+001
    5516,-2.187501181250e+000,-9.621376425487e+001,1.717973091766e+001
    5517,-2.187501181250e+000,-9.620342917310e+001,1.646476908939e+001
    5518,-2.187501181250e+000,-9.617222915625e+001,1.669876921575e+001
    5519,-2.187501181250e+000,-9.490448934822e+001,2.660785926535e+001
    5520,-2.187501181250e+000,-9.452659384437e+001,2.692261710277e+001
    5521,-2.187501181250e+000,-9.410152092897e+001,2.702565538217e+001
    5522,-2.187501181250e+000,-9.551467446899e+001,2.501316434065e+001
    5523,-2.187501181250e+000,-9.540264483887e+001,2.351892329228e+001
    5524,-2.187501181250e+000,-9.536267815062e+001,2.381867345415e+001
    5525,-2.187501181250e+000,-9.532271146237e+001,2.411842361601e+001
    5526,-2.187501181250e+000,-9.517526588219e+001,1.960233935714e+001
    5527,-2.187501181250e+000,-9.550156095372e+001,1.986059553971e+001
    5528,-2.187501181250e+000,-9.569583011003e+001,2.022478726593e+001
    5529,-2.187501181250e+000,-9.577244459622e+001,2.060797034922e+001
    5530,-2.187501181250e+000,-9.314137350710e+001,1.952094157798e+001
    5531,-2.187501181250e+000,-9.342001189561e+001,1.952094157798e+001
    5532,-2.187501181250e+000,-9.074055384233e+001,2.009538419140e+001
    5533,-2.187501181250e+000,-9.097374819166e+001,1.972657152447e+001
    5534,-2.187501181250e+000,-9.135284609626e+001,1.951283242268e+001
    5535,-2.187501181250e+000,-9.171454269481e+001,1.941474751795e+001
    5536,-2.187501181250e+000,-9.079541723201e+001,2.464325309659e+001
    5537,-2.187501181250e+000,-9.079541723201e+001,2.435450294067e+001
    5538,-2.187501181250e+000,-9.030204232117e+001,2.290700556842e+001
    5539,-2.187501181250e+000,-9.065108197731e+001,2.275056685018e+001
    5540,-2.187501181250e+000,-9.065108197731e+001,2.244531668535e+001
    5541,-2.187501181250e+000,-9.135454294908e+001,2.693865892898e+001
    5542,-2.187501181250e+000,-9.077461098797e+001,2.161505127371e+001
    5543,-2.187501181250e+000,-9.077461098797e+001,2.135655113412e+001
    5544,-2.187501181250e+000,-9.070665288545e+001,2.047791374430e+001
    5545,-2.187501181250e+000,-9.170027126953e+001,2.701027554931e+001
    5546,-2.187501181250e+000,-9.096911851972e+001,2.673551233335e+001
    5547,-2.187501181250e+000,-9.075380655452e+001,2.638792812769e+001
    5548,-2.187501181250e+000,-9.067968530056e+001,2.602825114519e+001
    5549,-2.187501181250e+000,-9.354270109944e+001,3.649778495389e+001
    5550,-2.187501181250e+000,-9.367345882764e+001,3.619740294830e+001
    5551,-2.187501181250e+000,-9.331270208768e+001,3.676782115925e+001
    5552,-2.187501181250e+000,-9.301852406875e+001,3.693994258383e+001
    5553,-2.187501181250e+000,-9.271563018879e+001,3.702092696056e+001
    5554,-2.187501181250e+000,-9.436178946456e+001,3.040143010772e+001
    5555,-2.187501181250e+000,-9.432582277847e+001,3.067118025339e+001
    5556,-2.187501181250e+000,-9.405127133715e+001,3.549322719458e+001
    5557,-2.187501181250e+000,-9.376829635221e+001,3.560379009756e+001
    5558,-2.187501181250e+000,-9.406119718919e+001,3.353045266313e+001
    5559,-2.187501181250e+000,-9.394045066707e+001,2.858727291621e+001
    5560,-2.187501181250e+000,-9.427477210291e+001,2.880248593109e+001
    5561,-2.187501181250e+000,-9.449169481016e+001,2.915720900974e+001
    5562,-2.187501181250e+000,-9.454112786920e+001,2.954924779263e+001
    5563,-2.187501181250e+000,-9.083361801552e+001,2.907698915513e+001
    5564,-2.187501181250e+000,-9.358680832904e+001,2.848177014996e+001
    5565,-2.187501181250e+000,-9.073832511991e+001,2.941856646598e+001
    5566,-2.187501181250e+000,-9.104696160909e+001,2.875902691375e+001
    5567,-2.187501181250e+000,-9.065663503214e+001,3.497111828629e+001
    5568,-2.187501181250e+000,-9.030867253389e+001,3.485621186975e+001
    5569,-2.062501113750e+000,-9.308169807493e+001,1.936726473612e+000
    5570,-2.187501181250e+000,-9.073697665988e+001,3.344661916188e+001
    5571,-2.187501181250e+000,-9.073697665988e+001,3.315736900569e+001
    5572,-2.187501181250e+000,-9.031780907569e+001,3.184484779068e+001
    5573,-2.187501181250e+000,-9.065644504133e+001,3.169832967562e+001
    5574,-2.187501181250e+000,-9.080746100751e+001,3.005728533949e+001
    5575,-2.187501181250e+000,-9.080746100751e+001,2.985578523068e+001
    5576,-2.187501181250e+000,-9.133436603029e+001,3.695076093001e+001
    5577,-2.187501181250e+000,-9.100457931494e+001,3.672476808831e+001
    5578,-2.187501181250e+000,-9.076739329380e+001,3.636892137533e+001
    5579,-2.187501181250e+000,-9.067981872054e+001,3.596173607871e+001
    5580,-2.187501181250e+000,-9.167645770344e+001,3.703508071787e+001
    5581,-2.187501181250e+000,-9.542039451097e+001,2.906877456082e+001
    5582,-2.187501181250e+000,-9.512924564239e+001,2.933403412769e+001
    5583,-2.187501181250e+000,-9.535109303736e+001,2.708063650406e+001
    5584,-2.187501181250e+000,-9.785781865678e+001,7.984326884715e+000
    5585,-2.187501181250e+000,-9.550169712853e+001,2.638334804015e+001
    5586,-2.187501181250e+000,-9.519648910219e+001,2.788365362465e+001
    5587,-2.187501181250e+000,-9.369177102694e+001,3.901620903154e+001
    5588,-2.187501181250e+000,-9.382997124137e+001,3.807507433864e+001
    5589,-2.187501181250e+000,-9.368162221213e+001,3.989565512452e+001
    5590,-2.187501181250e+000,-9.326267921978e+001,4.165545445109e+001
    5591,-2.187501181250e+000,-9.308776092585e+001,4.377367010154e+001
    5592,-2.187501181250e+000,-9.311873406462e+001,4.546987451457e+001
    5593,-2.187501181250e+000,-9.003488361955e+001,4.539958222601e+001
    5594,-2.187501181250e+000,-9.247670992463e+001,4.621210332985e+001
    5595,-2.187501181250e+000,-9.018697510685e+001,4.080545219339e+001
    5596,-2.187501181250e+000,-9.026095164500e+001,3.936583272874e+001
    5597,-2.187501181250e+000,-9.031812092514e+001,3.777711358635e+001
    5598,-2.187501181250e+000,-9.020679486088e+001,3.627950552613e+001
    5599,-2.187501181250e+000,-9.005284457358e+001,2.891513668895e+001
    5600,-2.187501181250e+000,-9.019022299236e+001,2.738175637011e+001
    5601,-2.187501181250e+000,-9.016344937314e+001,2.592624401012e+001
    5602,-2.187501181250e+000,-9.019328613221e+001,2.444575987391e+001
    5603,-2.187501181250e+000,-9.007279451527e+001,2.151289371778e+001
    5604,-2.187501181250e+000,-8.989990778018e+001,2.001727388212e+001
    5605,-2.187501181250e+000,-9.022841641189e+001,1.982852633688e+001
    5606,-2.187501181250e+000,-9.009325155570e+001,1.855688731511e+001
    5607,-2.187501181250e+000,-9.022536924840e+001,1.718844135200e+001
    5608,-2.187501181250e+000,-9.007812292675e+001,1.562334101183e+001
    5609,-2.187501181250e+000,-9.020173496780e+001,1.127660354749e+001
    5610,-2.187501181250e+000,-9.022682926184e+001,9.735212114988e+000
    5611,-2.187501181250e+000,-9.016262930397e+001,8.289836407682e+000
    5612,-2.187501181250e+000,-9.020726867381e+001,6.828886937879e+000
    5613,-2.187501181250e+000,-9.012209253069e+001,5.339037626626e+000
    5614,-2.187501181250e+000,-9.010021761910e+001,3.842333756149e+000
    5615,-2.187501181250e+000,-9.631621037572e+001,1.681477802571e+001
    5616,-2.187501181250e+000,-9.305571348138e+001,1.820731435571e+001
    5617,-2.187501181250e+000,-9.055312628893e+001,1.524267180742e+001
    5618,-2.187501181250e+000,-9.355285463653e+001,1.931525912913e+001
    5619,-2.187501181250e+000,-9.563781962419e+001,2.431819105769e+001
    5620,-2.187501181250e+000,-9.043924765104e+001,2.227788551423e+001
    5621,-2.187501181250e+000,-9.058145097543e+001,2.123350024047e+001
    5622,-2.187501181250e+000,-9.040779041393e+001,3.304294744253e+001
    5623,-2.187501181250e+000,-9.319846701498e+001,4.274018765645e+001
    5624,-2.187501181250e+000,-9.304237136184e+001,4.469668525219e+001
    5625,-2.187501181250e+000,-9.321347008867e+001,4.600929316548e+001
    5626,-2.187501181250e+000,-9.019630940421e+001,4.316140407400e+001
    5627,-2.187501181250e+000,-9.023857634613e+001,3.700290657112e+001
    5628,-2.187501181250e+000,-9.023873568445e+001,3.558064695067e+001
    5629,-2.187501181250e+000,-9.019882300560e+001,2.658750119837e+001
    5630,-2.187501181250e+000,-9.010242122086e+001,2.525626093563e+001
    5631,-2.187501181250e+000,-9.017307651700e+001,1.787095636579e+001
    5632,-2.187501181250e+000,-9.015567537399e+001,1.644395986168e+001
