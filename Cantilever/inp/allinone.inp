    8449,-3.666260645140e+000,-8.925004819500e+001,4.304317891051e+001
    8450,-3.666260645140e+000,-8.925004819500e+001,4.275189246849e+001
    8451,-3.600727760400e+000,-8.925004819500e+001,4.419526956846e+001
    8452,-3.600727760400e+000,-8.925004819500e+001,4.390398312644e+001
    8453,-3.607381975042e+000,-8.925004819500e+001,4.542428597821e+001
    8454,-3.607381975042e+000,-8.925004819500e+001,4.511059288681e+001
    8455,-3.761062513268e+000,-8.925004819500e+001,4.641284288331e+001
    8456,-3.761062513268e+000,-8.925004819500e+001,4.623358968822e+001
    8457,-3.447567053615e+000,-8.925004819500e+001,4.637205068186e+001
    8458,-3.602396927588e+000,-8.925004819500e+001,4.654728277962e+001
    8459,-2.690100646542e+000,-8.925004819500e+001,4.650802830946e+001
    8460,-2.980823303532e+000,-8.925004819500e+001,4.650802830946e+001
    8461,-2.618283294956e+000,-8.925004819500e+001,4.526453758395e+001
    8462,-2.586159523388e+000,-8.925004819500e+001,4.458026082710e+001
    8463,-2.581441525954e+000,-8.925004819500e+001,4.389128635394e+001
    8464,-2.660689483689e+000,-8.925004819500e+001,4.242421549493e+001
    8465,-2.647585697118e+000,-8.925004819500e+001,4.078960585321e+001
    8466,-2.586544231125e+000,-8.925004819500e+001,3.935964417574e+001
    8467,-2.652066348128e+000,-8.925004819500e+001,3.781498775486e+001
    8468,-2.584166278483e+000,-8.925004819500e+001,3.636856907812e+001
    8469,-2.665855811345e+000,-8.925004819500e+001,3.488885344999e+001
    8470,-2.647849849930e+000,-8.925004819500e+001,3.330822040258e+001
    8471,-2.575276829470e+000,-8.925004819500e+001,3.181439713095e+001
    8472,-2.596416113764e+000,-8.925004819500e+001,3.039676191305e+001
    8473,-2.654546236837e+000,-8.925004819500e+001,2.887908395496e+001
    8474,-2.654627903063e+000,-8.925004819500e+001,2.739179190513e+001
    8475,-2.593038208068e+000,-8.925004819500e+001,2.586650826735e+001
    8476,-2.636291483422e+000,-8.925004819500e+001,2.442804638694e+001
    8477,-2.580928948083e+000,-8.925004819500e+001,2.289391585823e+001
    8478,-2.641241234306e+000,-8.925004819500e+001,2.147320163975e+001
    8479,-2.595914023983e+000,-8.925004819500e+001,1.995289297552e+001
    8480,-2.642730174631e+000,-8.925004819500e+001,1.852620567589e+001
    8481,-2.593676027882e+000,-8.925004819500e+001,1.701819963102e+001
    8482,-2.643180824601e+000,-8.925004819500e+001,1.557086135843e+001
    8483,-2.581779492126e+000,-8.925004819500e+001,1.410970694596e+001
    8484,-2.642099944725e+000,-8.925004819500e+001,1.262926446031e+001
    8485,-2.598307140929e+000,-8.925004819500e+001,1.114655175457e+001
    8486,-2.657323785748e+000,-8.925004819500e+001,9.578793455101e+000
    8487,-2.574535168953e+000,-8.925004819500e+001,8.166198362489e+000
    8488,-2.649573492563e+000,-8.925004819500e+001,6.750181648515e+000
    8489,-2.582300489126e+000,-8.925004819500e+001,5.264111643616e+000
    8490,-2.580581970309e+000,-8.925004819500e+001,3.897409068185e+000
    8491,-3.530687329834e+000,-8.925004819500e+001,2.162006331634e+000
    8492,-3.493177403433e+000,-8.925004819500e+001,2.631938487553e+000
    8493,-3.296601883271e+000,-8.925004819500e+001,3.640895627325e+000
    8494,-3.276313929567e+000,-8.925004819500e+001,4.876960405627e+000
    8495,-3.364522878131e+000,-8.925004819500e+001,6.060990045115e+000
    8496,-3.297271489554e+000,-8.925004819500e+001,7.195581088919e+000
    8497,-3.278208902058e+000,-8.925004819500e+001,8.435700725863e+000
    8498,-3.366001200138e+000,-8.925004819500e+001,9.622924158349e+000
    8499,-3.305545391396e+000,-8.925004819500e+001,1.077306819769e+001
    8500,-3.365042356510e+000,-8.925004819500e+001,1.196313250336e+001
    8501,-3.300702509817e+000,-8.925004819500e+001,1.308837136163e+001
    8502,-3.304056302344e+000,-8.925004819500e+001,1.433583462980e+001
    8503,-3.365346708725e+000,-8.925004819500e+001,1.545622752880e+001
    8504,-3.287284592057e+000,-8.925004819500e+001,1.664895663084e+001
    8505,-3.370768461565e+000,-8.925004819500e+001,1.785934881071e+001
    8506,-3.295771932903e+000,-8.925004819500e+001,1.898441099618e+001
    8507,-3.297798969251e+000,-8.925004819500e+001,2.021674553553e+001
    8508,-3.370223228189e+000,-8.925004819500e+001,2.135426192499e+001
    8509,-3.281393657383e+000,-8.925004819500e+001,2.254987494118e+001
    8510,-3.368827677619e+000,-8.925004819500e+001,2.374510142420e+001
    8511,-3.302976356833e+000,-8.925004819500e+001,2.488721736210e+001
    8512,-3.301428578520e+000,-8.925004819500e+001,2.612472488652e+001
    8513,-3.373137898461e+000,-8.925004819500e+001,2.725342424924e+001
    8514,-3.305932120569e+000,-8.925004819500e+001,2.845577503681e+001
    8515,-3.372182576182e+000,-8.925004819500e+001,2.958476846611e+001
    8516,-3.290060700780e+000,-8.925004819500e+001,3.078747722654e+001
    8517,-3.307163791448e+000,-8.925004819500e+001,3.203981444184e+001
    8518,-3.375305401366e+000,-8.925004819500e+001,3.316430976686e+001
    8519,-3.374746599117e+000,-8.925004819500e+001,3.431324782574e+001
    8520,-3.302220028632e+000,-8.925004819500e+001,3.545077045041e+001
    8521,-3.281452947722e+000,-8.925004819500e+001,3.670915262992e+001
    8522,-3.364483755263e+000,-8.925004819500e+001,3.791081642434e+001
    8523,-3.295809647653e+000,-8.925004819500e+001,3.905811949721e+001
    8524,-3.294248227126e+000,-8.925004819500e+001,4.029828884707e+001
    8525,-3.368640827360e+000,-8.925004819500e+001,4.142533669735e+001
    8526,-3.373265861294e+000,-8.925004819500e+001,4.259784175647e+001
    8527,-3.300856779874e+000,-8.925004819500e+001,4.371367847655e+001
    8528,-3.295797668874e+000,-8.925004819500e+001,4.494933512492e+001
    8529,-3.487768925534e+000,-8.925004819500e+001,4.612844339991e+001
    8530,-2.643662362340e+000,-8.925004819500e+001,4.317602245798e+001
    8531,-2.661940686987e+000,-8.925004819500e+001,4.160132153443e+001
    8532,-2.586896185054e+000,-8.925004819500e+001,4.006319049554e+001
    8533,-2.598813404545e+000,-8.925004819500e+001,3.564659162849e+001
    8534,-2.665319258398e+000,-8.925004819500e+001,3.409822473332e+001
    8535,-2.633201879817e+000,-8.925004819500e+001,3.254293962683e+001
    8536,-2.601920605842e+000,-8.925004819500e+001,2.815189455072e+001
    8537,-2.657078004527e+000,-8.925004819500e+001,2.660694103555e+001
    8538,-2.583220158222e+000,-8.925004819500e+001,2.515652140437e+001
    8539,-2.636473571516e+000,-8.925004819500e+001,2.364169728025e+001
    8540,-2.581544575067e+000,-8.925004819500e+001,2.220173483294e+001
    8541,-2.650926952950e+000,-8.925004819500e+001,2.070205563153e+001
    8542,-2.589164221683e+000,-8.925004819500e+001,1.924580892806e+001
    8543,-2.645349224593e+000,-8.925004819500e+001,1.777204322640e+001
    8544,-2.591472873734e+000,-8.925004819500e+001,1.629569879433e+001
    8545,-2.641448257859e+000,-8.925004819500e+001,1.483046359182e+001
    8546,-2.582610140472e+000,-8.925004819500e+001,1.337996240937e+001
    8547,-2.644282782200e+000,-8.925004819500e+001,1.187880189593e+001
    8548,-2.655867841801e+000,-8.925004819500e+001,1.037718780151e+001
    8549,-2.588787939182e+000,-8.925004819500e+001,8.849482417235e+000
    8550,-2.585411399475e+000,-8.925004819500e+001,7.480001539079e+000
    8551,-2.647381278748e+000,-8.925004819500e+001,5.988557362937e+000
    8552,-2.572114280691e+000,-8.925004819500e+001,4.577995515130e+000
    8553,-2.621324261491e+000,-8.925004819500e+001,3.187819665904e+000
    8554,-3.292447019739e+000,-8.925004819500e+001,5.488139525328e+000
    8555,-3.367971127014e+000,-8.925004819500e+001,6.609242694168e+000
    8556,-3.278340026036e+000,-8.925004819500e+001,7.815048863919e+000
    8557,-3.294124281717e+000,-8.925004819500e+001,9.048770129188e+000
    8558,-3.373085417384e+000,-8.925004819500e+001,1.017751472634e+001
    8559,-3.299231677805e+000,-8.925004819500e+001,1.138871782613e+001
    8560,-3.365393881753e+000,-8.925004819500e+001,1.250693976310e+001
    8561,-3.294960512779e+000,-8.925004819500e+001,1.371243639751e+001
    8562,-3.366163545644e+000,-8.925004819500e+001,1.491394851233e+001
    8563,-3.296442352504e+000,-8.925004819500e+001,1.603176310635e+001
    8564,-3.304877467922e+000,-8.925004819500e+001,1.727251176962e+001
    8565,-3.365370110435e+000,-8.925004819500e+001,1.840849576793e+001
    8566,-3.283118658854e+000,-8.925004819500e+001,1.959848046054e+001
    8567,-3.369356966064e+000,-8.925004819500e+001,2.080079053477e+001
    8568,-3.297606415003e+000,-8.925004819500e+001,2.193581318258e+001
    8569,-3.298921836607e+000,-8.925004819500e+001,2.316420565567e+001
    8570,-3.371414100472e+000,-8.925004819500e+001,2.430030113543e+001
    8571,-3.287265107410e+000,-8.925004819500e+001,2.550679774707e+001
    8572,-3.369333786119e+000,-8.925004819500e+001,2.670336608855e+001
    8573,-3.308550139035e+000,-8.925004819500e+001,2.783987274775e+001
    8574,-3.370738467046e+000,-8.925004819500e+001,2.903804523047e+001
    8575,-3.308118256438e+000,-8.925004819500e+001,3.016401772484e+001
    8576,-3.289002717370e+000,-8.925004819500e+001,3.141813371497e+001
    8577,-3.371344229067e+000,-8.925004819500e+001,3.261860082732e+001
    8578,-3.323475325380e+000,-8.925004819500e+001,3.373671137959e+001
    8579,-3.371104862517e+000,-8.925004819500e+001,3.486466071366e+001
    8580,-3.286295153647e+000,-8.925004819500e+001,3.607905426387e+001
    8581,-3.293816932294e+000,-8.925004819500e+001,3.732975226281e+001
    8582,-3.366640365011e+000,-8.925004819500e+001,3.846580082922e+001
    8583,-3.281092651483e+000,-8.925004819500e+001,3.968209196126e+001
    8584,-3.364756768123e+000,-8.925004819500e+001,4.087435342618e+001
    8585,-3.318788145146e+000,-8.925004819500e+001,4.201177500228e+001
    8586,-3.366389664614e+000,-8.925004819500e+001,4.314416070263e+001
    8587,-3.289143454233e+000,-8.925004819500e+001,4.432529824858e+001
    8588,-3.334088387308e+000,-8.925004819500e+001,4.558801948253e+001
    8589,-2.587493213688e+000,-8.925004819500e+001,3.707421205894e+001
    8590,-2.653910612089e+000,-8.925004819500e+001,2.963576566794e+001
    8591,-3.276693035011e+000,-8.925004819500e+001,4.260287521851e+000
    8592,-3.366248653122e+000,-8.925004819500e+001,3.077244500524e+000
    8593,-3.046745548766e+000,-8.925004819500e+001,4.633279621170e+001
    8594,-2.928970698752e+000,-8.925004819500e+001,4.443923987238e+001
    8595,-2.942522322891e+000,-8.925004819500e+001,4.477599872509e+001
    8596,-2.941614281434e+000,-8.925004819500e+001,4.377734473015e+001
    8597,-2.932780654730e+000,-8.925004819500e+001,4.412956035059e+001
    8598,-2.973420969127e+000,-8.925004819500e+001,4.217727857069e+001
    8599,-3.009781057460e+000,-8.925004819500e+001,4.256603725822e+001
    8600,-3.007307863005e+000,-8.925004819500e+001,4.143581796602e+001
    8601,-2.969696571375e+000,-8.925004819500e+001,4.186995323899e+001
    8602,-2.951457522270e+000,-8.925004819500e+001,4.050725428661e+001
    8603,-3.003423803769e+000,-8.925004819500e+001,4.088483469485e+001
    8604,-2.929686889911e+000,-8.925004819500e+001,3.985422505600e+001
    8605,-2.938410120475e+000,-8.925004819500e+001,4.020306000543e+001
    8606,-2.929578716062e+000,-8.925004819500e+001,3.954222245136e+001
    8607,-2.937949992697e+000,-8.925004819500e+001,3.918751108100e+001
    8608,-2.950425388690e+000,-8.925004819500e+001,3.552184651402e+001
    8609,-2.961648739060e+000,-8.925004819500e+001,3.520948999895e+001
    8610,-2.934683169502e+000,-8.925004819500e+001,3.620379937835e+001
    8611,-2.931076738013e+000,-8.925004819500e+001,3.655975126205e+001
    8612,-3.012052684913e+000,-8.925004819500e+001,2.955604552653e+001
    8613,-2.959952344293e+000,-8.925004819500e+001,2.993585640487e+001
    8614,-3.017650451287e+000,-8.925004819500e+001,3.481777738639e+001
    8615,-2.964753922713e+000,-8.925004819500e+001,3.386744839436e+001
    8616,-3.021292187888e+000,-8.925004819500e+001,3.426636449847e+001
    8617,-3.006571252596e+000,-8.925004819500e+001,3.317748338780e+001
    8618,-2.967502395890e+000,-8.925004819500e+001,3.356857161444e+001
    8619,-2.948893253479e+000,-8.925004819500e+001,3.225758189915e+001
    8620,-3.002610080297e+000,-8.925004819500e+001,3.263177444826e+001
    8621,-2.933547367440e+000,-8.925004819500e+001,3.159662967364e+001
    8622,-2.937755590969e+000,-8.925004819500e+001,3.195097962041e+001
    8623,-2.948708866506e+000,-8.925004819500e+001,2.797521813127e+001
    8624,-2.949869781628e+000,-8.925004819500e+001,2.832553670087e+001
    8625,-2.959143859904e+000,-8.925004819500e+001,2.863245145626e+001
    8626,-3.010608575777e+000,-8.925004819500e+001,2.900932229089e+001
    8627,-2.949976183614e+000,-8.925004819500e+001,3.024373786625e+001
    8628,-2.922942617739e+000,-8.925004819500e+001,4.403440601248e+000
    8629,-2.925680429011e+000,-8.925004819500e+001,4.095466296939e+000
    8630,-2.959246952371e+000,-8.925004819500e+001,2.633132156733e+001
    8631,-3.010665063251e+000,-8.925004819500e+001,2.670638836093e+001
    8632,-2.935219834217e+000,-8.925004819500e+001,2.565991158654e+001
    8633,-2.947841519796e+000,-8.925004819500e+001,2.602527756114e+001
    8634,-2.935265431415e+000,-8.925004819500e+001,2.500340756490e+001
    8635,-2.932461795682e+000,-8.925004819500e+001,2.534802845329e+001
    8636,-3.004002408839e+000,-8.925004819500e+001,2.431185618414e+001
    8637,-2.953734719373e+000,-8.925004819500e+001,2.469571031319e+001
    8638,-2.951330384615e+000,-8.925004819500e+001,2.335416149526e+001
    8639,-3.001415985986e+000,-8.925004819500e+001,2.375665647291e+001
    8640,-2.928520400075e+000,-8.925004819500e+001,2.270396001864e+001
    8641,-2.933979422136e+000,-8.925004819500e+001,2.304924646301e+001
    8642,-2.934417832375e+000,-8.925004819500e+001,2.204764975547e+001
    8643,-2.928343183330e+000,-8.925004819500e+001,2.239454433640e+001
    8644,-3.004429816934e+000,-8.925004819500e+001,2.136136506686e+001
    8645,-2.950807806739e+000,-8.925004819500e+001,2.174300367912e+001
    8646,-2.959627263258e+000,-8.925004819500e+001,2.041838628068e+001
    8647,-3.003563554808e+000,-8.925004819500e+001,2.080789367664e+001
    8648,-2.934085729976e+000,-8.925004819500e+001,1.975125223037e+001
    8649,-2.945162367392e+000,-8.925004819500e+001,2.011090749041e+001
    8650,-2.938197150562e+000,-8.925004819500e+001,1.909303715823e+001
    8651,-2.933870315446e+000,-8.925004819500e+001,1.944046594564e+001
    8652,-3.000304956973e+000,-8.925004819500e+001,1.841757951384e+001
    8653,-2.951065839141e+000,-8.925004819500e+001,1.878975397859e+001
    8654,-2.959083240233e+000,-8.925004819500e+001,1.748644457189e+001
    8655,-3.005703308103e+000,-8.925004819500e+001,1.786843255662e+001
    8656,-2.939470255571e+000,-8.925004819500e+001,1.680426682874e+001
    8657,-2.944523384412e+000,-8.925004819500e+001,1.717612243940e+001
    8658,-2.939287210219e+000,-8.925004819500e+001,1.614038859643e+001
    8659,-2.936437235526e+000,-8.925004819500e+001,1.649103382246e+001
    8660,-3.000335966886e+000,-8.925004819500e+001,1.546223586835e+001
    8661,-2.951477990711e+000,-8.925004819500e+001,1.583642807823e+001
    8662,-2.950562260888e+000,-8.925004819500e+001,1.455375129515e+001
    8663,-3.001152803805e+000,-8.925004819500e+001,1.491995685189e+001
    8664,-2.935273533581e+000,-8.925004819500e+001,1.389179028062e+001
    8665,-2.944351756398e+000,-8.925004819500e+001,1.424634136974e+001
    8666,-2.942297119670e+000,-8.925004819500e+001,1.320060852626e+001
    8667,-2.932388248507e+000,-8.925004819500e+001,1.357580197373e+001
    8668,-3.000505334873e+000,-8.925004819500e+001,1.251702729568e+001
    8669,-2.950924401782e+000,-8.925004819500e+001,1.289253179728e+001
    8670,-2.952755714013e+000,-8.925004819500e+001,1.159826197315e+001
    8671,-3.000153809629e+000,-8.925004819500e+001,1.197322003594e+001
    8672,-2.944783104721e+000,-8.925004819500e+001,1.093700760755e+001
    8673,-2.943360650376e+000,-8.925004819500e+001,1.129429968612e+001
    8674,-2.960491881949e+000,-8.925004819500e+001,1.062532026615e+001
    8675,-3.016630128477e+000,-8.925004819500e+001,1.021324839166e+001
    8676,-2.954863608650e+000,-8.925004819500e+001,9.272335351753e+000
    8677,-3.009545911231e+000,-8.925004819500e+001,9.658657823667e+000
    8678,-2.928048612249e+000,-8.925004819500e+001,8.625917194670e+000
    8679,-2.941902156234e+000,-8.925004819500e+001,8.968905760622e+000
    8680,-2.924695458763e+000,-8.925004819500e+001,7.975981893683e+000
    8681,-2.925094685006e+000,-8.925004819500e+001,8.316277382477e+000
    8682,-2.939055966748e+000,-8.925004819500e+001,7.319068509315e+000
    8683,-2.927780509984e+000,-8.925004819500e+001,7.664969843931e+000
    8684,-3.007789015369e+000,-8.925004819500e+001,6.626694228119e+000
    8685,-2.954902379045e+000,-8.925004819500e+001,7.010612784067e+000
    8686,-2.949261916346e+000,-8.925004819500e+001,5.700735849436e+000
    8687,-3.004340766486e+000,-8.925004819500e+001,6.078441579065e+000
    8688,-2.925485592519e+000,-8.925004819500e+001,5.051515319508e+000
    8689,-2.935487532002e+000,-8.925004819500e+001,5.398255309201e+000
    8690,-2.923126886691e+000,-8.925004819500e+001,4.742816740042e+000
    8691,-2.934332387581e+000,-8.925004819500e+001,3.754255988788e+000
    8692,-2.983593757182e+000,-8.925004819500e+001,3.074459304441e+000
    8693,-2.951503424570e+000,-8.925004819500e+001,3.442838398571e+000
    8694,-2.949517651098e+000,-8.925004819500e+001,4.347540447990e+001
    8695,-3.036069490043e+000,-8.925004819500e+001,2.822225767857e+000
    8696,-3.067164838276e+000,-8.925004819500e+001,2.697898555677e+001
    8697,-3.014469175592e+000,-8.925004819500e+001,2.725644652161e+001
    8698,-2.960600963248e+000,-8.925004819500e+001,2.766623059760e+001
    8699,-2.926523955872e+000,-8.925004819500e+001,3.128155122552e+001
    8700,-2.930936056703e+000,-8.925004819500e+001,3.687392232970e+001
    8701,-2.950374089279e+000,-8.925004819500e+001,3.753004199205e+001
    8702,-2.937869423397e+000,-8.925004819500e+001,3.722361342682e+001
    8703,-3.066176014112e+000,-8.925004819500e+001,3.819576218715e+001
    8704,-3.008013857025e+000,-8.925004819500e+001,3.792112659085e+001
    8705,-3.010170466773e+000,-8.925004819500e+001,3.847611099573e+001
    8706,-3.002904860780e+000,-8.925004819500e+001,4.311235620438e+001
    8707,-2.952986493510e+000,-8.925004819500e+001,4.509035607965e+001
    8708,-2.999385188754e+000,-8.925004819500e+001,4.576220098683e+001
    8709,-2.971558640939e+000,-8.925004819500e+001,4.543787398379e+001
    8710,-2.952775162716e+000,-8.925004819500e+001,3.887554122159e+001
    8711,-2.936500630931e+000,-8.925004819500e+001,3.094050127333e+001
    8712,-3.060534375855e+000,-8.925004819500e+001,4.284477868070e+001
    8713,-3.060884942971e+000,-8.925004819500e+001,4.115670499278e+001
    8714,-3.066140843978e+000,-8.925004819500e+001,2.928467772917e+001
    8715,-3.075311934803e+000,-8.925004819500e+001,3.454402416470e+001
    8716,-3.055652855406e+000,-8.925004819500e+001,3.290395855500e+001
    8717,-2.944582025909e+000,-8.925004819500e+001,3.062492323302e+001
    8718,-3.053970864520e+000,-8.925004819500e+001,2.403263720919e+001
    8719,-3.060656655756e+000,-8.925004819500e+001,2.108445988562e+001
    8720,-3.057034445925e+000,-8.925004819500e+001,1.814494746522e+001
    8721,-3.057049542614e+000,-8.925004819500e+001,1.519066080900e+001
    8722,-3.056569424697e+000,-8.925004819500e+001,1.224367242613e+001
    8723,-3.062642240533e+000,-8.925004819500e+001,6.348811558616e+000
    8724,-3.625479150732e+000,-8.925004819500e+001,2.294032478957e+000
    8725,-3.472838599985e+000,-8.925004819500e+001,2.306839863845e+000
    8726,-2.856801725284e+000,-8.925004819500e+001,2.613272014932e+000
    8727,-3.239456621224e+000,-8.925004819500e+001,2.616057211014e+000
    8728,-3.068461377236e+000,-8.925004819500e+001,9.929382261697e+000
    8729,-2.939384694118e+000,-8.925004819500e+001,3.588787207994e+001
    8730,-3.086947420684e+000,-8.925004819500e+001,4.608918892975e+001
    8731,-3.313909638674e+000,-8.925004819500e+001,2.422984734628e+000
    8732,-3.321713063204e+000,-8.925004819500e+001,4.615595376752e+001
    8733,-2.062501113750e+000,-9.022630807922e+001,1.936726473612e+000
    8734,-2.062501113750e+000,-8.994001553265e+001,1.936726473612e+000
    8735,-2.062501113750e+000,-9.054986693311e+001,1.036989659014e+001
    8736,-2.062501113750e+000,-9.074261362754e+001,1.044611722384e+001
    8737,-2.062501113750e+000,-9.048287255800e+001,1.052931477723e+001
    8738,-2.062501113750e+000,-9.067561925243e+001,1.060553541093e+001
    8739,-2.062501113750e+000,-9.032296775596e+001,1.028264623104e+001
    8740,-2.062501113750e+000,-9.022268592499e+001,1.065093747754e+001
    8741,-2.062501113750e+000,-9.090811607447e+001,1.026843240213e+001
    8742,-2.062501113750e+000,-9.095397250653e+001,1.009724861702e+001
    8743,-2.680155253772e+000,-8.937504826250e+001,1.628502209947e+001
    8744,-3.025119615565e+000,-8.937504826250e+001,1.648035712760e+001
    8745,-2.684269006758e+000,-8.937504826250e+001,1.594395131847e+001
    8746,-3.029233368551e+000,-8.937504826250e+001,1.613928634660e+001
    8747,-3.061498628851e+000,-8.937504826250e+001,8.340251236957e+000
    8748,-3.064452556094e+000,-8.937504826250e+001,8.649891049150e+000
    8749,-2.711338339042e+000,-8.937504826250e+001,8.530467705764e+000
    8750,-2.062501113750e+000,-9.169844067237e+001,1.809119822083e+001
    8751,-2.062501113750e+000,-9.164195971706e+001,1.789146068927e+001
    8752,-2.062501113750e+000,-9.151882126182e+001,1.803891114524e+001
    8753,-2.062501113750e+000,-9.568011793299e+001,2.561495277638e+001
    8754,-2.062501113750e+000,-9.554518985819e+001,2.524413377154e+001
    8755,-2.062501113750e+000,-9.534064331166e+001,2.551318127342e+001
    8756,-2.062501113750e+000,-9.466322810490e+001,2.663038279877e+001
    8757,-3.287549732626e+000,-9.631099705077e+001,2.708662173814e+001
    8758,-3.589126506333e+000,-9.624859122676e+001,2.755466541828e+001
    8759,-2.991214640251e+000,-9.627120859719e+001,2.738503514002e+001
    8760,-2.062501113750e+000,-9.073697665988e+001,3.315086900218e+001
    8761,-2.062501113750e+000,-9.046439701877e+001,3.329324192959e+001
    8762,-2.062501113750e+000,-9.073697665988e+001,3.343036915311e+001
    8763,-2.062501113750e+000,-9.354122943067e+001,2.708627326933e+001
    8764,-2.062501113750e+000,-9.367914712243e+001,2.719867307908e+001
    8765,-2.062501113750e+000,-9.373312120924e+001,2.705667028452e+001
    8766,-2.636543431451e+000,-9.616045706686e+001,2.821567161753e+001
    8767,-3.079037242134e+000,-9.611252380415e+001,2.857517108783e+001
    8768,-3.102059114079e+000,-9.616905973981e+001,2.815115157037e+001
    8769,-2.062501113750e+000,-9.478553484652e+001,3.426769862993e+001
    8770,-2.062501113750e+000,-9.468776157391e+001,3.470020507610e+001
    8771,-2.062501113750e+000,-9.435490354707e+001,3.435705722448e+001
    8772,-2.062501113750e+000,-9.425713027446e+001,3.478956367064e+001
    8773,-2.062501113750e+000,-9.171750403161e+001,1.942293520135e+001
    8774,-2.062501113750e+000,-9.154667376149e+001,1.945550585772e+001
    8775,-2.062501113750e+000,-9.159880382661e+001,1.925346809570e+001
    8776,-2.062501113750e+000,-9.351797580951e+001,4.661558534869e+001
    8777,-2.062501113750e+000,-9.372775800002e+001,4.646091461881e+001
    8778,-2.062501113750e+000,-9.370383114125e+001,4.664036605958e+001
    8779,-2.062501113750e+000,-9.181659378487e+001,1.790067913213e+001
    8780,-2.062501113750e+000,-9.197514459009e+001,1.790067913213e+001
    8781,-2.062501113750e+000,-9.187307474017e+001,1.810041666369e+001
    8782,-2.062501113750e+000,-9.333297611048e+001,4.559585331386e+001
    8783,-2.062501113750e+000,-9.357195171107e+001,4.550876851633e+001
    8784,-2.062501113750e+000,-9.335582327455e+001,4.589522073481e+001
    8785,-2.062501113750e+000,-9.359479887513e+001,4.580813593728e+001
    8786,-3.045187042463e+000,-8.937504826250e+001,2.764014684958e+001
    8787,-3.033294945720e+000,-8.937504826250e+001,2.794913438325e+001
    8788,-3.347236239017e+000,-8.937504826250e+001,2.773822749924e+001
    8789,-3.335344142275e+000,-8.937504826250e+001,2.804721503291e+001
    8790,-2.062501113750e+000,-9.349255170963e+001,4.645649031972e+001
    8791,-2.062501113750e+000,-9.331943502617e+001,4.646926378696e+001
    8792,-2.062501113750e+000,-9.335233275810e+001,4.632327957363e+001
    8793,-2.062501113750e+000,-9.645706005757e+001,2.043424742421e+001
    8794,-2.062501113750e+000,-9.615972357003e+001,2.040785874619e+001
    8795,-2.062501113750e+000,-9.658580027254e+001,2.016602372514e+001
    8796,-2.062501113750e+000,-9.628846378500e+001,2.013963504713e+001
    8797,-3.638048871972e+000,-8.937504826250e+001,2.504927011705e+001
    8798,-2.062501113750e+000,-9.382340265730e+001,4.574357968923e+001
    8799,-2.062501113750e+000,-9.386826551749e+001,4.540710823778e+001
    8800,-2.387423705424e+000,-9.382967260540e+001,4.569655507843e+001
    8801,-2.062501113750e+000,-9.597033027226e+001,2.066181925493e+001
    8802,-2.062501113750e+000,-9.574425980394e+001,2.058420040706e+001
    8803,-2.062501113750e+000,-9.576180204469e+001,2.077263809031e+001
    8804,-2.062501113750e+000,-9.598043468905e+001,2.049674688360e+001
    8805,-2.062501113750e+000,-9.588758047092e+001,2.028641795020e+001
    8806,-2.062501113750e+000,-9.575436422073e+001,2.041912803573e+001
    8807,-3.486280417754e+000,-9.935890815765e+001,4.227288436539e+000
    8808,-2.062501113750e+000,-9.606686935189e+001,2.019752981279e+001
    8809,-2.062501113750e+000,-9.208309604945e+001,1.812969037360e+001
    8810,-2.062501113750e+000,-9.151406982611e+001,3.702689300236e+001
    8811,-2.062501113750e+000,-9.133148042862e+001,3.694252263814e+001
    8812,-2.062501113750e+000,-9.150468363926e+001,3.686087012415e+001
    8813,-2.062501113750e+000,-8.992400489155e+001,3.475242357180e+000
    8814,-2.062501113750e+000,-8.989021765979e+001,3.172945153442e+000
    8815,-2.062501113750e+000,-9.015180677607e+001,3.223398893475e+000
    8816,-3.643309882592e+000,-8.937504826250e+001,2.135760709737e+001
    8817,-3.402283860803e+000,-8.937504826250e+001,2.120343639904e+001
    8818,-3.346057021981e+000,-8.937504826250e+001,2.148034158029e+001
    8819,-2.397245921324e+000,-8.937504826250e+001,2.053543009658e+001
    8820,-2.062501113750e+000,-8.937504826250e+001,2.075831195759e+001
    8821,-2.441182212875e+000,-8.937504826250e+001,2.092493749254e+001
    8822,-2.062501113750e+000,-9.391607952602e+001,9.520564257606e+000
    8823,-2.062501113750e+000,-9.729100120050e+001,1.075760536201e+001
    8824,-2.062501113750e+000,-9.756080109081e+001,1.060647266501e+001
    8825,-2.062501113750e+000,-9.728759350574e+001,1.056007943745e+001
    8826,-2.062501113750e+000,-9.023193789520e+001,3.573150707466e+000
    8827,-2.062501113750e+000,-9.050554659850e+001,3.357411791793e+000
    8828,-2.062501113750e+000,-9.042541547937e+001,3.007659977802e+000
    8829,-2.062501113750e+000,-9.071403165391e+001,3.072845105153e+000
    8830,-2.062501113750e+000,-9.119659064007e+001,1.912428174884e+001
    8831,-2.062501113750e+000,-9.137105839341e+001,1.898017358634e+001
    8832,-2.062501113750e+000,-9.142651701062e+001,1.914582847856e+001
    8833,-2.062501113750e+000,-9.160098476396e+001,1.900172031606e+001
    8834,-2.062501113750e+000,-9.030118695435e+001,8.465649197150e+000
    8835,-2.062501113750e+000,-9.031856155586e+001,8.116592596499e+000
    8836,-2.062501113750e+000,-9.000594159030e+001,8.634624895825e+000
    8837,-2.062501113750e+000,-9.002331619181e+001,8.285568295174e+000
    8838,-2.062501113750e+000,-9.202231864657e+001,2.858663154644e+001
    8839,-2.062501113750e+000,-9.055275793268e+001,1.956565165696e+001
    8840,-2.062501113750e+000,-9.026956458929e+001,1.970541036999e+001
    8841,-2.062501113750e+000,-9.050551203662e+001,1.926349326141e+001
    8842,-2.062501113750e+000,-9.022231869323e+001,1.940325197445e+001
    8843,-2.062501113750e+000,-9.402964738620e+001,6.706019306525e+000
    8844,-2.062501113750e+000,-9.378813745366e+001,7.302453670681e+000
    8845,-2.062501113750e+000,-9.327828636413e+001,7.082284398488e+000
    8846,-2.062501113750e+000,-9.675914218532e+001,1.824187717229e+001
    8847,-2.062501113750e+000,-9.706850766781e+001,1.861845374171e+001
    8848,-2.062501113750e+000,-9.670294312083e+001,1.869857572484e+001
    8849,-3.332327114206e+000,-8.937504826250e+001,3.972650123820e+001
    8850,-3.332218940357e+000,-8.937504826250e+001,3.941449863356e+001
    8851,-3.034714241467e+000,-8.937504826250e+001,3.986835525990e+001
    8852,-3.034606067617e+000,-8.937504826250e+001,3.955635265527e+001
    8853,-2.062501113750e+000,-9.232929018367e+001,3.303829706806e+000
    8854,-2.062501113750e+000,-9.214551279415e+001,3.614449209785e+000
    8855,-2.062501113750e+000,-9.247138017248e+001,3.638946109519e+000
    8856,-2.062501113750e+000,-9.163244565112e+001,5.400432126280e+000
    8857,-2.062501113750e+000,-9.153606509550e+001,4.974495500011e+000
    8858,-2.062501113750e+000,-9.217267285058e+001,5.152441737349e+000
    8859,-2.062501113750e+000,-9.142403799292e+001,4.481977358927e+000
    8860,-2.062501113750e+000,-9.106888617988e+001,4.658648588652e+000
    8861,-2.062501113750e+000,-9.011621640563e+001,2.865021436294e+000
    8862,-2.062501113750e+000,-9.394377411758e+001,9.003075183693e+000
    8863,-2.062501113750e+000,-9.403552764429e+001,9.265346802417e+000
    8864,-2.062501113750e+000,-9.422664778939e+001,9.013334326038e+000
    8865,-2.062501113750e+000,-8.937504826250e+001,1.558237594950e+001
    8866,-2.390912014838e+000,-8.937504826250e+001,1.577491808359e+001
    8867,-2.439769991013e+000,-8.937504826250e+001,1.540072587372e+001
    8868,-2.973799659536e+000,-9.437056757552e+001,4.163984280251e+001
    8869,-3.490130874117e+000,-9.434851375199e+001,4.180524647904e+001
    8870,-3.097168631325e+000,-9.431293777413e+001,4.207206631296e+001
    8871,-2.062501113750e+000,-9.385151588559e+001,9.494787809812e+000
    8872,-2.062501113750e+000,-9.375019581362e+001,9.260297422687e+000
    8873,-2.062501113750e+000,-9.073704715914e+001,1.336519609054e+001
    8874,-2.062501113750e+000,-9.073704715914e+001,1.307594593434e+001
    8875,-2.062501113750e+000,-9.080688912746e+001,2.106171054612e+001
    8876,-2.062501113750e+000,-9.061355391399e+001,2.096460804129e+001
    8877,-2.062501113750e+000,-9.080671392653e+001,2.087865882208e+001
    8878,-2.062501113750e+000,-8.996563433368e+001,1.486431205643e+001
    8879,-2.062501113750e+000,-9.025529661981e+001,1.503432063246e+001
    8880,-2.062501113750e+000,-8.996074706238e+001,1.519567385612e+001
    8881,-2.062501113750e+000,-9.582176858314e+001,2.138600934309e+001
    8882,-2.062501113750e+000,-9.581226963124e+001,2.117015865439e+001
    8883,-2.062501113750e+000,-9.607225236220e+001,2.120226664201e+001
    8884,-2.062501113750e+000,-9.713124628609e+001,1.814791410461e+001
    8885,-2.062501113750e+000,-9.584801285286e+001,2.098348774114e+001
    8886,-2.062501113750e+000,-9.119696128436e+001,1.836662592249e+001
    8887,-2.062501113750e+000,-9.138210585780e+001,1.821108454474e+001
    8888,-2.062501113750e+000,-9.141020674113e+001,1.846555370659e+001
    8889,-2.992132037624e+000,-9.940093591246e+001,3.912080275509e+000
    8890,-3.015111247533e+000,-9.934118828525e+001,4.360187479572e+000
    8891,-2.553853265790e+000,-9.937453412578e+001,4.110093675626e+000
    8892,-2.576832475699e+000,-9.931478649857e+001,4.558200879688e+000
    8893,-3.030040625168e+000,-8.937504826250e+001,7.654700270988e+000
    8894,-2.676396057894e+000,-8.937504826250e+001,7.815633300752e+000
    8895,-2.687671514659e+000,-8.937504826250e+001,7.469731966136e+000
    8896,-2.567860493098e+000,-9.711717520851e+001,2.104028555508e+001
    8897,-2.062501113750e+000,-9.708459755350e+001,2.128461796768e+001
    8898,-2.567860493098e+000,-9.705443659024e+001,2.151082519218e+001
    8899,-2.062501113750e+000,-9.702185893522e+001,2.175515760478e+001
    8900,-2.062501113750e+000,-9.122427944745e+001,1.868870389169e+001
    8901,-2.062501113750e+000,-9.105655237375e+001,1.890619279440e+001
    8902,-2.062501113750e+000,-9.077136413614e+001,1.558544494689e+001
    8903,-2.062501113750e+000,-9.050409285585e+001,1.545248152850e+001
    8904,-2.062501113750e+000,-9.055329979815e+001,1.573449577345e+001
    8905,-2.062501113750e+000,-9.424818807710e+001,1.790440124370e+001
    8906,-2.062501113750e+000,-9.283536856066e+001,1.821686096359e+001
    8907,-2.062501113750e+000,-9.293903314481e+001,1.798855925227e+001
    8908,-2.062501113750e+000,-9.310408251998e+001,1.821756231168e+001
    8909,-2.062501113750e+000,-9.025222019319e+001,2.996634549037e+001
    8910,-2.062501113750e+000,-9.041890545675e+001,2.981828915372e+001
    8911,-2.062501113750e+000,-9.017790241558e+001,2.968084944504e+001
    8912,-2.062501113750e+000,-9.034458767914e+001,2.953279310839e+001
    8913,-2.062501113750e+000,-9.257349123241e+001,1.930676434158e+001
    8914,-2.062501113750e+000,-9.231939249312e+001,1.932147570968e+001
    8915,-2.062501113750e+000,-9.243181299584e+001,1.954035497015e+001
    8916,-3.687642892602e+000,-8.937504826250e+001,2.547583752356e+000
    8917,-3.517207047748e+000,-8.937504826250e+001,2.484960429734e+000
    8918,-3.738066265737e+000,-8.937504826250e+001,2.367049437475e+000
    8919,-2.062501113750e+000,-8.966136169446e+001,6.996227869856e+000
    8920,-2.062501113750e+000,-9.001725745514e+001,6.812511422547e+000
    8921,-2.062501113750e+000,-9.001268627758e+001,7.187455215351e+000
    8922,-3.643559380013e+000,-8.937504826250e+001,7.334891290115e+000
    8923,-3.690932052470e+000,-8.937504826250e+001,7.073901025978e+000
    8924,-2.062501113750e+000,-9.436532401634e+001,2.734089165113e+001
    8925,-2.062501113750e+000,-9.425784804666e+001,2.753664454253e+001
    8926,-2.062501113750e+000,-9.458893104534e+001,2.729187833411e+001
    8927,-2.062501113750e+000,-9.448145507566e+001,2.748763122551e+001
    8928,-2.062501113750e+000,-9.219937595388e+001,1.953113140453e+001
    8929,-2.062501113750e+000,-9.189647194607e+001,1.937571371284e+001
    8930,-2.062501113750e+000,-9.208741090312e+001,1.934075135409e+001
    8931,-2.062501113750e+000,-9.198824503595e+001,1.955963061455e+001
    8932,-2.062501113750e+000,-9.076880412026e+001,7.233694467701e+000
    8933,-2.062501113750e+000,-9.071637479519e+001,7.623157222320e+000
    8934,-2.062501113750e+000,-9.033660786548e+001,7.396882238638e+000
    8935,-2.062501113750e+000,-9.408728303529e+001,2.881316305581e+001
    8936,-2.062501113750e+000,-9.424787595188e+001,2.895892634404e+001
    8937,-2.408629831174e+000,-9.541653595206e+001,3.379507997852e+001
    8938,-2.869258752957e+000,-9.536735898562e+001,3.416390722682e+001
    8939,-2.945352197660e+000,-9.541622387133e+001,3.379742058399e+001
    8940,-2.062501113750e+000,-9.007109923717e+001,3.740280129392e+001
    8941,-2.062501113750e+000,-8.970721669460e+001,3.726119521136e+001
    8942,-2.062501113750e+000,-9.004374328319e+001,3.704774523906e+001
    8943,-2.062501113750e+000,-8.967986074062e+001,3.690613915650e+001
    8944,-2.062501113750e+000,-9.557329714557e+001,2.105494197835e+001
    8945,-2.062501113750e+000,-9.710851904702e+001,6.573788114829e+000
    8946,-2.062501113750e+000,-9.762750429374e+001,6.295527945061e+000
    8947,-2.062501113750e+000,-9.703599292335e+001,7.155203960503e+000
    8948,-2.062501113750e+000,-9.755497817007e+001,6.876943790735e+000
    8949,-2.062501113750e+000,-9.554367614915e+001,1.902286932690e+001
    8950,-2.062501113750e+000,-9.580660825566e+001,1.917100511954e+001
    8951,-2.062501113750e+000,-9.534836820774e+001,1.921165140896e+001
    8952,-2.062501113750e+000,-9.561130031425e+001,1.935978720160e+001
    8953,-2.062501113750e+000,-9.213726274482e+001,9.315249010338e+000
    8954,-2.062501113750e+000,-9.201408940722e+001,9.542819771692e+000
    8955,-2.062501113750e+000,-9.189908573895e+001,9.343559784961e+000
    8956,-2.062501113750e+000,-9.518729347077e+001,1.974730937844e+001
    8957,-2.062501113750e+000,-8.937504826250e+001,2.479150884702e+001
    8958,-2.062501113750e+000,-8.937504826250e+001,2.443300245685e+001
    8959,-2.062501113750e+000,-8.968250281574e+001,2.496434744319e+001
    8960,-2.062501113750e+000,-8.968250281574e+001,2.460584105302e+001
    8961,-2.062501113750e+000,-9.084035538917e+001,2.578872125496e+001
    8962,-2.062501113750e+000,-9.084035538917e+001,2.594547133961e+001
    8963,-2.062501113750e+000,-9.222908034363e+001,9.522434503646e+000
    8964,-3.082079980111e+000,-8.937504826250e+001,2.376809643390e+001
    8965,-3.134634858645e+000,-8.937504826250e+001,2.404407717017e+001
    8966,-2.767223167012e+000,-8.937504826250e+001,2.405563221888e+001
    8967,-2.062501113750e+000,-9.120571042538e+001,2.670955656952e+001
    8968,-2.676513851840e+000,-8.937504826250e+001,3.216973800094e+001
    8969,-2.671492680329e+000,-8.937504826250e+001,3.181959319681e+001
    8970,-3.034784389809e+000,-8.937504826250e+001,3.195197054363e+001
    8971,-3.029763218299e+000,-8.937504826250e+001,3.160182573950e+001
    8972,-2.062501113750e+000,-9.034049435377e+001,2.557269489280e+001
    8973,-2.062501113750e+000,-8.999965471484e+001,2.553773884778e+001
    8974,-2.062501113750e+000,-9.028616577268e+001,2.533549208391e+001
    8975,-2.062501113750e+000,-8.984573173632e+001,4.569443540486e+001
    8976,-2.062501113750e+000,-8.959573486246e+001,4.546989467570e+001
    8977,-2.062501113750e+000,-8.988057327814e+001,4.532893648824e+001
    8978,-2.723101583636e+000,-8.937504826250e+001,2.814576860152e+001
    8979,-2.724262498758e+000,-8.937504826250e+001,2.849608717111e+001
    8980,-3.071050759423e+000,-8.937504826250e+001,2.831941075167e+001
    8981,-2.742898395795e+000,-8.937504826250e+001,2.700454471441e+001
    8982,-2.447998648328e+000,-8.937504826250e+001,2.720875065184e+001
    8983,-2.447998648328e+000,-8.937504826250e+001,2.680543096290e+001
    8984,-2.062501113750e+000,-9.012632771220e+001,1.380801451729e+001
    8985,-2.062501113750e+000,-9.038498924801e+001,1.353854100390e+001
    8986,-2.062501113750e+000,-9.042940109300e+001,1.380650887953e+001
    8987,-2.377861284044e+000,-8.937504826250e+001,4.639151885483e+001
    8988,-2.062501113750e+000,-8.937504826250e+001,4.603301246466e+001
    8989,-2.062501113750e+000,-8.937504826250e+001,4.639151885483e+001
    8990,-2.062501113750e+000,-9.049713274596e+001,2.601530888336e+001
    8991,-2.062501113750e+000,-9.044556612010e+001,2.584324520749e+001
    8992,-2.062501113750e+000,-9.030144830158e+001,2.619711257610e+001
    8993,-2.062501113750e+000,-9.024988167573e+001,2.602504890023e+001
    8994,-2.062501113750e+000,-8.966482668950e+001,6.221139245634e+000
    8995,-2.062501113750e+000,-8.937504826250e+001,6.014736661808e+000
    8996,-2.062501113750e+000,-8.966527196535e+001,5.842200355836e+000
    8997,-2.062501113750e+000,-8.937504826250e+001,7.157475780478e+000
    8998,-2.062501113750e+000,-8.937504826250e+001,6.821376039693e+000
    8999,-2.062501113750e+000,-9.029938500804e+001,2.642492384326e+001
    9000,-2.062501113750e+000,-9.003841441712e+001,2.621572301768e+001
    9001,-3.329996425040e+000,-8.937504826250e+001,3.629490385326e+001
    9002,-3.643450665819e+000,-8.937504826250e+001,3.616204979022e+001
    9003,-3.595047869811e+000,-8.937504826250e+001,3.641897404493e+001
    9004,-2.062501113750e+000,-9.051827233954e+001,1.464094988962e+001
    9005,-2.062501113750e+000,-9.037797293768e+001,1.439666737888e+001
    9006,-2.062501113750e+000,-9.073651018675e+001,1.446372274830e+001
    9007,-2.062501113750e+000,-8.937504826250e+001,2.515001523719e+001
    9008,-2.386762487603e+000,-8.937504826250e+001,2.498095787659e+001
    9009,-2.383958851869e+000,-8.937504826250e+001,2.532557876497e+001
    9010,-2.062501113750e+000,-9.078181129280e+001,1.479498503491e+001
    9011,-2.062501113750e+000,-9.364843038076e+001,2.863391935728e+001
    9012,-2.062501113750e+000,-9.377912828595e+001,2.865743241997e+001
    9013,-2.062501113750e+000,-9.375521168509e+001,2.850622940842e+001
    9014,-2.062501113750e+000,-9.028938256359e+001,2.471214378258e+001
    9015,-2.062501113750e+000,-9.052905429567e+001,2.452931612177e+001
    9016,-2.062501113750e+000,-9.055638050938e+001,2.475236623616e+001
    9017,-2.062501113750e+000,-9.037122683595e+001,2.426275551046e+001
    9018,-2.062501113750e+000,-9.041779659036e+001,2.399210953319e+001
    9019,-2.062501113750e+000,-9.057562405009e+001,2.425867014451e+001
    9020,-2.062501113750e+000,-9.327740981954e+001,2.736663776089e+001
    9021,-2.062501113750e+000,-9.350406677530e+001,2.731857172740e+001
    9022,-2.062501113750e+000,-9.341543691655e+001,2.754972426150e+001
    9023,-2.062501113750e+000,-9.345723380380e+001,2.691364379858e+001
    9024,-2.062501113750e+000,-9.331457247491e+001,2.713433930282e+001
    9025,-2.062501113750e+000,-9.104866006282e+001,9.954082769444e+000
    9026,-2.062501113750e+000,-9.086825852938e+001,9.936250417749e+000
    9027,-2.062501113750e+000,-9.119869294729e+001,9.810361310537e+000
    9028,-2.062501113750e+000,-9.101829141386e+001,9.792528958841e+000
    9029,-2.062501113750e+000,-9.487618144741e+001,3.017947417605e+001
    9030,-2.062501113750e+000,-9.459720095618e+001,3.029704196810e+001
    9031,-2.062501113750e+000,-9.500267910159e+001,3.050419834872e+001
    9032,-2.062501113750e+000,-9.472369861037e+001,3.062176614077e+001
    9033,-2.062501113750e+000,-9.080864716903e+001,1.124892587872e+001
    9034,-2.062501113750e+000,-9.452250562347e+001,2.991675068266e+001
    9035,-2.062501113750e+000,-9.468945952040e+001,2.980165202560e+001
    9036,-2.062501113750e+000,-9.451966124109e+001,2.973427373373e+001
    9037,-3.345867275643e+000,-8.937504826250e+001,7.166106107633e+000
    9038,-3.393239948100e+000,-8.937504826250e+001,6.905115843495e+000
    9039,-3.078741285298e+000,-8.937504826250e+001,6.959570610224e+000
    9040,-2.062501113750e+000,-8.937504826250e+001,1.123548596867e+001
    9041,-2.062501113750e+000,-8.984859263777e+001,1.142665018463e+001
    9042,-2.062501113750e+000,-8.937504826250e+001,1.159399235885e+001
    9043,-2.062501113750e+000,-9.032722347609e+001,8.795671821501e+000
    9044,-2.062501113750e+000,-9.065144815089e+001,8.343309214073e+000
    9045,-2.062501113750e+000,-9.067748467262e+001,8.673331838423e+000
    9046,-3.330020863347e+000,-8.937504826250e+001,7.474561832881e+000
    9047,-3.062894873002e+000,-8.937504826250e+001,7.268026335473e+000
    9048,-2.062501113750e+000,-9.314861935843e+001,2.835622519369e+001
    9049,-2.062501113750e+000,-9.306521119521e+001,2.855089758427e+001
    9050,-2.062501113750e+000,-9.290508092149e+001,2.833986216320e+001
    9051,-2.062501113750e+000,-9.275053734407e+001,2.853898010393e+001
    9052,-2.062501113750e+000,-9.567442035991e+001,1.813941617339e+001
    9053,-2.062501113750e+000,-9.590929675675e+001,1.802265385737e+001
    9054,-2.062501113750e+000,-9.573156052650e+001,1.789194332648e+001
    9055,-2.062501113750e+000,-9.596643692333e+001,1.777518101046e+001
    9056,-3.636659253380e+000,-8.937504826250e+001,3.128124573692e+001
    9057,-2.062501113750e+000,-9.319247456519e+001,2.697070994924e+001
    9058,-2.062501113750e+000,-9.551572513216e+001,1.783236905572e+001
    9059,-2.062501113750e+000,-9.534627132901e+001,1.787283890015e+001
    9060,-2.062501113750e+000,-9.550278401698e+001,1.801215055666e+001
    9061,-2.062501113750e+000,-9.100169371326e+001,3.671652979644e+001
    9062,-2.062501113750e+000,-9.115580330546e+001,3.687841307731e+001
    9063,-2.062501113750e+000,-9.119263926953e+001,3.670643592644e+001
    9064,-2.062501113750e+000,-8.937504826250e+001,3.478487447304e+001
    9065,-2.454679352411e+000,-8.937504826250e+001,3.464100765523e+001
    9066,-2.398677640184e+000,-8.937504826250e+001,3.503272026780e+001
    9067,-3.603382538383e+000,-9.851057810313e+001,1.058976384550e+001
    9068,-3.206822256015e+000,-9.852835562156e+001,1.045643245726e+001
    9069,-3.603382538383e+000,-9.855837895515e+001,1.023125745533e+001
    9070,-2.062501113750e+000,-9.225396609615e+001,9.058357017891e+000
    9071,-2.062501113750e+000,-9.208013074033e+001,8.803665553951e+000
    9072,-2.062501113750e+000,-9.239347548766e+001,8.756323460448e+000
    9073,-2.062501113750e+000,-9.298959314951e+001,2.697941110821e+001
    9074,-2.062501113750e+000,-9.307160741935e+001,2.720010661245e+001
    9075,-2.683585243490e+000,-8.937504826250e+001,5.952130792173e+000
    9076,-2.738664093630e+000,-8.937504826250e+001,6.329836521802e+000
    9077,-3.040544731228e+000,-8.937504826250e+001,6.042015008300e+000
    9078,-2.062501113750e+000,-9.707315376433e+001,1.509115502145e+001
    9079,-2.062501113750e+000,-9.748814512221e+001,1.537468684427e+001
    9080,-2.062501113750e+000,-9.714006930737e+001,1.462354713738e+001
    9081,-2.062501113750e+000,-9.755506066526e+001,1.490707896019e+001
    9082,-2.062501113750e+000,-9.629418273652e+001,1.682532323320e+001
    9083,-2.062501113750e+000,-9.610638111145e+001,1.689418586204e+001
    9084,-2.062501113750e+000,-9.625036233092e+001,1.701019467200e+001
    9085,-2.062501113750e+000,-8.937504826250e+001,3.397823509515e+001
    9086,-2.454679352411e+000,-8.937504826250e+001,3.423768796629e+001
    9087,-2.398141087237e+000,-8.937504826250e+001,3.383877186219e+001
    9088,-2.062501113750e+000,-9.037715207940e+001,2.274409276132e+001
    9089,-2.062501113750e+000,-9.008812972963e+001,2.256623672767e+001
    9090,-2.062501113750e+000,-9.037707958594e+001,2.310847702697e+001
    9091,-2.062501113750e+000,-9.008805723617e+001,2.293062099332e+001
    9092,-2.062501113750e+000,-9.640427100714e+001,1.683757160639e+001
    9093,-2.062501113750e+000,-9.668296760279e+001,1.677029374957e+001
    9094,-2.062501113750e+000,-9.644809141275e+001,1.665270016758e+001
    9095,-2.645089911388e+000,-9.771851727515e+001,1.653022005531e+001
    9096,-2.062501113750e+000,-9.771234388263e+001,1.657652049920e+001
    9097,-2.645089911388e+000,-9.766175376338e+001,1.695594639363e+001
    9098,-2.062501113750e+000,-9.765558037086e+001,1.700224683753e+001
    9099,-2.062501113750e+000,-9.601701528766e+001,9.583577010267e+000
    9100,-2.062501113750e+000,-9.587898572702e+001,9.583577010267e+000
    9101,-2.062501113750e+000,-9.596419010089e+001,9.416679801869e+000
    9102,-2.062501113750e+000,-9.099588067299e+001,8.179138058929e+000
    9103,-2.062501113750e+000,-9.105410780306e+001,7.810221886863e+000
    9104,-2.062501113750e+000,-9.070967528096e+001,7.974393042008e+000
    9105,-3.104005194167e+000,-8.937504826250e+001,3.819254847603e+001
    9106,-3.045843037079e+000,-8.937504826250e+001,3.791791287973e+001
    9107,-2.747535295928e+000,-8.937504826250e+001,3.820285864253e+001
    9108,-3.043992980111e+000,-8.937504826250e+001,6.590267657354e+000
    9109,-3.098846205275e+000,-8.937504826250e+001,6.312384987852e+000
    9110,-3.344809975938e+000,-8.937504826250e+001,6.653159262203e+000
    9111,-2.062501113750e+000,-9.278688473918e+001,3.676149885731e+000
    9112,-2.062501113750e+000,-9.259494277219e+001,3.974587918369e+000
    9113,-2.062501113750e+000,-9.483375404830e+001,3.816594425672e+001
    9114,-2.062501113750e+000,-9.476205277026e+001,3.870370384198e+001
    9115,-2.062501113750e+000,-9.437774421883e+001,3.841465175143e+001
    9116,-2.062501113750e+000,-9.430604294080e+001,3.895241133668e+001
    9117,-3.399663201102e+000,-8.937504826250e+001,6.375276592701e+000
    9118,-2.062501113750e+000,-9.076430839448e+001,4.621224107255e+001
    9119,-2.062501113750e+000,-9.092278982255e+001,4.648383497070e+001
    9120,-2.062501113750e+000,-9.105622130472e+001,4.618572760966e+001
    9121,-3.502000096383e+000,-9.566718706830e+001,3.191519660673e+001
    9122,-2.062501113750e+000,-9.092401938964e+001,3.693825804577e+001
    9123,-2.062501113750e+000,-9.063299707316e+001,3.700555402886e+001
    9124,-2.062501113750e+000,-9.091061953975e+001,3.716654904266e+001
    9125,-2.062501113750e+000,-8.937504826250e+001,3.709275935977e+001
    9126,-2.062501113750e+000,-8.937504826250e+001,3.745126574994e+001
    9127,-2.773412398817e+000,-8.937504826250e+001,6.699139474672e+000
    9128,-2.062501113750e+000,-9.085750405264e+001,3.760994379108e+001
    9129,-2.062501113750e+000,-9.066179282734e+001,3.734836529522e+001
    9130,-2.062501113750e+000,-9.110633076505e+001,3.742812753851e+001
    9131,-2.062501113750e+000,-8.971610725835e+001,2.383293867060e+001
    9132,-2.062501113750e+000,-9.011706800721e+001,2.363304539877e+001
    9133,-2.062501113750e+000,-8.968249901382e+001,2.347248674054e+001
    9134,-2.062501113750e+000,-9.008345976268e+001,2.327259346871e+001
    9135,-2.062501113750e+000,-9.083177222794e+001,2.908905909591e+001
    9136,-2.062501113750e+000,-9.097202747028e+001,2.907862532696e+001
    9137,-2.062501113750e+000,-9.089826397750e+001,2.890806566526e+001
    9138,-2.678758533138e+000,-9.494545394852e+001,3.732819500504e+001
    9139,-3.130545855960e+000,-9.498170164560e+001,3.705633727695e+001
    9140,-3.136023289478e+000,-9.493117654122e+001,3.743527555980e+001
    9141,-3.046444373547e+000,-8.937504826250e+001,2.470685362185e+001
    9142,-2.678733448129e+000,-8.937504826250e+001,2.482304382465e+001
    9143,-3.027975085588e+000,-8.937504826250e+001,2.501455087357e+001
    9144,-2.062501113750e+000,-9.038457247956e+001,2.338690403689e+001
    9145,-3.332874216383e+000,-8.937504826250e+001,2.003450476494e+001
    9146,-3.064950138391e+000,-8.937504826250e+001,1.975821998850e+001
    9147,-3.028043339519e+000,-8.937504826250e+001,2.014809716650e+001
    9148,-2.062501113750e+000,-9.420288686444e+001,3.245622703922e+001
    9149,-2.062501113750e+000,-9.424188688550e+001,3.216372688127e+001
    9150,-2.062501113750e+000,-9.495437818645e+001,3.249482491990e+001
    9151,-2.062501113750e+000,-9.307874575503e+001,2.749609703838e+001
    9152,-2.062501113750e+000,-9.293023837876e+001,2.778956716853e+001
    9153,-2.062501113750e+000,-9.321677285205e+001,2.767918353899e+001
    9154,-2.397245921324e+000,-8.937504826250e+001,2.013211040764e+001
    9155,-2.386169283909e+000,-8.937504826250e+001,1.977245514759e+001
    9156,-2.062501113750e+000,-8.937504826250e+001,1.995167257971e+001
    9157,-2.062501113750e+000,-9.329228774417e+001,2.859786631768e+001
    9158,-2.062501113750e+000,-9.080864716903e+001,1.097917573305e+001
    9159,-2.726778432398e+000,-8.937504826250e+001,1.995986073365e+001
    9160,-2.689871633527e+000,-8.937504826250e+001,2.034973791165e+001
    9161,-2.062501113750e+000,-9.481012273519e+001,2.430997209608e+000
    9162,-2.062501113750e+000,-9.507327661742e+001,2.438155830188e+000
    9163,-2.062501113750e+000,-9.495271994697e+001,2.182311130965e+000
    9164,-2.062501113750e+000,-9.501711680473e+001,3.202428528280e+001
    9165,-2.062501113750e+000,-9.509092667612e+001,3.162263917547e+001
    9166,-2.062501113750e+000,-9.431569675689e+001,3.176208077394e+001
    9167,-2.062501113750e+000,-9.544953694804e+001,3.354757250862e+001
    9168,-2.062501113750e+000,-9.486425570187e+001,3.336164035478e+001
    9169,-2.062501113750e+000,-9.484827346480e+001,3.379715899283e+001
    9170,-2.062501113750e+000,-9.378457810185e+001,4.283793166275e+001
    9171,-2.062501113750e+000,-9.374621734451e+001,4.333092346482e+001
    9172,-2.062501113750e+000,-9.417612888256e+001,4.309813299977e+001
    9173,-2.062501113750e+000,-9.583515269183e+001,3.065545443024e+001
    9174,-2.062501113750e+000,-9.589191620360e+001,3.022972809191e+001
    9175,-2.062501113750e+000,-9.548205421750e+001,3.029535169388e+001
    9176,-2.062501113750e+000,-9.553881772928e+001,2.986962535555e+001
    9177,-3.690421847676e+000,-8.937504826250e+001,1.961268949871e+001
    9178,-3.377837829073e+000,-8.937504826250e+001,1.977073977657e+001
    9179,-3.595918091987e+000,-8.937504826250e+001,1.990806301310e+001
    9180,-2.062501113750e+000,-9.075250629333e+001,1.088460367910e+001
    9181,-2.062501113750e+000,-9.057040059114e+001,1.079599248583e+001
    9182,-2.062501113750e+000,-9.085772495462e+001,1.069414660420e+001
    9183,-3.613298263853e+000,-8.937504826250e+001,2.985577393582e+001
    9184,-2.062501113750e+000,-9.115882304862e+001,1.813034969027e+001
    9185,-2.062501113750e+000,-9.134396762205e+001,1.797480831253e+001
    9186,-2.062501113750e+000,-9.105862513072e+001,1.757698681212e+001
    9187,-2.062501113750e+000,-9.102157811420e+001,1.774112328967e+001
    9188,-2.062501113750e+000,-9.120045135122e+001,1.771167821201e+001
    9189,-2.062501113750e+000,-9.056110432236e+001,1.106802358245e+001
    9190,-2.062501113750e+000,-9.191418096124e+001,4.396393454591e+001
    9191,-2.062501113750e+000,-9.143553196522e+001,4.427736775214e+001
    9192,-2.062501113750e+000,-9.198553611461e+001,4.453861289398e+001
    9193,-2.062501113750e+000,-8.937504826250e+001,4.202222222462e+001
    9194,-2.405915288303e+000,-8.937504826250e+001,4.221929603579e+001
    9195,-2.062501113750e+000,-8.937504826250e+001,4.164130918506e+001
    9196,-2.405915288303e+000,-8.937504826250e+001,4.183838299623e+001
    9197,-2.062501113750e+000,-9.490964807159e+001,1.869226477727e+001
    9198,-2.062501113750e+000,-9.471146106797e+001,1.856131970355e+001
    9199,-2.062501113750e+000,-9.491788394528e+001,1.848592075447e+001
    9200,-2.380101225280e+000,-8.937504826250e+001,1.396295644752e+001
    9201,-2.389179448096e+000,-8.937504826250e+001,1.431750753664e+001
    9202,-2.669095335445e+000,-8.937504826250e+001,1.377188277917e+001
    9203,-2.678173558261e+000,-8.937504826250e+001,1.412643386829e+001
    9204,-2.383493117125e+000,-8.937504826250e+001,3.202037856531e+001
    9205,-2.062501113750e+000,-8.937504826250e+001,3.187201005290e+001
    9206,-2.062501113750e+000,-8.937504826250e+001,3.223051644307e+001
    9207,-3.406972559137e+000,-8.937504826250e+001,3.261871412556e+001
    9208,-3.452969392852e+000,-8.937504826250e+001,3.287864538552e+001
    9209,-3.140545971862e+000,-8.937504826250e+001,3.289937433517e+001
    9210,-2.062501113750e+000,-9.471809572437e+001,3.603843952679e+000
    9211,-2.062501113750e+000,-9.508397610779e+001,3.633785154969e+000
    9212,-2.062501113750e+000,-9.444434936946e+001,3.740233106315e+000
    9213,-2.062501113750e+000,-9.481022975288e+001,3.770174308605e+000
    9214,-2.062501113750e+000,-9.136959709724e+001,1.953788305159e+001
    9215,-2.062501113750e+000,-9.117873076881e+001,1.960339729995e+001
    9216,-2.062501113750e+000,-9.137438694550e+001,1.934786624058e+001
    9217,-2.062501113750e+000,-9.118352061708e+001,1.941338048894e+001
    9218,-2.062501113750e+000,-9.455614622227e+001,3.335988998342e+000
    9219,-2.062501113750e+000,-9.565187439083e+001,2.413209394593e+001
    9220,-2.062501113750e+000,-9.605102808057e+001,2.442530281332e+001
    9221,-2.062501113750e+000,-9.611077914560e+001,2.397716982561e+001
    9222,-2.062501113750e+000,-9.428111077313e+001,3.940353718763e+001
    9223,-2.062501113750e+000,-9.469625390865e+001,3.919719530410e+001
    9224,-3.031667599717e+000,-8.937504826250e+001,1.390851720295e+001
    9225,-3.334628523351e+000,-8.937504826250e+001,1.405136817935e+001
    9226,-3.334510507102e+000,-8.937504826250e+001,1.375321116510e+001
    9227,-2.062501113750e+000,-9.538811875535e+001,3.570670096001e+000
    9228,-2.062501113750e+000,-9.522428526251e+001,3.274673533199e+000
    9229,-2.062501113750e+000,-9.469903229731e+001,4.169983687191e+000
    9230,-2.062501113750e+000,-9.455441775547e+001,4.696442629359e+000
    9231,-2.062501113750e+000,-9.507035829827e+001,4.492133149321e+000
    9232,-2.062501113750e+000,-9.353983474410e+001,3.648494507492e+001
    9233,-2.062501113750e+000,-9.371297453445e+001,3.649195101808e+001
    9234,-2.062501113750e+000,-9.362835051109e+001,3.632840201612e+001
    9235,-3.643123347557e+000,-8.937504826250e+001,1.188108370643e+001
    9236,-3.399601278050e+000,-8.937504826250e+001,1.203283010339e+001
    9237,-3.664980041084e+000,-8.937504826250e+001,1.214905844475e+001
    9238,-3.539258997808e+000,-9.496039171478e+001,3.721616175811e+001
    9239,-3.409793570139e+000,-8.937504826250e+001,3.314582435484e+001
    9240,-3.030972698743e+000,-9.719646985975e+001,2.044557567082e+001
    9241,-3.104333923879e+000,-9.724471707873e+001,2.008372152843e+001
    9242,-3.493372951467e+000,-9.721958237847e+001,2.027223178046e+001
    9243,-3.566734176603e+000,-9.726782959745e+001,1.991037763807e+001
    9244,-2.062501113750e+000,-9.579940447311e+001,1.979055485173e+001
    9245,-2.062501113750e+000,-9.588202091095e+001,1.950967657217e+001
    9246,-2.062501113750e+000,-9.606518292186e+001,1.970237463421e+001
    9247,-2.062501113750e+000,-9.200390387815e+001,4.180606915969e+001
    9248,-2.062501113750e+000,-9.243362386263e+001,4.226955750362e+001
    9249,-2.062501113750e+000,-9.173257980202e+001,4.244439297511e+001
    9250,-2.062501113750e+000,-9.041819321226e+001,2.172726797692e+000
    9251,-2.062501113750e+000,-9.392549665149e+001,3.474402008669e+001
    9252,-2.062501113750e+000,-9.381813452685e+001,3.502657886113e+001
    9253,-2.062501113750e+000,-9.414976814982e+001,3.507212244508e+001
    9254,-2.062501113750e+000,-9.022809706731e+001,2.415956049182e+000
    9255,-2.062501113750e+000,-9.000673888386e+001,2.583337345136e+000
    9256,-2.062501113750e+000,-9.033757458908e+001,2.697640140340e+000
    9257,-2.062501113750e+000,-9.240351776080e+001,4.388214968290e+001
    9258,-2.062501113750e+000,-9.228202895397e+001,4.336545475847e+001
    9259,-2.062501113750e+000,-9.238241318932e+001,4.284870933491e+001
    9260,-2.062501113750e+000,-9.150552251084e+001,4.175207436060e+001
    9261,-2.062501113750e+000,-9.123419843472e+001,4.239039817602e+001
    9262,-2.062501113750e+000,-9.146776148538e+001,4.043578464739e+001
    9263,-2.062501113750e+000,-9.167845344092e+001,3.984263090627e+001
    9264,-2.062501113750e+000,-9.108468585453e+001,3.995520337608e+001
    9265,-2.664764290628e+000,-9.371052084243e+001,4.659019330075e+001
    9266,-2.436128167165e+000,-9.371052084243e+001,4.659019330075e+001
    9267,-2.062501113750e+000,-9.432137599695e+001,3.547303110915e+001
    9268,-2.062501113750e+000,-9.397821994714e+001,3.541321139797e+001
    9269,-2.062501113750e+000,-9.431140451051e+001,3.575124218413e+001
    9270,-2.062501113750e+000,-9.396824846070e+001,3.569142247294e+001
    9271,-3.181552878539e+000,-9.739711521457e+001,1.894073550970e+001
    9272,-2.806432265902e+000,-9.738589291597e+001,1.902490274919e+001
    9273,-2.911589826148e+000,-9.743983733526e+001,1.862031960450e+001
    9274,-2.062501113750e+000,-9.287290799737e+001,9.032736607240e+000
    9275,-2.062501113750e+000,-9.304595899756e+001,8.757204264957e+000
    9276,-2.062501113750e+000,-9.275207502511e+001,8.744812706598e+000
    9277,-3.690754974843e+000,-8.937504826250e+001,3.500189305817e+001
    9278,-3.668634228311e+000,-8.937504826250e+001,3.468789098251e+001
    9279,-3.450887092564e+000,-8.937504826250e+001,3.483768961949e+001
    9280,-2.254673717523e+000,-9.370383114125e+001,4.664036605958e+001
    9281,-2.302141299738e+000,-9.373377538493e+001,4.641578423200e+001
    9282,-2.062501113750e+000,-9.332362277932e+001,4.348299756925e+001
    9283,-2.062501113750e+000,-9.367750361973e+001,4.384627640069e+001
    9284,-2.062501113750e+000,-9.325461339931e+001,4.396681131372e+001
    9285,-2.393444257858e+000,-9.852720304573e+001,1.046507677595e+001
    9286,-2.393444257858e+000,-9.858097900426e+001,1.006175708701e+001
    9287,-2.857384440161e+000,-9.856290588367e+001,1.019730549139e+001
    9288,-2.062501113750e+000,-9.909553741803e+001,3.444673051461e+000
    9289,-2.062501113750e+000,-9.947898238676e+001,3.326731718273e+000
    9290,-2.062501113750e+000,-9.902682369325e+001,3.960025987332e+000
    9291,-2.062501113750e+000,-9.941026866197e+001,3.842084654144e+000
    9292,-2.062501113750e+000,-9.010364829563e+001,2.399553628263e+001
    9293,-2.062501113750e+000,-9.282733834535e+001,3.721672385049e+001
    9294,-2.062501113750e+000,-9.278203633926e+001,3.744053658415e+001
    9295,-2.062501113750e+000,-9.262621823232e+001,3.726159666569e+001
    9296,-3.509348954061e+000,-9.929862767509e+001,4.679392055794e+000
    9297,-3.038179783840e+000,-9.928090780268e+001,4.812291098826e+000
    9298,-2.062501113750e+000,-9.050976518484e+001,1.712777743687e+001
    9299,-2.062501113750e+000,-9.054749790736e+001,1.738134374116e+001
    9300,-2.062501113750e+000,-9.028298577445e+001,1.729193883594e+001
    9301,-2.062501113750e+000,-9.032071849697e+001,1.754550514023e+001
    9302,-2.062501113750e+000,-9.513074762138e+001,8.822653214143e+000
    9303,-2.062501113750e+000,-9.525133916320e+001,9.109970397428e+000
    9304,-2.062501113750e+000,-9.488837761524e+001,8.838932392777e+000
    9305,-2.062501113750e+000,-9.500896915706e+001,9.126249576062e+000
    9306,-3.091464369053e+000,-8.937504826250e+001,3.317289916798e+001
    9307,-3.360711967330e+000,-8.937504826250e+001,3.341934918765e+001
    9308,-2.062501113750e+000,-9.189522920610e+001,4.114248418791e+001
    9309,-2.062501113750e+000,-9.247247589095e+001,4.105181847449e+001
    9310,-2.062501113750e+000,-9.232494919059e+001,4.160597253183e+001
    9311,-3.500965968111e+000,-9.913359198437e+001,5.917159736147e+000
    9312,-3.523234131861e+000,-9.908152254392e+001,6.307680539541e+000
    9313,-2.062501113750e+000,-9.591158449678e+001,1.883848002113e+001
    9314,-2.680203597208e+000,-9.471563329649e+001,3.905184989528e+001
    9315,-2.541955975559e+000,-9.476583142396e+001,3.867536393922e+001
    9316,-3.636069608568e+000,-9.608404370672e+001,2.878877181853e+001
    9317,-3.636069608568e+000,-9.603325530145e+001,2.916968485809e+001
    9318,-3.353929784028e+000,-8.937504826250e+001,3.234653001883e+001
    9319,-3.087503196753e+000,-8.937504826250e+001,3.262719022843e+001
    9320,-2.062501113750e+000,-9.564081635031e+001,3.211297699159e+001
    9321,-3.448720406084e+000,-8.937504826250e+001,1.001292480305e+001
    9322,-3.666709388367e+000,-8.937504826250e+001,9.881164476263e+000
    9323,-3.690513128307e+000,-8.937504826250e+001,1.013488057925e+001
    9324,-2.062501113750e+000,-9.460287375564e+001,3.711395518997e+001
    9325,-2.062501113750e+000,-9.432896497850e+001,3.695449515360e+001
    9326,-2.062501113750e+000,-9.422141297945e+001,3.731624470860e+001
    9327,-2.771811823092e+000,-8.937504826250e+001,3.291254795611e+001
    9328,-2.391208344505e+000,-8.937504826250e+001,3.884428213576e+001
    9329,-2.062501113750e+000,-8.937504826250e+001,3.868363146615e+001
    9330,-2.448603648562e+000,-8.937504826250e+001,3.844485190990e+001
    9331,-2.062501113750e+000,-9.468349729448e+001,3.632854250415e+001
    9332,-2.062501113750e+000,-9.427137810655e+001,3.633095720834e+001
    9333,-2.062501113750e+000,-9.434983745231e+001,3.661721545549e+001
    9334,-2.062501113750e+000,-9.715338727246e+001,2.076869507546e+001
    9335,-2.421641187642e+000,-9.599310528590e+001,2.947080997470e+001
    9336,-2.850280039800e+000,-9.601346540848e+001,2.931810905536e+001
    9337,-2.421641187642e+000,-9.604688124442e+001,2.906749028576e+001
    9338,-2.062501113750e+000,-9.454526642899e+001,2.873967704726e+001
    9339,-2.062501113750e+000,-9.437880039141e+001,2.855417100483e+001
    9340,-2.062501113750e+000,-9.447263028724e+001,2.896888200643e+001
    9341,-2.062501113750e+000,-9.430616424967e+001,2.878337596401e+001
    9342,-2.062501113750e+000,-9.088493781292e+001,1.039822636862e+001
    9343,-2.062501113750e+000,-9.085772495462e+001,1.054789652522e+001
    9344,-2.448603648562e+000,-8.937504826250e+001,3.799671892219e+001
    9345,-2.062501113750e+000,-9.448438088696e+001,2.802398941947e+001
    9346,-2.062501113750e+000,-9.469338327012e+001,2.785484079936e+001
    9347,-2.062501113750e+000,-9.444166274605e+001,2.776451174294e+001
    9348,-2.062501113750e+000,-9.414557133308e+001,2.863761267578e+001
    9349,-2.062501113750e+000,-9.391606636951e+001,4.504860184761e+001
    9350,-2.062501113750e+000,-9.359658000166e+001,4.477296440272e+001
    9351,-2.062501113750e+000,-9.361975256309e+001,4.515026212616e+001
    9352,-2.062501113750e+000,-9.306730648409e+001,9.036961322640e+000
    9353,-2.062501113750e+000,-9.289425548390e+001,9.312493664922e+000
    9354,-2.062501113750e+000,-9.683335698909e+001,2.054842487153e+001
    9355,-2.062501113750e+000,-9.688713294762e+001,2.014510518259e+001
    9356,-2.062501113750e+000,-9.395285680519e+001,2.872688214662e+001
    9357,-3.644727354312e+000,-8.937504826250e+001,2.901622033023e+001
    9358,-2.062501113750e+000,-9.576923572591e+001,2.854630358715e+001
    9359,-2.062501113750e+000,-9.577098989524e+001,2.806939533384e+001
    9360,-2.062501113750e+000,-9.536637163398e+001,2.865341726245e+001
    9361,-2.062501113750e+000,-9.536812580331e+001,2.817650900913e+001
    9362,-2.062501113750e+000,-9.720716323099e+001,2.036537538652e+001
    9363,-2.062501113750e+000,-9.498213070877e+001,2.913383932914e+001
    9364,-2.062501113750e+000,-9.493089773050e+001,2.879809045532e+001
    9365,-2.062501113750e+000,-9.526966161322e+001,2.901443890539e+001
    9366,-2.062501113750e+000,-8.993292716887e+001,1.855104513321e+001
    9367,-2.062501113750e+000,-9.001389064338e+001,1.815488371719e+001
    9368,-2.062501113750e+000,-8.962858099360e+001,1.872198998974e+001
    9369,-2.062501113750e+000,-8.970954446812e+001,1.832582857373e+001
    9370,-2.062501113750e+000,-9.441607133782e+001,2.950152677403e+001
    9371,-2.062501113750e+000,-9.454640693629e+001,2.956812077978e+001
    9372,-2.062501113750e+000,-9.455330366791e+001,2.938504178731e+001
    9373,-3.165175821999e+000,-9.646597920185e+001,2.592425560509e+001
    9374,-3.589700366232e+000,-9.649635452879e+001,2.569644065300e+001
    9375,-3.589700366232e+000,-9.644257857027e+001,2.609976034194e+001
    9376,-3.218062954581e+000,-9.606598597653e+001,2.892420479498e+001
    9377,-3.486808353890e+000,-9.589027536847e+001,3.024203435540e+001
    9378,-3.486808353890e+000,-9.583943079359e+001,3.062336866705e+001
    9379,-2.062501113750e+000,-9.136382590225e+001,3.751184943818e+001
    9380,-2.062501113750e+000,-9.168025785785e+001,3.767235461812e+001
    9381,-2.062501113750e+000,-9.162939358823e+001,3.743433466421e+001
    9382,-2.062501113750e+000,-9.102324799832e+001,5.033276064809e+000
    9383,-2.437030177069e+000,-8.937504826250e+001,2.385768431782e+001
    9384,-2.062501113750e+000,-8.937504826250e+001,2.367117637773e+001
    9385,-2.386944575697e+000,-8.937504826250e+001,2.345518934017e+001
    9386,-2.652553260863e+000,-9.835139031822e+001,1.178367223233e+001
    9387,-2.062501113750e+000,-9.834606531827e+001,1.182360973194e+001
    9388,-2.431013069697e+000,-9.840683132440e+001,1.136786468598e+001
    9389,-2.062501113750e+000,-9.182344846809e+001,2.858198172110e+001
    9390,-2.062501113750e+000,-9.191770866279e+001,2.841859774254e+001
    9391,-2.062501113750e+000,-9.172528202872e+001,2.844993578056e+001
    9392,-2.384030514122e+000,-8.937504826250e+001,3.653893044593e+001
    9393,-2.062501113750e+000,-8.937504826250e+001,3.671184632021e+001
    9394,-2.062501113750e+000,-8.937504826250e+001,3.635333993004e+001
    9395,-2.062501113750e+000,-9.383811059059e+001,3.998748957034e+001
    9396,-2.062501113750e+000,-9.388991457232e+001,3.958347547558e+001
    9397,-2.062501113750e+000,-9.422135970810e+001,3.985167017535e+001
    9398,-3.502000096383e+000,-9.561634249341e+001,3.229653091838e+001
    9399,-3.518639759436e+000,-9.556412509593e+001,3.268816139944e+001
    9400,-2.062501113750e+000,-9.323344084627e+001,4.444536632804e+001
    9401,-2.062501113750e+000,-9.325706066228e+001,4.488456773421e+001
    9402,-2.062501113750e+000,-9.334390501464e+001,9.515514877875e+000
    9403,-3.345225160214e+000,-8.937504826250e+001,3.205792765359e+001
    9404,-3.045922052319e+000,-8.937504826250e+001,3.225857282237e+001
    9405,-2.062501113750e+000,-9.677545407151e+001,2.093606197049e+001
    9406,-2.062501113750e+000,-9.841447401604e+001,7.984457022376e+000
    9407,-2.062501113750e+000,-9.804375403091e+001,8.084293666043e+000
    9408,-2.062501113750e+000,-9.800437057549e+001,7.658358961818e+000
    9409,-2.585601393196e+000,-9.717214675660e+001,2.062799894447e+001
    9410,-2.585601393196e+000,-9.722592271512e+001,2.022467925553e+001
    9411,-2.062501113750e+000,-9.392894020433e+001,2.857567913506e+001
    9412,-2.062501113750e+000,-9.889571382108e+001,4.475016525382e+000
    9413,-2.062501113750e+000,-9.853484482812e+001,4.619894401199e+000
    9414,-2.062501113750e+000,-9.858328532788e+001,4.138392036216e+000
    9415,-2.062501113750e+000,-9.200632667320e+001,2.822099637241e+001
    9416,-2.062501113750e+000,-9.213267488098e+001,2.799949721828e+001
    9417,-2.062501113750e+000,-9.188244822569e+001,2.806138941340e+001
    9418,-2.062501113750e+000,-9.179383021528e+001,2.825899078353e+001
    9419,-2.062501113750e+000,-9.165119274962e+001,2.803192700128e+001
    9420,-2.062501113750e+000,-9.159813465241e+001,2.828869283673e+001
    9421,-2.062501113750e+000,-9.409736528684e+001,1.954541257144e+001
    9422,-2.062501113750e+000,-9.292656496462e+001,3.989796615284e+001
    9423,-2.062501113750e+000,-9.342147083144e+001,4.020088694645e+001
    9424,-2.062501113750e+000,-9.347327481316e+001,3.979687285169e+001
    9425,-3.632829975735e+000,-8.937504826250e+001,4.555039223242e+001
    9426,-3.359536388002e+000,-8.937504826250e+001,4.571412573673e+001
    9427,-3.635208522857e+000,-8.937504826250e+001,4.588305287757e+001
    9428,-3.425894129277e+000,-8.937504826250e+001,4.626539463076e+001
    9429,-3.761062513268e+000,-8.937504826250e+001,4.609914979191e+001
    9430,-3.300040138866e+000,-8.937504826250e+001,4.604929771642e+001
    9431,-2.062501113750e+000,-8.969047461548e+001,4.331599203296e+001
    9432,-2.062501113750e+000,-8.937504826250e+001,4.312014804452e+001
    9433,-2.062501113750e+000,-8.970841309705e+001,4.293870182135e+001
    9434,-2.062501113750e+000,-9.659422373365e+001,1.643371355130e+001
    9435,-2.389261568655e+000,-8.937504826250e+001,3.056315258724e+001
    9436,-2.685936345368e+000,-8.937504826250e+001,3.079626718775e+001
    9437,-2.389261568655e+000,-8.937504826250e+001,3.096647227619e+001
    9438,-2.062501113750e+000,-9.185935021180e+001,3.591751410197e+000
    9439,-2.062501113750e+000,-9.162871824483e+001,3.887470807595e+000
    9440,-2.062501113750e+000,-9.153054835182e+001,3.507466190015e+000
    9441,-2.062501113750e+000,-9.118580363420e+001,4.526403242261e+001
    9442,-2.062501113750e+000,-9.083741382769e+001,4.524642163290e+001
    9443,-2.062501113750e+000,-9.103420865657e+001,4.559057700080e+001
    9444,-2.062501113750e+000,-9.701462887346e+001,4.849281493088e+000
    9445,-2.062501113750e+000,-9.758307887073e+001,4.584017872430e+000
    9446,-2.062501113750e+000,-9.666282643691e+001,4.434810130167e+000
    9447,-2.062501113750e+000,-9.723127643419e+001,4.169546509510e+000
    9448,-2.675959670309e+000,-8.937504826250e+001,3.113731713993e+001
    9449,-2.379284893596e+000,-8.937504826250e+001,3.130752222837e+001
    9450,-2.062501113750e+000,-9.056693499813e+001,2.169974357380e+001
    9451,-2.062501113750e+000,-9.053302406824e+001,2.146225480805e+001
    9452,-2.062501113750e+000,-9.077461098797e+001,2.156280124549e+001
    9453,-2.062501113750e+000,-9.176982829042e+001,4.346304663873e+001
    9454,-2.062501113750e+000,-9.121865216200e+001,4.331366647022e+001
    9455,-2.062501113750e+000,-9.129117929440e+001,4.377647984496e+001
    9456,-2.062501113750e+000,-8.937504826250e+001,3.151350366273e+001
    9457,-2.379284893596e+000,-8.937504826250e+001,3.166602861854e+001
    9458,-2.995863583031e+000,-9.911247499926e+001,6.075537124462e+000
    9459,-3.123469508212e+000,-9.916372505719e+001,5.691161690040e+000
    9460,-2.062501113750e+000,-9.040801942693e+001,4.377672198228e+001
    9461,-2.062501113750e+000,-9.003013998642e+001,4.352965520530e+001
    9462,-2.062501113750e+000,-9.036118799951e+001,4.335173628993e+001
    9463,-2.062501113750e+000,-9.458278769889e+001,9.289653024006e+000
    9464,-2.062501113750e+000,-9.473570783797e+001,9.095312428723e+000
    9465,-2.062501113750e+000,-9.450481109286e+001,9.023914173495e+000
    9466,-2.062501113750e+000,-9.376311479565e+001,8.724155331464e+000
    9467,-2.062501113750e+000,-9.343591000342e+001,8.698655197146e+000
    9468,-2.062501113750e+000,-9.365580908065e+001,8.427209213388e+000
    9469,-3.602580076441e+000,-8.937504826250e+001,2.815068326815e+001
    9470,-2.062501113750e+000,-9.059524010022e+001,2.744694325728e+000
    9471,-2.062501113750e+000,-9.527107084802e+001,3.072724439066e+001
    9472,-2.062501113750e+000,-9.521366247107e+001,3.007230565194e+001
    9473,-2.062501113750e+000,-9.167224225781e+001,2.432494540818e+000
    9474,-2.062501113750e+000,-9.179904778555e+001,2.198759810680e+000
    9475,-2.062501113750e+000,-9.153897961982e+001,2.170461203750e+000
    9476,-2.062501113750e+000,-9.536011148256e+001,2.383792346454e+001
    9477,-2.062501113750e+000,-9.530918991726e+001,2.431430624233e+001
    9478,-3.047999646827e+000,-8.937504826250e+001,3.847289728461e+001
    9479,-3.077789767245e+000,-8.937504826250e+001,3.885890525379e+001
    9480,-2.777325416346e+000,-8.937504826250e+001,3.858886661172e+001
    9481,-2.062501113750e+000,-9.731889812236e+001,1.112545603004e+001
    9482,-2.062501113750e+000,-9.762007662499e+001,1.130453475382e+001
    9483,-2.062501113750e+000,-9.727389179547e+001,1.133493897407e+001
    9484,-2.062501113750e+000,-8.937504826250e+001,2.205606266240e+000
    9485,-2.062501113750e+000,-8.937504826250e+001,2.474486058868e+000
    9486,-2.363078776062e+000,-8.937504826250e+001,2.205606266240e+000
    9487,-3.645678873313e+000,-9.945232646201e+001,3.526651153852e+000
    9488,-3.153225896229e+000,-9.900746079548e+001,6.863143652835e+000
    9489,-2.677993410288e+000,-9.896554876058e+001,7.177483914629e+000
    9490,-3.223856986222e+000,-9.896024995602e+001,7.217224948772e+000
    9491,-2.062501113750e+000,-8.994658514073e+001,3.820579876784e+000
    9492,-2.062501113750e+000,-8.995596348734e+001,4.202669004889e+000
    9493,-2.062501113750e+000,-9.024131624180e+001,3.955239835571e+000
    9494,-3.643559380013e+000,-8.937504826250e+001,7.626177732129e+000
    9495,-3.079177889680e+000,-8.937504826250e+001,1.255767772033e+001
    9496,-3.344085922225e+000,-8.937504826250e+001,1.283481929982e+001
    9497,-3.044458180640e+000,-8.937504826250e+001,1.292399233008e+001
    9498,-2.386730788834e+000,-9.962547822711e+001,2.228012915626e+000
    9499,-2.621149623283e+000,-9.963377393846e+001,2.165795080494e+000
    9500,-2.397499511429e+000,-9.956363760353e+001,2.691817592452e+000
    9501,-2.631918345877e+000,-9.957193331488e+001,2.629599757320e+000
    9502,-2.062501113750e+000,-9.479165568594e+001,3.009452283335e+000
    9503,-2.062501113750e+000,-9.466704030735e+001,2.707830285045e+000
    9504,-2.062501113750e+000,-9.454095390357e+001,2.951191451838e+000
    9505,-2.062501113750e+000,-9.143352068299e+001,2.729007392753e+001
    9506,-2.062501113750e+000,-9.137720498914e+001,2.712607045162e+001
    9507,-2.062501113750e+000,-9.121769518244e+001,2.727783450383e+001
    9508,-2.062501113750e+000,-9.175128920732e+001,5.971030770139e+000
    9509,-2.062501113750e+000,-9.125362105859e+001,5.824837711393e+000
    9510,-3.600288669148e+000,-8.937504826250e+001,1.331306292731e+001
    9511,-2.062501113750e+000,-9.111962855394e+001,5.459212691078e+000
    9512,-2.062501113750e+000,-9.038061475329e+001,1.318015230101e+001
    9513,-2.062501113750e+000,-9.033640373580e+001,2.020918472830e+001
    9514,-2.062501113750e+000,-9.052363673522e+001,2.017493767818e+001
    9515,-2.062501113750e+000,-9.034091540775e+001,1.995975921765e+001
    9516,-3.075501060102e+000,-9.463071782546e+001,3.968871592797e+001
    9517,-3.138786833092e+000,-9.468411179983e+001,3.928826112021e+001
    9518,-3.506584881804e+000,-9.465875069730e+001,3.947846938922e+001
    9519,-2.062501113750e+000,-9.457070398200e+001,4.013881975394e+001
    9520,-2.616917824218e+000,-9.460248825709e+001,3.990043769076e+001
    9521,-2.677647956647e+000,-9.455177135866e+001,4.028081442900e+001
    9522,-2.062501113750e+000,-9.179646089921e+001,3.690265539495e+001
    9523,-2.062501113750e+000,-9.198980680238e+001,3.693687606960e+001
    9524,-2.062501113750e+000,-9.189372433489e+001,3.708951161955e+001
    9525,-2.655039403128e+000,-9.431095908335e+001,4.208690649383e+001
    9526,-2.435469637651e+000,-9.425773976988e+001,4.248605134481e+001
    9527,-2.062501113750e+000,-9.430765391570e+001,4.211169525116e+001
    9528,-2.062501113750e+000,-9.366689202285e+001,2.767073703543e+001
    9529,-2.062501113750e+000,-9.339076903197e+001,2.777378247139e+001
    9530,-2.380101225280e+000,-8.937504826250e+001,1.360445005735e+001
    9531,-2.676143919330e+000,-8.937504826250e+001,1.341142294217e+001
    9532,-2.390010096442e+000,-8.937504826250e+001,1.322925660988e+001
    9533,-2.686052790492e+000,-8.937504826250e+001,1.303622949471e+001
    9534,-2.390010096442e+000,-8.937504826250e+001,1.282593692094e+001
    9535,-2.062501113750e+000,-9.572333301252e+001,2.957574507761e+001
    9536,-2.062501113750e+000,-9.596070592257e+001,2.971380519969e+001
    9537,-2.062501113750e+000,-9.530144481923e+001,2.973156523348e+001
    9538,-2.062501113750e+000,-9.576935383021e+001,3.114894589236e+001
    9539,-2.646008064961e+000,-9.578115347043e+001,3.106044859070e+001
    9540,-2.062501113750e+000,-9.570661521193e+001,3.161948552946e+001
    9541,-2.646008064961e+000,-9.571841485215e+001,3.153098822780e+001
    9542,-3.393225609049e+000,-8.937504826250e+001,3.511144284117e+001
    9543,-3.137164186566e+000,-8.937504826250e+001,3.486335541728e+001
    9544,-3.079502703051e+000,-8.937504826250e+001,3.513710863896e+001
    9545,-3.088346144608e+000,-9.575056151807e+001,3.128988823341e+001
    9546,-2.831447427837e+000,-9.650724866840e+001,2.561473460592e+001
    9547,-2.395471507400e+000,-9.652866133560e+001,2.545413960198e+001
    9548,-2.831214551710e+000,-9.656543354104e+001,2.517834806113e+001
    9549,-2.062501113750e+000,-9.768073196475e+001,9.966460902410e+000
    9550,-2.062501113750e+000,-9.759465212680e+001,1.034914927983e+001
    9551,-2.062501113750e+000,-9.745565273332e+001,1.012981467420e+001
    9552,-2.062501113750e+000,-8.968162663024e+001,1.103597548175e+001
    9553,-2.062501113750e+000,-9.221933602005e+001,8.513198165541e+000
    9554,-2.062501113750e+000,-9.253268076737e+001,8.465856072038e+000
    9555,-3.084666402964e+000,-8.937504826250e+001,2.432329614513e+001
    9556,-2.062501113750e+000,-9.236721835393e+001,8.120257214409e+000
    9557,-2.062501113750e+000,-9.200487354207e+001,8.201012168066e+000
    9558,-2.062501113750e+000,-9.185699120819e+001,8.593953119198e+000
    9559,-3.504222205175e+000,-9.888822731219e+001,7.757394777490e+000
    9560,-3.593865221853e+000,-9.893561341204e+001,7.401999028666e+000
    9561,-2.062501113750e+000,-9.557807773203e+001,3.258351662869e+001
    9562,-2.062501113750e+000,-8.965803982788e+001,2.941060211101e+001
    9563,-2.062501113750e+000,-8.991966808663e+001,2.922847901659e+001
    9564,-2.062501113750e+000,-8.965803982788e+001,2.902968907146e+001
    9565,-2.394130435985e+000,-8.937504826250e+001,2.761853472783e+001
    9566,-2.685345769934e+000,-8.937504826250e+001,2.777549223310e+001
    9567,-2.394130435985e+000,-8.937504826250e+001,2.797704111800e+001
    9568,-3.501311232907e+000,-9.876961464544e+001,8.646989778165e+000
    9569,-3.504222205175e+000,-9.882541930792e+001,8.228454809518e+000
    9570,-3.523234131861e+000,-9.903366882638e+001,6.666583421086e+000
    9571,-3.018131746780e+000,-9.906040555881e+001,6.466057927856e+000
    9572,-3.031605363111e+000,-9.885958152211e+001,7.972238203113e+000
    9573,-3.134213969544e+000,-9.891286385618e+001,7.572620697596e+000
    9574,-2.062501113750e+000,-9.726698037791e+001,1.991674678459e+001
    9575,-2.062501113750e+000,-9.058379010031e+001,1.985571981433e+001
    9576,-3.447617267481e+000,-8.937504826250e+001,2.404503418955e+001
    9577,-3.405782230614e+000,-8.937504826250e+001,2.378021751731e+001
    9578,-3.401301439525e+000,-8.937504826250e+001,9.752838194548e+000
    9579,-3.137599882281e+000,-8.937504826250e+001,1.000149527335e+001
    9580,-3.645458234986e+000,-8.937504826250e+001,2.016774092909e+001
    9581,-2.062501113750e+000,-9.345871619178e+001,3.813945171953e+001
    9582,-2.062501113750e+000,-9.324985781344e+001,3.775920106414e+001
    9583,-2.062501113750e+000,-9.363857157312e+001,3.767374902486e+001
    9584,-2.062501113750e+000,-9.439394753610e+001,3.795129937688e+001
    9585,-2.062501113750e+000,-9.388939489034e+001,3.819356525186e+001
    9586,-2.062501113750e+000,-9.406925027168e+001,3.772786255718e+001
    9587,-2.541955975559e+000,-9.483753270200e+001,3.813760435396e+001
    9588,-2.062501113750e+000,-9.489357119522e+001,3.771731565479e+001
    9589,-2.062501113750e+000,-8.937504826250e+001,1.049606653895e+001
    9590,-2.062501113750e+000,-8.968162663024e+001,1.065506244219e+001
    9591,-2.062501113750e+000,-8.937504826250e+001,1.085457292912e+001
    9592,-2.062501113750e+000,-9.305642966437e+001,3.038064383489e+000
    9593,-2.062501113750e+000,-9.322000390264e+001,3.332994751574e+000
    9594,-2.062501113750e+000,-9.339998344309e+001,3.042419075464e+000
    9595,-2.062501113750e+000,-9.346259544155e+001,3.703978290758e+000
    9596,-2.062501113750e+000,-9.354829056723e+001,3.330827920044e+000
    9597,-2.062501113750e+000,-9.756278137262e+001,1.363116313209e+001
    9598,-2.062501113750e+000,-9.815777346925e+001,1.323579859959e+001
    9599,-2.062501113750e+000,-9.809197460763e+001,1.372929006172e+001
    9600,-3.353227352080e+000,-8.937504826250e+001,2.350423678103e+001
    9601,-3.042374393572e+000,-8.937504826250e+001,2.337207464919e+001
    9602,-3.501276162403e+000,-9.671419607884e+001,2.406262902766e+001
    9603,-3.501276162403e+000,-9.666335150395e+001,2.444396333931e+001
    9604,-2.733807925077e+000,-8.937504826250e+001,2.073924530762e+001
    9605,-2.062501113750e+000,-9.671271545323e+001,2.140660160759e+001
    9606,-2.062501113750e+000,-9.641486842175e+001,2.115148225942e+001
    9607,-2.062501113750e+000,-9.601448188109e+001,2.931048551075e+001
    9608,-2.062501113750e+000,-9.090511194963e+001,9.091902884806e+000
    9609,-2.062501113750e+000,-9.060880553194e+001,8.971236906370e+000
    9610,-2.062501113750e+000,-9.068196670609e+001,9.247595689904e+000
    9611,-2.681995479174e+000,-8.937504826250e+001,1.448137749682e+001
    9612,-2.062501113750e+000,-9.827069945485e+001,2.421577919353e+000
    9613,-2.062501113750e+000,-9.858869765484e+001,2.543870621040e+000
    9614,-2.062501113750e+000,-9.823517526860e+001,2.724112568133e+000
    9615,-2.062501113750e+000,-9.855317346859e+001,2.846405269820e+000
    9616,-2.381485553636e+000,-8.937504826250e+001,2.239289011546e+001
    9617,-2.062501113750e+000,-8.937504826250e+001,2.221474416766e+001
    9618,-2.387560202681e+000,-8.937504826250e+001,2.204599553453e+001
    9619,-2.062501113750e+000,-8.973811584916e+001,2.205340695984e+001
    9620,-2.062501113750e+000,-8.968709648732e+001,2.241350148481e+001
    9621,-2.680038926460e+000,-9.953267374536e+001,2.924046528770e+000
    9622,-3.593966478436e+000,-8.937504826250e+001,3.908005769162e+000
    9623,-3.347339112249e+000,-8.937504826250e+001,2.034198355521e+001
    9624,-3.610382987853e+000,-8.937504826250e+001,2.050682824538e+001
    9625,-2.676859439375e+000,-8.937504826250e+001,2.147873114729e+001
    9626,-2.716474494258e+000,-8.937504826250e+001,2.186153586473e+001
    9627,-3.040048022002e+000,-8.937504826250e+001,2.136689457440e+001
    9628,-3.079663076886e+000,-8.937504826250e+001,2.174969929184e+001
    9629,-3.623906578321e+000,-9.660600300750e+001,2.487407706266e+001
    9630,-3.216680630134e+000,-9.663310471183e+001,2.467081428022e+001
    9631,-2.062501113750e+000,-9.027094266938e+001,1.695903806108e+001
    9632,-3.610972744796e+000,-8.937504826250e+001,3.523052399682e+001
    9633,-3.350033318623e+000,-8.937504826250e+001,3.537731152814e+001
    9634,-3.647562684417e+000,-8.937504826250e+001,3.558145483655e+001
    9635,-3.395760223433e+000,-8.937504826250e+001,2.861250484436e+001
    9636,-3.692408179305e+000,-8.937504826250e+001,2.846425962140e+001
    9637,-3.386486145157e+000,-8.937504826250e+001,2.830559008898e+001
    9638,-2.062501113750e+000,-9.227902266985e+001,2.817273092396e+001
    9639,-2.062501113750e+000,-9.240064082411e+001,2.836129192345e+001
    9640,-2.062501113750e+000,-9.234148406754e+001,2.792056185578e+001
    9641,-2.062501113750e+000,-9.246310222180e+001,2.810912285526e+001
    9642,-2.062501113750e+000,-9.094857157679e+001,1.741299903153e+001
    9643,-2.062501113750e+000,-9.086524469209e+001,1.758641641993e+001
    9644,-2.062501113750e+000,-9.434173922125e+001,2.911572042048e+001
    9645,-2.062501113750e+000,-9.439806901191e+001,2.932468021090e+001
    9646,-2.062501113750e+000,-9.452896007791e+001,2.917784179686e+001
    9647,-3.223099251248e+000,-9.863579881767e+001,9.650608486385e+000
    9648,-2.851026719018e+000,-9.861601225074e+001,9.799007738412e+000
    9649,-3.229456972391e+000,-9.858269245061e+001,1.004890623936e+001
    9650,-2.062501113750e+000,-9.784311844475e+001,1.056227685212e+001
    9651,-2.062501113750e+000,-9.787990757822e+001,1.017449636339e+001
    9652,-2.062501113750e+000,-9.738826384159e+001,1.046511375802e+001
    9653,-2.062501113750e+000,-9.724926444810e+001,1.024577915239e+001
    9654,-2.062501113750e+000,-9.711505625652e+001,1.041872053045e+001
    9655,-2.062501113750e+000,-8.970721669460e+001,3.759729495214e+001
    9656,-2.062501113750e+000,-8.937504826250e+001,3.778736549072e+001
    9657,-3.023218424225e+000,-9.564116187319e+001,3.211038556999e+001
    9658,-2.569219973761e+000,-9.566563573010e+001,3.192683164321e+001
    9659,-3.100006515424e+000,-9.569394099525e+001,3.171454215458e+001
    9660,-2.062501113750e+000,-9.408541002263e+001,3.586659121658e+001
    9661,-2.062501113750e+000,-9.815363111901e+001,1.075769476541e+001
    9662,-2.062501113750e+000,-9.820740707754e+001,1.035437507647e+001
    9663,-3.667167835867e+000,-8.937504826250e+001,2.702647518438e+001
    9664,-3.401065723279e+000,-8.937504826250e+001,2.688194082303e+001
    9665,-3.642399998002e+000,-8.937504826250e+001,2.673079287854e+001
    9666,-2.062501113750e+000,-9.159738267071e+001,4.466015165244e+001
    9667,-2.062501113750e+000,-9.149623006792e+001,4.511267586301e+001
    9668,-2.062501113750e+000,-9.108463002422e+001,4.487174979081e+001
    9669,-2.395471507400e+000,-9.659737506038e+001,2.493878666611e+001
    9670,-2.062501113750e+000,-9.664521576348e+001,2.457998139288e+001
    9671,-2.562710907852e+000,-9.666227053893e+001,2.445207057699e+001
    9672,-2.062501113750e+000,-9.512476626678e+001,2.537439720191e+001
    9673,-2.062501113750e+000,-9.388772996808e+001,2.839982052409e+001
    9674,-2.062501113750e+000,-9.385329151283e+001,2.824258648625e+001
    9675,-2.062501113750e+000,-9.404861116820e+001,2.825915498235e+001
    9676,-3.036562118984e+000,-9.674143994227e+001,2.385830005189e+001
    9677,-3.015985424335e+000,-9.668339713675e+001,2.429362109332e+001
    9678,-3.266749059261e+000,-9.734353718637e+001,1.934257072117e+001
    9679,-2.891628446624e+000,-9.733231488777e+001,1.942673796066e+001
    9680,-3.049368285642e+000,-8.937504826250e+001,1.746281084842e+001
    9681,-3.034808429821e+000,-8.937504826250e+001,1.715248871593e+001
    9682,-2.689014202132e+000,-8.937504826250e+001,1.736642151820e+001
    9683,-3.619103515341e+000,-9.804911496929e+001,1.405073734927e+001
    9684,-3.619103515341e+000,-9.799235145751e+001,1.447646368760e+001
    9685,-2.546224099490e+000,-9.778032253055e+001,1.606668063985e+001
    9686,-3.039858087278e+000,-9.558894447572e+001,3.250201605106e+001
    9687,-2.683961073291e+000,-8.937504826250e+001,1.699456590755e+001
    9688,-2.062501113750e+000,-9.480085091975e+001,1.946759934314e+001
    9689,-2.062501113750e+000,-9.493509766702e+001,1.931031731719e+001
    9690,-2.062501113750e+000,-9.497454060853e+001,1.950424648990e+001
    9691,-3.336519022253e+000,-8.937504826250e+001,1.722287865164e+001
    9692,-3.329919411869e+000,-8.937504826250e+001,1.692723547680e+001
    9693,-3.351078878074e+000,-8.937504826250e+001,1.753320078413e+001
    9694,-2.062501113750e+000,-9.487764335071e+001,1.915428110682e+001
    9695,-2.062501113750e+000,-9.468993009946e+001,1.910531142748e+001
    9696,-2.062501113750e+000,-9.474339660344e+001,1.931156313277e+001
    9697,-2.062501113750e+000,-9.907842887671e+001,6.330883043587e+000
    9698,-2.062501113750e+000,-9.902166536494e+001,6.756609381915e+000
    9699,-2.542899260840e+000,-9.907525703568e+001,6.354671851322e+000
    9700,-2.542899260840e+000,-9.901849352391e+001,6.780398189650e+000
    9701,-2.062501113750e+000,-9.147863859032e+001,7.671395024025e+000
    9702,-2.062501113750e+000,-9.135561639539e+001,8.085027794031e+000
    9703,-2.675146782595e+000,-8.937504826250e+001,2.257153918655e+001
    9704,-2.381485553636e+000,-8.937504826250e+001,2.272898985624e+001
    9705,-2.680605804655e+000,-8.937504826250e+001,2.291682563092e+001
    9706,-2.386944575697e+000,-8.937504826250e+001,2.307427630061e+001
    9707,-2.062501113750e+000,-8.968654787426e+001,1.470104552698e+001
    9708,-2.062501113750e+000,-8.937504826250e+001,1.486536316916e+001
    9709,-2.062501113750e+000,-8.968166060295e+001,1.503240732667e+001
    9710,-3.299390190033e+000,-9.417371592193e+001,4.311623020447e+001
    9711,-3.631020357967e+000,-9.414871287183e+001,4.330375308026e+001
    9712,-3.243526757328e+000,-9.412153436878e+001,4.350759185313e+001
    9713,-2.062501113750e+000,-8.937504826250e+001,1.522386955933e+001
    9714,-3.692468971481e+000,-8.937504826250e+001,3.015186816078e+001
    9715,-3.397265124744e+000,-8.937504826250e+001,2.997297729333e+001
    9716,-2.743304057500e+000,-8.937504826250e+001,4.527243682598e+001
    9717,-3.078007256054e+000,-8.937504826250e+001,4.509825532167e+001
    9718,-2.691049162377e+000,-8.937504826250e+001,4.561491015927e+001
    9719,-3.025752360932e+000,-8.937504826250e+001,4.544072865496e+001
    9720,-2.062501113750e+000,-9.088845929391e+001,2.621675648570e+001
    9721,-2.062501113750e+000,-9.086727634398e+001,2.609250471043e+001
    9722,-2.412178311817e+000,-8.937504826250e+001,4.582253397638e+001
    9723,-2.499740543748e+000,-8.937504826250e+001,4.614952191929e+001
    9724,-2.778611394308e+000,-8.937504826250e+001,4.594189810219e+001
    9725,-2.062501113750e+000,-9.108150597546e+001,3.284439274866e+000
    9726,-2.062501113750e+000,-9.104750358648e+001,2.989640744156e+000
    9727,-2.062501113750e+000,-9.280193781355e+001,4.323974319641e+001
    9728,-2.062501113750e+000,-9.030644009171e+001,2.045974124493e+001
    9729,-2.062501113750e+000,-9.053431565522e+001,2.032573313849e+001
    9730,-2.062501113750e+000,-9.054537747148e+001,2.048767487788e+001
    9731,-3.036633547997e+000,-8.937504826250e+001,4.410105494090e+001
    9732,-3.071893174682e+000,-8.937504826250e+001,4.370518958609e+001
    9733,-3.342464516955e+000,-8.937504826250e+001,4.395452646623e+001
    9734,-2.062501113750e+000,-8.993581922426e+001,2.988207432775e+001
    9735,-2.062501113750e+000,-9.073261047090e+001,2.045342782776e+001
    9736,-2.062501113750e+000,-9.072154865464e+001,2.029148608837e+001
    9737,-2.062501113750e+000,-9.034723352082e+001,7.014763208284e+000
    9738,-2.062501113750e+000,-9.086672342241e+001,3.579725378057e+001
    9739,-3.649030112344e+000,-8.937504826250e+001,3.246783307516e+001
    9740,-2.062501113750e+000,-9.351618848086e+001,3.620735221038e+001
    9741,-2.062501113750e+000,-9.367059247229e+001,3.618456306934e+001
    9742,-2.062501113750e+000,-9.001682059207e+001,7.551203590076e+000
    9743,-2.062501113750e+000,-9.000547379669e+001,7.919678128250e+000
    9744,-2.062501113750e+000,-9.032526107009e+001,7.765356776812e+000
    9745,-2.062501113750e+000,-9.645722414922e+001,5.030981100415e+000
    9746,-2.062501113750e+000,-9.377925696777e+001,3.691037569632e+001
    9747,-2.062501113750e+000,-9.387700179168e+001,3.668192330459e+001
    9748,-2.062501113750e+000,-9.408923464551e+001,3.679068962207e+001
    9749,-2.996633085448e+000,-8.937504826250e+001,2.978768083711e+001
    9750,-2.727428684331e+000,-8.937504826250e+001,3.002337765806e+001
    9751,-2.694263503213e+000,-8.937504826250e+001,2.963283487039e+001
    9752,-2.062501113750e+000,-9.092277931874e+001,4.448896589051e+001
    9753,-2.062501113750e+000,-9.043326439685e+001,4.454736590994e+001
    9754,-2.062501113750e+000,-9.073624021772e+001,4.485413900111e+001
    9755,-3.048733426068e+000,-8.937504826250e+001,2.940786995877e+001
    9756,-2.746363843832e+000,-8.937504826250e+001,2.925302399205e+001
    9757,-2.062501113750e+000,-9.052905615654e+001,4.523390441942e+001
    9758,-2.062501113750e+000,-9.042568475674e+001,4.560829988376e+001
    9759,-2.062501113750e+000,-9.073404242789e+001,4.562081709724e+001
    9760,-3.137426059422e+000,-8.937504826250e+001,4.313567181217e+001
    9761,-3.401584869383e+000,-8.937504826250e+001,4.286274285749e+001
    9762,-3.449168943244e+000,-8.937504826250e+001,4.312103155886e+001
    9763,-2.062501113750e+000,-9.023968390923e+001,2.871750657726e+001
    9764,-2.062501113750e+000,-8.994920781271e+001,2.887651678006e+001
    9765,-2.062501113750e+000,-8.997268305528e+001,2.852094606726e+001
    9766,-2.444980655069e+000,-8.937504826250e+001,6.190499877187e+000
    9767,-2.389901804929e+000,-8.937504826250e+001,5.812794147558e+000
    9768,-2.062501113750e+000,-8.937504826250e+001,2.035499226865e+001
    9769,-2.062501113750e+000,-9.514776349526e+001,7.762055292722e+000
    9770,-2.062501113750e+000,-9.491960261580e+001,7.243752901091e+000
    9771,-2.062501113750e+000,-9.478850751779e+001,7.748360549705e+000
    9772,-2.062501113750e+000,-9.381388367752e+001,1.872659241454e+001
    9773,-2.062501113750e+000,-9.362527833900e+001,1.900733861438e+001
    9774,-2.062501113750e+000,-9.345783557230e+001,1.874494513726e+001
    9775,-3.643826334833e+000,-8.937504826250e+001,4.273805214703e+001
    9776,-3.666260645140e+000,-8.937504826250e+001,4.297595896235e+001
    9777,-2.062501113750e+000,-9.472794309708e+001,2.852102830951e+001
    9778,-2.062501113750e+000,-9.003354292949e+001,1.984287684830e+001
    9779,-2.062501113750e+000,-8.996219211103e+001,1.958852800065e+001
    9780,-2.062501113750e+000,-9.402349716883e+001,3.381320281581e+001
    9781,-2.062501113750e+000,-9.439305292719e+001,3.355947162267e+001
    9782,-2.062501113750e+000,-9.413394875739e+001,3.316415964258e+001
    9783,-2.062501113750e+000,-9.251958354129e+001,4.539510749538e+001
    9784,-2.062501113750e+000,-9.236648311204e+001,4.491526716648e+001
    9785,-2.062501113750e+000,-9.276964725425e+001,4.513789240700e+001
    9786,-2.862429420275e+000,-9.802463334978e+001,1.423434949558e+001
    9787,-2.402634383847e+000,-9.800642567091e+001,1.437090708710e+001
    9788,-2.402634383847e+000,-9.806916428919e+001,1.390036745000e+001
    9789,-3.028426304600e+000,-8.937504826250e+001,1.099058396183e+001
    9790,-3.032310964927e+000,-8.937504826250e+001,1.133815657557e+001
    9791,-3.327191921031e+000,-8.937504826250e+001,1.116352863463e+001
    9792,-2.393615388262e+000,-8.937504826250e+001,1.102357614703e+001
    9793,-2.392192933917e+000,-8.937504826250e+001,1.138086822560e+001
    9794,-3.663613248287e+000,-8.937504826250e+001,2.784188407718e+000
    9795,-3.491478096455e+000,-8.937504826250e+001,2.924051632710e+000
    9796,-3.736366958759e+000,-8.937504826250e+001,3.040075622189e+000
    9797,-2.062501113750e+000,-9.854732336709e+001,6.942874447222e+000
    9798,-2.062501113750e+000,-9.848617529407e+001,7.446697437119e+000
    9799,-2.062501113750e+000,-9.806551864851e+001,7.154535971922e+000
    9800,-2.575384803855e+000,-9.884056514847e+001,8.114861005403e+000
    9801,-2.062501113750e+000,-9.889014693998e+001,7.742997569103e+000
    9802,-2.062501113750e+000,-9.882434807836e+001,8.236489031228e+000
    9803,-2.062501113750e+000,-9.008164452565e+001,1.013391934780e+001
    9804,-2.062501113750e+000,-8.998136269468e+001,1.050221059430e+001
    9805,-2.062501113750e+000,-8.962860942030e+001,3.699375852934e+000
    9806,-2.062501113750e+000,-8.962860942030e+001,3.340869462763e+000
    9807,-2.062501113750e+000,-8.959482218854e+001,3.038572259026e+000
    9808,-2.062501113750e+000,-8.937504826250e+001,3.191498839210e+000
    9809,-2.062501113750e+000,-9.340516586795e+001,4.613598287064e+001
    9810,-2.062501113750e+000,-9.324104649040e+001,4.618202531963e+001
    9811,-2.062501113750e+000,-9.351645213564e+001,4.627723712464e+001
    9812,-2.062501113750e+000,-8.937504826250e+001,3.527598579996e+000
    9813,-2.062501113750e+000,-9.606748870313e+001,2.484236935597e+001
    9814,-2.062501113750e+000,-9.564075870164e+001,2.493114022666e+001
    9815,-2.062501113750e+000,-9.562429807908e+001,2.451407368401e+001
    9816,-2.062501113750e+000,-8.966136169446e+001,7.354734260027e+000
    9817,-2.062501113750e+000,-8.966549600895e+001,7.718482634752e+000
    9818,-2.062501113750e+000,-9.503571716026e+001,2.764712880500e+001
    9819,-2.062501113750e+000,-9.501919466939e+001,2.808539548705e+001
    9820,-2.062501113750e+000,-9.538464829418e+001,2.773824232708e+001
    9821,-2.062501113750e+000,-8.972357112002e+001,3.238779067928e+001
    9822,-2.062501113750e+000,-8.968450816856e+001,3.277199701470e+001
    9823,-2.062501113750e+000,-8.937504826250e+001,3.258902283324e+001
    9824,-2.062501113750e+000,-8.974693378305e+001,2.448835517730e+000
    9825,-2.062501113750e+000,-9.003621193427e+001,2.179955725102e+000
    9826,-2.062501113750e+000,-8.965073738142e+001,2.205606266240e+000
    9827,-2.062501113750e+000,-9.203939494090e+001,1.884335307868e+001
    9828,-2.062501113750e+000,-9.217139433505e+001,1.909794997314e+001
    9829,-2.062501113750e+000,-9.229322195621e+001,1.882115044476e+001
    9830,-2.062501113750e+000,-9.254438913561e+001,1.824349848429e+001
    9831,-2.062501113750e+000,-9.270698588776e+001,1.849928572468e+001
    9832,-2.062501113750e+000,-9.240634243524e+001,1.851951852413e+001
    9833,-2.062501113750e+000,-9.256893918739e+001,1.877530576453e+001
    9834,-2.444980655069e+000,-8.937504826250e+001,6.593819566130e+000
    9835,-2.062501113750e+000,-9.229241641166e+001,1.824420801445e+001
    9836,-2.062501113750e+000,-9.155776163387e+001,6.921152295251e+000
    9837,-2.062501113750e+000,-9.121354321369e+001,6.674767655894e+000
    9838,-2.062501113750e+000,-9.114315941520e+001,7.073829478344e+000
    9839,-3.487639020124e+000,-9.762579799940e+001,1.722561462343e+001
    9840,-3.195535008553e+000,-9.758262239468e+001,1.754943165884e+001
    9841,-3.084727285592e+000,-9.764393482131e+001,1.708958845915e+001
    9842,-3.645471507091e+000,-8.937504826250e+001,1.848001695743e+001
    9843,-2.720554045906e+000,-8.937504826250e+001,4.346691558944e+001
    9844,-2.773941255588e+000,-8.937504826250e+001,4.310386731391e+001
    9845,-3.079796544347e+000,-8.937504826250e+001,4.340324933584e+001
    9846,-2.062501113750e+000,-9.078145900412e+001,1.363316396617e+001
    9847,-2.062501113750e+000,-9.078145900412e+001,1.392241412237e+001
    9848,-2.062501113750e+000,-9.429693087447e+001,2.790664678747e+001
    9849,-2.062501113750e+000,-9.560358892053e+001,2.067400103087e+001
    9850,-2.062501113750e+000,-9.561369333732e+001,2.050892865954e+001
    9851,-2.062501113750e+000,-9.207890603866e+001,4.646883716083e+001
    9852,-2.062501113750e+000,-9.197439253391e+001,4.612057097978e+001
    9853,-2.062501113750e+000,-9.228455548579e+001,4.616266778860e+001
    9854,-2.062501113750e+000,-9.134463509029e+001,4.543922044121e+001
    9855,-2.062501113750e+000,-9.117941405352e+001,4.587030668679e+001
    9856,-2.062501113750e+000,-9.148971936266e+001,4.582014786677e+001
