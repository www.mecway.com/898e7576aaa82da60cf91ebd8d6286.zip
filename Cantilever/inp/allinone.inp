  4337,  1426,  1445,   924,  1167,  6073, 10510, 11184,  8739,  8735,  4008 
  4338,  1361,  1357,  1766,  1358,  4864, 10337, 11734,  4857,  4860, 10657 
  4339,  1761,  1359,  1357,  1361,  8845,  4846, 10336, 11735,  4858,  4864 
  4340,   806,   883,  2109,   882,  8071,  8307, 10032,  8068,  3095,  8308 
  4341,  1433,    94,    95,   896, 11391,  2219, 11390, 10310,  3141,  3140 
  4342,  1361,  1358,  1766,  1750,  4857, 10657, 11734, 11248, 10177,  6371 
  4343,   767,   846,  2091,  1997,  8108,  8272, 11260,  7733, 11051, 11050 
  4344,   822,   742,   741,  1972,  8036,  2953,  8037, 11045,  7658,  7657 
  4345,  1522,   214,   575,  1523,  9012,  6440,  5289,  5559,  9356,  5290 
  4346,  2079,   742,  1973,   823, 12097,  7660,  9961,  8247,  8038, 12098 
  4347,  1925,  2124,   433,  1926, 11271,  8982,  7516,  7520,  8981,  7518 
  4348,   613,  1846,   671,  1847,  7166,  8869,  6716,  7168,  7170, 11789 
  4349,  2053,   306,   433,   307,  8195, 11598,  9565,  8194,  2456,  9901 
  4350,   877,   801,   800,  2031,  8163,  3012,  8167, 11380,  7835,  7834 
  4351,   437,   311,  1064,   438,  8958,  3565, 11697,  2591, 12099,  9131 
  4352,   671,  1846,   612,  1813,  8869,  7165,  6717,  6958,  8870, 11388 
  4353,   512,  1105,   103,   104, 11628,  3689,  6688,  6691,  3688,  2229 
  4354,   585,   976,  1139,   197, 11873,  3958, 12016,  6467,  3304,  3806 
  4355,   975,  1534,   584,    58, 10565,  5318,  9738, 10564,  5317,  2759 
  4356,   671,  1846,   613,   612,  8869,  7166,  6716,  6717,  7165,  2818 
  4357,  2120,  1917,   425,  2049, 11232,  7492, 11227,  8470, 10937, 11161 
  4358,  1819,  1857,   682,  1776, 10082, 10084,  6974,  7133, 11008,  6836 
  4359,   745,  1976,   826,   746,  7669, 10983,  8085,  2957,  7670,  8086 
  4360,  1944,  1980,  2083,  2151,  7949,  9226,  9224, 11393, 11056,  8561 
  4361,  1977,   746,   747,   827,  7672,  2958,  7673,  9235,  8043,  8042 
  4362,  1944,  2133,  2083,  2062,  9202,  8664,  9224,  9203,  8483,  8665 
  4363,  1980,  2151,   749,   830, 11056,  9510,  7681, 11593,  8399,  8089 
  4364,  1973,   742,  2079,  1972,  7660, 12097,  9961,  7662,  7658, 11044 
  4365,  1463,   501,   502,   116,  5130,  2661,  5131, 11779,  6656,  6655 
  4366,  1041,   288,   414,  1040,  3498,  9195, 11545,  3854,  3496, 11657 
  4367,  1463,   116,   912,  1110, 11779,  3173,  9830,  8906,  3702,  3927 
  4368,  1448,  1436,  1704,  1296,  5084,  6038,  6063, 10204, 11834, 10203 
  4369,   822,   742,  2079,   823,  8036, 12097,  8248,  3035,  8038,  8247 
  4370,  1064,   311,   312,   438,  3565,  2461,  3566,  9131, 12099,  9384 
  4371,  1464,   912,  1463,   116,  9835,  9830,  5134, 11491,  3173, 11779 
  4372,  2002,  2161,  1928,  2001, 11848, 10014,  7916,  7749, 11849,  7917 
  4373,  1463,   502,  1464,   116,  5131,  5132,  5134, 11779,  6655, 11491 
  4374,    38,     7,   927,   135,  2797,  3202, 10459,  6614,  2266,  3203 
  4375,  1448,   135,   481,    38, 10461,  6616,  5082,  5083,  6614,  2638 
  4376,  1438,  1098,  1202,  1638, 12044,  4140,  9274,  5780, 11957,  9276 
  4377,   472,    86,    87,  1098,  6602,  2210,  6595, 12071,  3670,  3669 
  4378,  1411,  1142,  1053,   978, 11372,  4070, 10981, 11226,  3909,  4071 
  4379,  1943,  1942,   450,  2132,  7571,  7567,  7569, 10997, 10877, 10998 
  4380,  1075,   449,  1585,  1422, 10868,  5472, 11736, 10321,  5021,  5608 
  4381,   121,  1450,   483,   482, 11467,  5089,  6626,  6625,  5088,  2640 
  4382,    98,  1102,   507,    97,  3682, 11468,  6673,  2223,  3683,  6670 
  4383,   506,  1469,  1102,   507,  5146, 11988, 11989,  2668,  5149, 11468 
  4384,  2071,  1960,  2142,  2073, 11608, 11609,  8727,  8731,  8917,  8492 
  4385,  2072,  1960,  2071,  2073, 11420, 11608,  8377,  8725,  8917,  8731 
  4386,  1256,  1494,  1257,   951, 10910,  9217,  4487,  4300,  9215,  4303 
  4387,   506,   507,  1102,    97,  2668, 11468, 11989,  6671,  6670,  3683 
  4388,   238,   379,   380,   929, 11994,  2532, 11650,  3379, 11030, 11033 
  4389,  1983,  2084,  1984,  1942, 10586, 10068,  7695,  8004, 10070,  7943 
  4390,   506,    97,  1102,   899,  6671,  3683, 11989, 11523,  3146,  3871 
  4391,   881,   805,  2035,  2177,  8134,  7847, 10611,  8452, 11968,  9733 
  4392,  1917,   424,  2049,  1916,  7491,  9087, 10937,  7493,  7489, 10930 
  4393,  1184,  1714,   985,  1710,  9419,  9420,  4081, 12082,  6104, 10261 
  4394,  1924,  2007,  2164,  2095,  7996,  9635, 10399,  8980,  9637,  8514 
  4395,  1577,  1682,  1288,  1413,  6105,  9878,  9763,  5599,  6106, 11826 
  4396,   905,  1107,  1595,   108,  3921,  9094,  9082,  3159,  3692, 11917 
  4397,   734,   735,  1965,   816,  2946,  7637,  7636,  8081,  8100, 11543 
  4398,   884,  2178,   807,   883,  8453, 11839,  8073,  3096,  8454,  8070 
  4399,  2178,  2037,   807,   883, 10162,  7853, 11839,  8454, 10034,  8070 
  4400,   311,  2126,   312,   438,  8347,  8346,  2461, 12099,  9383,  9384 
  4401,  1041,   289,   415,   288,  3499, 11977, 11382,  3498,  2438, 11546 
  4402,  2174,  1908,  1907,  2030, 11356,  7467, 11723, 11951,  7985,  7986 
  4403,   238,   380,  1118,   929, 11650, 11032,  4463,  3379, 11033,  3728 
  4404,   905,   108,  1595,   517,  3159, 11917,  9082,  9083,  6674,  5518 
  4405,  1706,   894,  1163,  1225, 12087,  3977, 11177, 11973,  4207,  4210 
  4406,  1163,   894,  1706,   895,  3977, 12087, 11177,  3976,  3677, 12066 
  4407,  2079,   742,   822,  1972, 12097,  8036,  8248, 11044,  7658, 11045 
  4408,  2134,  2081,  1947,  1946,  8671, 12019, 12083, 11175, 11103,  7583 
  4409,   843,  2089,   763,   842,  8267, 11104,  8051,  3055,  8268,  8049 
  4410,  1595,   516,   517,   108,  5517,  2678,  5518, 11917,  6675,  6674 
  4411,  1165,  1383,  1551,  1001, 10101,  5372, 10102,  4705, 11230, 12031 
  4412,  1244,  1165,  1383,  1650,  4509, 10101, 11073, 11891, 10103,  5963 
  4413,   906,  1165,  1244,  1650,  3988,  4509,  4271, 11518, 10103, 11891 
  4414,  1202,  1098,  1158,  1638,  4140,  3965,  4450,  9276, 11957,  9072 
  4415,  1235,  1590,  1632,  1428, 11140,  5764, 11930,  9737,  5612,  5765 
  4416,   950,  1227,  1493,   949,  4414,  9575, 10907,  3769,  4390, 12100 
  4417,  1947,  2064,  2149,  2081, 11867,  8673,  9790, 12019,  8670,  8559 
  4418,    40,   916,   120,    13, 10429,  3181,  6647,  2799,  3180,  2249 
  4419,   118,   494,    12,   913,  6648,  6642,  2246,  3174, 11115,  3175 
  4420,  2134,  2064,  1947,  2081,  8547, 11867, 12083,  8671,  8670, 12019 
  4421,   547,   161,   946,   160,  6560,  3243, 10841,  6559,  2296,  3244 
  4422,   496,  1457,   916,  1458,  5116, 11286, 10431,  5117,  5507, 10430 
  4423,  1977,  2081,  1947,  1976, 10950, 12019,  7953,  7674, 10978,  7982 
  4424,   851,   852,  2003,  2162,  3064, 11101,  9873,  8422,  8421, 11088 
  4425,  1930,  2092,  2055,  2126,  9555,  8637, 11310,  8966,  8636,  8476 
  4426,  1807,  1857,  1819,  1776,  8939, 10082,  7040,  7131, 11008,  7133 
  4427,  1947,  2081,  2149,  1976, 12019,  8559,  9790,  7982, 10978,  9791 
  4428,  2087,   838,   759,   839,  8264,  8046, 11940,  8263,  3051,  8075 
  4429,  1121,  1480,   144,  1479, 11504, 11627,  3740,  8755,  5181,  9672 
  4430,  1878,   645,   703,   644,  7262,  6768,  9839,  7261,  2850,  6769 
  4431,  1804,   383,   382,  1868,  9547,  2535,  9669,  9548,  7417,  7416 
  4432,  2047,  1913,   421,   420, 11021,  7481,  9392, 11398,  7480,  2574 
  4433,  1596,   171,   954,  1132, 10530,  3260, 10139, 10141,  3774,  3944 
  4434,  1596,   171,   536,   954, 10530,  6533,  5531, 10139,  3260, 11293 
  4435,  1607,  1209,  1606,  1369, 11098,  9504,  5669,  5667, 11999,  5665 
  4436,  1693,  1659,  1511,  1124,  6075,  5846,  5998, 10685, 11195, 10689 
  4437,   474,    88,    89,  1099,  6604,  2212,  6606,  9955,  3672,  3671 
  4438,   382,  1868,  1869,  1824,  7416,  7236,  7366,  9671, 11623,  9677 
  4439,  1804,  1868,   382,  1824,  9548,  7416,  9669,  7037, 11623,  9671 
  4440,  1878,  1829,   645,  1879,  9841, 10863,  7262,  7266, 10890,  7264 
  4441,   514,   105,   903,   513,  6681,  3154, 11378,  2675,  6692, 11889 
  4442,  1456,   494,   914,  1455,  5113, 10375, 10376,  5505,  5112,  9185 
  4443,  1606,  1209,  1027,  1369,  9504,  4160,  9503,  5665, 11999, 10773 
  4444,  2157,  1993,  1992,  1935, 10783,  7722,  9623, 10126,  7929,  7931 
  4445,   166,   949,   950,   539,  3249,  3769,  3252,  6540, 12095, 12015 
  4446,  1302,  1151,  1386,  1168,  3917, 10593,  9949,  4556,  4652, 11244 
  4447,   539,   949,  1493,  1492, 12095, 12100,  5213,  5212,  9736,  5532 
  4448,   950,   949,  1493,   539,  3769, 12100, 10907, 12015, 12095,  5213 
  4449,   337,  2139,   338,   464,  8373,  8372,  2487, 11374, 10889, 10839 
  4450,    88,  1439,   891,  1099,  9402, 10360,  3130,  3672,  9956,  3868 
  4451,   389,   390,   961,  1389,  2542, 10915,  9471,  4947,  4946, 10485 
  4452,  1639,  1733,  1638,  1336,  6184,  6183,  5783, 10035, 10104, 11860 
  4453,   653,   652,   711,  1886,  2858,  6817,  6803,  7286,  7285, 12101 
  4454,  1437,  1098,  1438,  1638, 11304, 12044,  5056,  5779, 11957,  5780 
  4455,  2146,  1953,  2067,  1952,  9047, 10824,  8682,  8893,  7601,  8895 
  4456,  1834,  1799,  1888,  1792,  7026,  9648, 10245,  7100,  7134,  9647 
  4457,  1799,  1887,  1833,  1791,  9287,  9068,  7135,  7028, 10553,  7099 
  4458,  1008,  1388,  1269,  1686, 12030, 11501,  4599,  9365,  5582,  9363 
  4459,   391,   568,   569,   963,  5876,  2740,  4951, 11447, 11211,  9782 
  4460,  1664,  1539,  1540,  1286,  5870,  5576,  5871,  9130, 11077, 11717 
  4461,   903,  1106,   514,  1382,  3875, 11164, 11378, 10297, 10298,  5152 
  4462,   971,  1539,  1687,  1286,  8810,  5935, 11081,  4425, 11077, 10445 
  4463,   371,  1149,   230,   229, 11360,  3834, 10795, 11824,  3833,  2377 
  4464,   596,   972,  1539,   193, 11257,  8811,  5338,  6485,  3296,  8812 
  4465,  1933,  1932,  2090,  1996,  7541, 11840, 10006,  7926,  7925, 10919 
  4466,  2087,   839,   759,  1990,  8263,  8075, 11940, 11267,  9861,  7711 
  4467,  1108,   497,   111,   909, 10366,  6649,  3699,  3877, 10933,  3166 
  4468,   909,  1468,   908,  1670, 11816,  9060,  3697, 11810,  5895, 12069 
  4469,  1829,  1879,  1880,   646, 10890,  7269, 10596, 10862,  7265,  7267 
  4470,  1829,   646,  1880,   704, 10862,  7267, 10596,  6997,  6771, 10597 
  4471,  1288,  1226,  1577,  1058,  4506, 12059,  9763,  4467,  4214,  9765 
  4472,  1001,  1107,  1551,  1165,  4379,  9093, 12031,  4705,  4364, 10102 
  4473,   234,   376,   235,  1003, 10515, 10514,  2382,  3370, 10303,  3371 
  4474,   645,  1829,   646,  1879, 10863, 10862,  2851,  7264, 10890,  7265 
  4475,   981,  1699,  1684,  1538, 11924,  6162, 11669, 12037,  6012,  5928 
  4476,  1176,  1645,  1647,  1740,  9772,  6066, 11493, 10871,  6241,  6262 
  4477,  1066,  1417,   946,  1065,  9091,  9090,  4032,  3573,  9134,  4036 
  4478,  1531,   984,   209,   582, 10624,  3320, 11264,  5310, 10340,  6454 
  4479,  1288,  1185,  1684,   982,  4445, 11668, 11825,  4524,  4082, 11670 
  4480,  1798,   720,  1896,  1796,  7017,  9487, 12092,  7016,  6877, 10548 
  4481,  1629,  1229,  1420,  1228, 10926, 11414,  5749, 10243,  4224, 11415 
  4482,    30,  1529,   987,  1147, 11132, 10462,  3325,  3827, 11133,  3914 
  4483,  1500,   549,   162,   548,  5232,  6563, 10620,  5231,  2716,  6562 
  4484,   949,  1227,  1493,  1653,  4390,  9575, 12100,  9514,  9515,  5826 
  4485,   122,  1759,  1112,   918, 10508, 11169,  3711,  3185, 10509,  3713 
  4486,   524,  1120,   381,   930, 11795, 11188,  4938, 11651,  3887, 11190 
  4487,   793,   871,  2024,  2103,  8065, 10353,  7813, 11399,  8295, 10355 
  4488,  1412,   592,  1143,  1575,  5330, 11026, 10631,  5445,  5448, 10633 
  4489,  1143,   592,   979,  1575, 11026, 10557,  3910, 10633,  5448, 10558 
  4490,  1739,  1323,  1214,  1213, 10740,  4639, 12079, 11713,  4638,  4176 
  4491,  1613,  1270,  1323,  1190, 11361,  4723,  9447,  9445,  4340,  4724 
  4492,  2047,   420,   294,  2117, 11398,  9125,  8183,  8589, 11652,  8327 
  4493,  1222,  1698,  1625,  1342, 10363,  5883, 11442,  4742, 12013,  9908 
  4494,   532,   175,   176,  1484,  6524,  2314,  6527,  5191,  9935, 12102 
  4495,   566,   180,   962,   179,  6424,  3276, 10790,  6422,  2319,  3786 
  4496,  2036,   806,  2109,   882,  7850, 10032, 11699, 11929,  8068,  8308 
  4497,  1191,  1307,  1637,  1192,  4580, 11134,  8945,  4103,  4581,  8947 
  4498,   525,  1120,   140,   141, 11799,  3735,  6514,  6517,  3734,  2272 
  4499,  1555,  1120,   525,   141, 11796, 11799,  5524,  9476,  3734,  6517 
  4500,  2024,   794,  2025,  2172,  7814,  7816,  7818, 10354, 12103, 11283 
  4501,  1563,  1394,   402,  1015,  5623,  4961,  5409, 11168, 10079,  9170 
  4502,   835,   834,  2085,  1985,  3047,  8260,  8259, 11235, 10886, 10897 
  4503,   931,  1120,  1555,   141,  3934, 11796,  9219,  3213,  3734,  9476 
  4504,  1752,  1160,  1344,  1751, 11553,  4763, 10262,  6293, 11556, 10264 
  4505,  1148,   366,   998,  1549, 10669,  9662,  3853,  9651,  5369,  9650 
  4506,  1243,   997,  1694,  1380,  4454, 11637, 10239, 10314, 12034,  6166 
  4507,   909,   908,  1246,  1670,  3697,  4275,  4274, 11810, 12069, 11809 
  4508,  1201,  1017,  1180,  1395,  4136,  4052,  4137, 10531,  9401,  9785 
  4509,  1643,  1160,  1752,  1751, 12005, 11553,  6291,  6288, 11556,  6293 
  4510,  1643,  1642,  1442,   893,  5795,  5791,  5793,  9303,  9305, 11558 
  4511,    92,   893,  1442,    91,  3134, 11558, 11315,  2215,  3135, 11744 
  4512,   349,  1369,   272,   350,  4889, 10771,  4865,  2501,  4890,  4862 
  4513,   985,  1267,  1184,  1710,  4328,  4331,  4081, 10261, 10680, 12082 
  4514,  1169,  1289,  1184,  1730,  4549,  4448,  4567, 11823, 11846, 11640 
  4515,   351,   270,  1371,  1025,  5147, 10175,  4895, 11424,  3450, 11425 
  4516,  1005,   237,   378,   236,  3376,  8897,  9405,  3375,  2384,  9334 
  4517,   378,   236,  1826,  1785,  9334,  6993,  8896,  9409,  6907,  6990 
  4518,  2024,   871,   794,  2172, 10353,  8064,  7814, 10354,  8442, 12103 
  4519,  2025,   794,   872,  2172,  7816,  8123, 11282, 11283, 12103,  8441 
  4520,  1779,   629,   688,   687,  9317,  6747,  6842,  6843,  6744,  2895 
  4521,  1478,  1479,   932,   143,  5522,  8754,  9814, 10602, 11338,  3216 
  4522,  1508,  1297,  1122,  1173,  8764,  4519,  8763,  9021,  4531,  4024 
  4523,  1101,   893,  1442,    92,  3870, 11558, 11314,  3676,  3134, 11315 
  4524,  1901,  2110,  2178,  2038, 10830,  8588,  9719,  7869,  9426, 11172 
  4525,  1803,   380,   238,   379, 12052, 11650,  6909, 11332,  2532, 11994 
  4526,  1151,   383,   932,   241, 11555, 10615,  4462,  3840, 10096,  3385 
  4527,  1720,  1730,  1169,  1659,  6235, 11823, 11845,  6316,  6249, 11194 
  4528,  1588,  1633,  1249,  1644,  5769,  9610, 11958,  6031,  6047, 10021 
  4529,   435,  1061,   308,   434, 11698,  3556, 11122,  2588, 10675, 11548 
  4530,   422,  1048,  1574,  1049, 11256, 11945,  5437, 11885,  3855, 12017 
  4531,  1409,  1049,  1574,  1139, 11364, 12017,  5628, 11352,  4069, 10560 
  4532,  1496,    50,   943,  1506,  5219,  8962, 11703,  5548,  5245, 10519 
  4533,  1574,  1139,  1049,  1048, 10560,  4069, 12017, 11945,  4195,  3855 
  4534,  1574,   421,  1408,  1048,  5438,  4993,  5598, 11945, 11255, 12104 
  4535,  1735,  1246,  1734,  1670, 11741, 11745,  6195,  6205, 11809,  6258 
  4536,   294,  1047,  1046,   420,  3515,  3517,  3513,  9125,  8943,  8941 
  4537,  1574,  1408,  1265,  1048,  5598, 11354, 12054, 11945, 12104,  4484 
  4538,  1222,  1309,  1698,  1342,  4587,  9263, 10363,  4742,  4741, 12013 
  4539,  1625,  1731,  1746,  1342,  6250,  6307,  6334,  9908, 11952,  9906 
  4540,  1694,  1380,   997,   365,  6166, 12034, 11637,  4920,  5637, 11638 
  4541,  1145,  1714,  1526,  1533,  9418,  6103,  9390,  9391,  6102,  5315 
  4542,  1741,  1714,  1184,  1710,  6299,  9419, 11641,  6300,  6104, 12082 
  4543,  1051,  1410,  1600,   977, 11326,  5743, 11139,  4067, 11576, 11362 
  4544,  1577,  1226,  1414,  1058, 12059, 10379,  5646,  9765,  4214, 11570 
  4545,  1119,  1554,  1005,   929,  8883,  9606,  4386,  3933, 10666,  4110 
  4546,  1228,  1227,  1070,  1582,  4221,  4218,  4219,  8842,  8840,  9779 
  4547,  1420,  1228,  1071,  1070, 11415,  4220, 11215, 12042,  4219,  3588 
  4548,  1420,  1071,   444,  1070, 11215, 11220,  5018, 12042,  3588, 11632 
  4549,  1746,  1731,  1313,  1342,  6307, 10977, 12076,  9906, 11952,  4812 
  4550,   363,  1793,   364,  1890, 10457,  9800,  2516,  7332,  9572,  7333 
  4551,  1199,  1014,  1393,  1198,  4129, 12105, 10607,  4131,  4127, 10608 
  4552,  1170,  1492,  1419,  1653,  9729,  5835,  9728,  9513,  5825,  6131 
  4553,  1170,   949,  1492,  1653,  4015,  9736,  9729,  9513,  9514,  5825 
  4554,  1492,   949,  1493,  1653,  9736, 12100,  5532,  5825,  9514,  5826 
  4555,  2020,   867,   789,   790,  9634,  8097,  7801,  7802,  8076,  3001 
  4556,  1081,  1082,  1588,   457,  3622, 11704, 12106, 10737, 12107,  5484 
  4557,  1081,   457,  1588,  1426, 10737,  5484, 12106,  9803,  5029,  5610 
  4558,   873,  2104,   795,   872,  8297, 11757,  8125,  3085,  8298,  8124 
  4559,  2104,  2172,  1911,  2025,  8582,  9105,  9478, 11284, 11283,  7886 
  4560,   656,   714,   715,  1890,  6784,  2922,  6818,  7297,  9569,  9559 
  4561,  1559,   963,   184,   964,  9781,  3789,  9780, 10419,  3948,  3280 
  4562,   715,   714,  1793,  1890,  2922,  6871,  6870,  9559,  9569,  9572 
  4563,  1548,   365,   997,  1380,  5365, 11638, 11005,  5638,  5637, 12034 
  4564,  1808,   402,  1845,  1844, 11218,  7434, 10583, 11897,  7404,  7164 
  4565,  1180,  1154,  1291,  1395,  4053,  4457,  4739,  9785, 10499, 10498 
  4566,  2010,  2011,  1922,  2097,  7776,  7905,  7995, 10929,  9889, 11206 
  4567,  2038,  1902,  2178,  1901,  7870,  9717, 11172,  7869,  7450,  9719 
  4568,  1381,  1102,  1162,  1469,  9481,  3974, 11597,  5685, 11988,  8823 
  4569,   404,  1769,   260,  1811, 12008,  6943, 10167, 11272,  6952,  6955 
  4570,   260,   403,  1016,   259, 11445,  9283,  3425,  2407, 11404,  3424 
  4571,  1728,  1348,  1356,  1758, 10234,  4825, 11739,  6331, 10662, 10074 
  4572,   794,   871,   872,  2172,  8064,  3084,  8123, 12103,  8442,  8441 
  4573,   451,   325,   452,  2133, 10567, 11966,  2605,  9200,  8361,  9530 
  4574,  1451,   919,  1114,  1423, 10545,  3883,  9004,  5799, 12108,  9005 
  4575,  1090,  1089,  1592,  1239,  3646,  9491,  8813,  4254,  4253,  8826 
  4576,  1207,  1609,  1317,  1206,  9592, 11788,  4618,  4155, 11775,  4617 
  4577,  1372,  1023,  1610,  1206, 11407, 11969,  5676, 11429,  4150, 11594 
  4578,   450,   449,  1585,  1076,  2603,  5472,  5471,  9709, 10649,  8880 
  4579,   403,   402,  1016,   259,  2555,  9171,  9283, 11404,  9172,  3424 
  4580,  1458,  1457,   916,  1248,  5507, 11286, 10430,  9299, 10477,  4281 
  4581,   447,  1421,  1584,  1073,  5019,  5607,  5470, 11605, 10673, 10672 
  4582,  1036,  1230,  1035,  1402,  4478,  4228,  3485, 10149, 11143,  8977 
  4583,  1902,  2112,  2041,   409, 11911,  8461,  9716,  7448, 12000, 12056 
  4584,  1565,  1154,  1291,  1018,  8782,  4457, 10497,  8784,  3963,  4458 
  4585,  1911,  2024,  2025,  2172,  7887,  7818,  7886,  9105, 10354, 11283 
  4586,   943,   542,  1496,  1125,  8961,  5220, 11703,  3891, 11464, 11726 
  4587,  1496,   542,  1497,  1125,  5220,  5221,  5223, 11726, 11464, 11539 
  4588,   925,  1644,  1447,  1446, 10022,  5797,  9028,  9026,  5796,  5498 
  4589,   309,   435,  2054,  2125, 11124, 11123,  8196,  8345, 11325,  8475 
  4590,  1448,   926,   135,   927, 11397,  3200, 10461, 10460,  3204,  3203 
  4591,   254,   255,  1011,   398,  2402,  3410,  3409,  9114,  9223,  9116 
  4592,   726,  1840,  1797,   724,  7146, 10456, 10789,  6390,  9499,  6879 
  4593,  1063,  1062,  1416,   944,  3564, 10782, 10849,  4051,  4029, 10534 
  4594,  1447,   926,   135,  1448, 11095,  3200, 11094,  5085, 11397, 10461 
  4595,  1447,  1448,   135,   481,  5085, 10461, 11094,  5081,  5082,  6616 
  4596,  1775,   251,   393,   394,  6929, 10511, 11117, 11118, 12109,  2546 
  4597,  1854,  1817,  1855,   394, 10638, 11125,  7194,  7389, 11902,  7388 
  4598,     7,    38,  1436,   471,  2797,  5049, 11297,  6593,  2626,  5050 
  4599,  1640,  1159,   892,  1641, 11475,  3968,  8862,  5789, 11477,  8864 
  4600,  2116,   417,   418,   291, 10739,  2571,  9328,  8326, 11695, 11457 
  4601,  2174,  2030,  1907,  2106, 11951,  7986, 11723,  8584, 10770, 11724 
  4602,    92,    91,  1442,   477,  2215, 11744, 11315,  6597,  6603,  5067 
  4603,  1712,  1183,  1660,  1304,  9674,  9675,  6093,  9994,  4571,  9993 
  4604,  1902,   409,  2041,  1901,  7448, 12056,  9716,  7450,  7447,  9718 
  4605,   711,  1833,   653,  1886,  6867,  9067,  6803, 12101, 10437,  7286 
  4606,  1242,  1160,  1643,  1751,  4264, 12005,  9302, 10190, 11556,  6288 
  4607,  1508,   556,  1122,   148,  5249,  9023,  8763, 10222,  6577,  3746 
  4608,  1097,  1568,  1400,  1666,  9118,  5424, 11837, 12058,  5879,  5878 
  4609,   409,  1036,  1035,  1402, 11689,  3485,  8976,  4982, 10149,  8977 
  4610,  1797,  1796,  1837,  1898,  7114,  7138,  7103, 11421, 11787,  9621 
  4611,   304,  2122,   430,   303,  8338, 11797, 11408,  2453,  8339, 12110 
  4612,   430,  2122,   429,   303, 11797,  9896,  2583, 12110,  8339,  9897 
  4613,  1056,   304,   430,   303,  3542, 11408, 11288,  3541,  2453, 12110 
  4614,  1327,  1737,  1640,  1231, 10317,  6209, 11485,  4664,  9468,  9466 
  4615,   429,  1056,   430,   303, 10327, 11288,  2583,  9897,  3541, 12110 
  4616,  1337,  1303,  1704,  1296,  4715, 12089, 10378,  4714,  4566, 10203 
  4617,  1639,  1439,   891,  1438,  5782, 10360,  9352,  5781,  5059,  9353 
  4618,   441,   315,  2057,   314, 10792,  8202, 11662, 12111,  2464,  8203 
  4619,   441,  2057,   440,   314, 11662,  9618,  2594, 12111,  8203,  9617 
  4620,  1067,   315,   441,   314,  3575, 10792, 11303,  3574,  2464, 12111 
  4621,  1268,  1187,  1658,  1124,  4334,  9152, 11631,  4398,  4291, 11029 
  4622,   440,  1067,   441,   314,  9619, 11303,  2594,  9617,  3574, 12111 
  4623,   526,   143,   931,   142,  6519,  3214,  9477,  6520,  2274,  3212 
  4624,   557,   938,   150,  1510,  9073,  3227,  6582,  5254, 10870, 10309 
  4625,  1750,  1760,  1331,  1358,  6342,  8856,  9508, 10177, 11800,  4838 
  4626,   696,   695,  1871,   637,  2903, 10902, 10901,  6813,  6807,  7240 
  4627,  1581,  1283,  1068,   948, 11606,  4570,  9941, 11607,  4413,  4017 
  4628,   547,  1580,   946,   161,  5539,  9088, 10841,  6560, 10622,  3243 
  4629,  1068,  1129,  1581,   948,  4018, 10434,  9941,  4017,  3938, 11607 
  4630,  1217,  1036,  1566,  1402,  4183, 10148,  9753, 11278, 10149,  5416 
  4631,  1269,  1686,  1525,   989,  9363,  5933, 12027,  4336, 11948,  9646 
  4632,   862,   863,  2015,  2099,  3075, 10088, 10127,  8288,  8287,  9208 
  4633,   451,  1077,  1078,   325, 11602,  3609, 11524, 10567,  3605,  3607 
  4634,  1782,  1868,   635,   634, 11622,  7232,  9629, 11129,  7231,  2840 
  4635,  1895,  1798,   719,   720,  8889,  7018,  8807, 11896,  7017,  2927 
  4636,  1236,  1331,  1702,  1237,  4676,  9511, 10663,  4249,  4677, 11722 
  4637,  1508,   148,   937,   555, 10222,  3225,  8765,  5248,  6578, 10347 
  4638,  1379,   995,   363,  1546,  9799,  9797,  4919,  5364, 10787,  5357 
  4639,  1443,   478,  2181,  1101,  5070, 10614, 10612, 10113, 11895, 10715 
  4640,   220,   361,   219,  1795, 10833, 10879,  2367,  6884, 11836,  6885 
  4641,  1420,  1654,  1629,  1228,  6020,  6025,  5749, 11415,  8841, 10243 
  4642,   334,   335,   461,  2067,  2484,  8998,  8997,  8223,  8222, 10823 
  4643,   462,   461,  1086,   335,  2615, 10898,  8994, 11817,  8998,  3632 
  4644,   250,   964,   393,   965,  3404,  8769, 10334,  3405,  3903,  8770 
  4645,  1341,  1616,  1636,  1747, 10540,  6084, 10538, 11155,  6278,  6277 
  4646,  1242,  1325,  1344,  1751,  4647,  4769,  4764, 10190, 11733, 10264 
  4647,   568,  1135,   567,   181,  9148,  9149,  2739,  6427,  3788,  6428 
  4648,  1163,  1340,  1341,  1747,  4776,  4775,  4762, 11178, 10268, 11155 
  4649,  1086,   336,   462,   335,  3633,  8995,  8994,  3632,  2485, 11817 
  4650,  1385,   523,   524,   930,  5174,  2687,  5698, 11182, 11992, 11651 
  4651,  1192,   995,  1379,  1546,  4101,  9799, 10542,  8948, 10787,  5364 
  4652,   301,  1054,   428,   302,  3535, 11119,  9456,  2451,  3536, 10896 
  4653,   184,   185,  1559,   964,  2324, 10996,  9780,  3280,  3279, 10419 
  4654,   719,  1798,  1895,  1795,  7018,  8889,  8807,  6874,  7022,  8890 
  4655,   959,  1675,  1484,   958,  8805,  5906, 11982,  3781, 11441, 12025 
  4656,  1306,  1745,  1764,  1667, 11776,  6373,  9745,  9972,  6273,  6363 
  4657,  2138,  2067,   461,   335,  8488, 10823,  9834,  8371,  8222,  8998 
  4658,  1235,  1234,  1632,  1329,  4243,  8932, 11930,  4671,  4670,  9838 
  4659,    88,  1439,   473,   891,  9402,  5057,  6601,  3130, 10360, 10359 
  4660,  1052,  1600,   978,  1141, 10342, 10341,  4076,  4077,  8761,  3956 
  4661,   890,  1436,   927,  1296,  8955, 10487,  3205,  4515, 11834,  4516 
  4662,  1895,   720,   719,   662, 11896,  2927,  8807,  7313,  6797,  6794 
  4663,   718,  1836,   660,   717,  7014, 10727,  6793,  2925,  7015,  6790 
  4664,   958,   959,   176,  1484,  3781,  3270,  3267, 12025, 11982, 12102 
  4665,   312,  2056,   439,   438,  8201,  9706, 11761,  9384,  9385,  2592 
  4666,  1722,  1604,  1211,  1212,  6137, 12050, 11319, 12011, 11785,  4170 
  4667,  1211,  1604,  1029,  1212, 12050, 11784,  4166,  4170, 11785,  4168 
  4668,    34,    31,   217,   724,  4527,  2364, 10735,  4526,  2933,  6881 
  4669,   374,  1001,   232,  1150, 12029,  3365,  9098, 11961,  3837,  3836 
  4670,   400,   401,  1014,  1393,  2553, 11396, 12112,  4959,  4958, 12105 
  4671,   705,  1880,   704,  1788, 10491, 10597,  2912,  6860, 10492,  6861 
  4672,   724,    34,   358,   217,  4526,  2510,  9498,  6881, 10735, 11093 
  4673,  1031,  1030,  1603,  1213,  3470,  9987, 10988,  4172,  4171, 10285 
  4674,  1603,  1212,  1030,  1604, 10284,  4169,  9987,  5660, 11785,  9989 
  4675,   276,  1366,  1031,  1030, 11869, 11855,  3468,  3466,  9988,  3470 
  4676,  1211,  1212,  1321,  1722,  4170,  4633,  4632, 11319, 12011, 10412 
  4677,  1722,  1604,  1212,  1721,  6137, 11785, 12011,  6139,  6136, 12012 
  4678,  2104,  2025,  1911,  1910, 11284,  7886,  9478,  9479,  7885,  7476 
  4679,    74,  1397,    73,    66, 10187, 10186,  2193,  3107,  4969,  3106 
  4680,  2116,  2045,   417,   291,  8466, 10404, 10739,  8326,  8178, 11695 
  4681,  1929,   436,   437,  2055,  7527,  2590,  7528,  9142,  9008, 11311 
  4682,  2142,  2070,  2074,  2040,  8695,  8692,  8592, 10945, 10947, 11022 
  4683,   176,   959,    15,    46,  3270,  3269,  2315,  6526,  9850,  2789 
  4684,  1137,   971,  1687,  1182,  3797, 11081, 11080,  4060,  4059,  9381 
  4685,   532,   959,  1485,  1484, 12113,  8806,  5192,  5191, 11982,  5528 
  4686,  1664,  1286,  1345,  1182,  9130,  4765, 10238,  9379,  4426,  4766 
  4687,   217,   218,   991,   358,  2365,  3335,  3334, 11093, 11179, 10750 
  4688,   776,  2007,  2006,  2095,  7762,  7764,  7760,  9469,  9637,  8789 
  4689,  1349,  1318,  1757,  1726,  4790, 11852, 10452, 10854,  9595,  6325 
  4690,  1368,  1028,  1027,  1606,  9162,  3461,  9161,  5664, 10725,  9503 
  4691,  1045,  1223,  1044,  1407,  4202,  4201,  3511, 10694, 10696, 11692 
  4692,  1885,  1832,  1790,   709, 10570,  7029, 12091, 11681,  7006,  6864 
  4693,   228,   369,  1104,   901, 11305, 11888,  4456,  3360,  9945,  3873 
  4694,  1104,   369,   228,   370, 11888, 11305,  4456, 11711,  2522,  9598 
  4695,   708,  1831,  1790,  1883,  7002,  7001,  6865, 10784, 11219, 11531 
  4696,  1753,  1329,  1328,  1353,  9910,  4672,  9701, 10427,  4807,  4806 
  4697,  1459,  1164,  1697,  1670, 11814,  9199,  6008,  5896, 11749,  6037 
  4698,   176,   959,   532,  1484,  3270, 12113,  6527, 12102, 11982,  5191 
  4699,  1221,  1571,  1698,  1624, 10732,  6009,  9264, 10762,  5720,  6010 
  4700,   707,  1831,   708,  1883,  7003,  7002,  2915, 10785, 11219, 10784 
  4701,  1610,  1206,  1023,  1205, 11594,  4150, 11969, 11595,  4152,  4148 
  4702,   876,   875,  2174,  2029,  3088,  8446,  8445, 10957, 11801, 11950 
  4703,   110,    42,   505,   908,  6666,  2666,  6667,  3165,  9059,  9058 
  4704,   232,  1001,   374,   233,  3365, 12029,  9098,  2380,  3366, 11996 
  4705,  1871,   380,  1870,  1825,  7429,  7363,  7242, 10903, 12053, 11061 
  4706,    48,    21,  1486,   952,  2791, 10324,  5194, 10273,  3255,  8773 
  4707,   238,  1825,  1783,   380,  7109,  7059,  6912, 11650, 12053, 12114 
  4708,  1783,   381,   238,   380, 11342, 11649,  6912, 12114,  2533, 11650 
  4709,  2046,   418,  1910,  1911,  9330,  7472,  9480,  9107,  7474,  7476 
  4710,   287,  1040,   413,   288,  3495, 11551, 11880,  2437,  3496,  9193 
  4711,  2045,   416,  2115,  1909, 10405, 10255,  8532, 10616,  7468, 10253 
  4712,  1688,  1614,  1339,  1199,  5985,  9308,  9247,  9248,  9310,  4728 
  4713,  1783,  1825,  1870,   380,  7059, 11061, 11835, 12114, 12053,  7363 
  4714,  1870,   381,  1783,   380,  7364, 11342, 11835,  7363,  2533, 12114 
  4715,  1485,   959,   532,    46,  8806, 12113,  5192,  5193,  9850,  2697 
  4716,  1533,   985,  1145,  1714, 10260,  3912,  9391,  6102,  9420,  9418 
  4717,   249,   248,  1819,   391,  2396,  6975,  7041, 11446,  9561, 12048 
  4718,  1187,   938,  1509,  1658,  4292,  9074,  9151,  9152, 10941,  5842 
  4719,  1819,   392,   249,   391, 11470,  9167,  7041, 12048,  2544, 11446 
  4720,  1123,  1693,  1279,  1671, 10684, 11821,  4392, 11844,  5969, 11822 
  4721,   389,  1778,   246,   247, 11222,  6922,  9173,  9538,  6924,  2394 
  4722,   683,  1858,  1819,  1777,  9399, 10081,  6973,  6839,  9686,  6972 
  4723,  1533,  1710,  1532,   985,  6080,  6079,  5316, 10260, 10261, 10678 
  4724,  1710,  1184,  1334,  1267, 12082,  4759, 11567, 10680,  4331,  4760 
  4725,  1710,  1267,  1334,  1705, 10680,  4760, 11567,  6081, 11461, 11568 
  4726,   268,   354,   353,  1373,  6383,  2505,  6320, 10743,  4902,  4901 
  4727,  2158,  2089,  1934,  1994,  8508, 10760,  9627,  8818,  8817,  7928 
  4728,  1184,  1279,  1169,  1730,  4773,  4393,  4567, 11640, 11763, 11823 
  4729,   532,   959,   176,    46, 12113,  3270,  6527,  2697,  9850,  6526 
  4730,   759,   839,   760,  1990,  8075,  8098,  2971,  7711,  9861,  7712 
  4731,  1808,  1844,   403,   402, 11897,  7405, 11403, 11218,  7404,  2555 
  4732,   444,  1070,  1071,   318, 11632,  3588, 11220, 11781,  3584,  3586 
  4733,   855,  2007,   776,  2095,  9636,  7762,  8056,  8279,  9637,  9469 
  4734,  1192,  1616,  1308,  1637, 10543, 11978,  4583,  8947,  5979, 11136 
  4735,  1393,  1014,  1013,  1198, 12105,  3420, 11794, 10608,  4127,  4126 
  4736,  1419,   442,  1068,  1069,  5016,  9943,  9942, 11644,  9984,  3582 
  4737,  1467,  1245,  1649,  1326,  9053, 10468,  5809, 11906,  4686, 10467 
  4738,  1247,  1583,  1229,  1072, 11859, 11804,  4401,  4402,  9367,  4223 
  4739,  1299,  1256,  1654,  1257,  4730, 10458, 10244,  4691,  4487, 11577 
  4740,    25,   599,  1543,  1138,  6491,  5346,  9979,  3800, 11375, 11337 
  4741,  1308,  1616,  1192,  1193, 11978, 10543,  4583,  4584, 10539,  4106 
  4742,  2064,   328,  2134,   454,  8217,  8362,  8547, 12084, 12049, 12062 
  4743,  1387,  1557,   386,  1007,  5586,  5391,  4942,  9820,  9361,  9359 
  4744,  1387,  1312,  1295,  1672,  9818,  4688, 11076,  6197, 12061, 11684 
  4745,  1295,  1312,  1251,  1672,  4688,  4687,  4514, 11684, 12061,  8926 
  4746,  1086,  1429,   462,  1087, 10811,  5036,  8994,  3637, 10496,  8996 
  4747,  1507,   937,  1297,  1252, 10674,  4520, 10766, 10630,  4289,  4536 
  4748,  1760,  1766,  1360,  1358,  6370, 10451,  8858, 11800, 10657,  4839 
  4749,  1543,    53,    25,  1516,  5345,  2780,  9979,  5553,  5270,  9980 
  4750,  1233,  1589,  1084,  1234,  8835,  9743,  4236,  4240,  9744,  4238 
  4751,   462,  1087,   463,   336,  8996, 10495,  2616,  8995,  3635, 10840 
  4752,   965,   964,  1519,   185,  3903,  8771,  8772,  3790,  3279, 11521 
  4753,  1767,  1322,  1321,  1352, 11582,  4637, 10411, 10201,  4836,  4802 
  4754,  1368,   348,   274,  1367,  4886,  3946, 10481,  4888,  4884, 11059 
  4755,  1591,  1237,  1088,  1087, 11746,  4248, 10943, 11306,  4247,  3640 
  4756,  1519,   571,   186,   185,  5280,  6436,  9251, 11521,  6433,  2325 
  4757,  1306,  1352,  1764,  1745,  4815, 10199,  9745, 11776, 10391,  6373 
  4758,  1601,   981,  1144,   207, 12115,  4058, 11082, 12116,  3314,  3816 
  4759,   993,   219,   220,   361,  3339,  2367,  3340, 10432, 10879, 10833 
  4760,   981,  1601,   595,   207, 12115,  5575, 12032,  3314, 12116,  6464 
  4761,   854,   776,  2006,  2095,  8054,  7760, 11932,  8280,  9469,  8789 
  4762,   595,  1538,    28,    57,  5335, 12036,  6466,  2771,  5336,  2784 
  4763,   967,  1285,  1521,   966,  4422, 11565,  9741,  3793,  4423,  9958 
  4764,  1661,  1262,  1261,   968, 11253,  4523,  9746,  9895,  4316,  4313 
  4765,  1915,  1916,  2119,   423,  7490, 10931, 10712,  7486,  7488,  9065 
  4766,  1123,  1693,  1169,  1279, 10684, 10683,  4013,  4392, 11821,  4393 
  4767,  1775,  1855,   679,  1817, 10717, 10718,  6835,  6966, 11125,  6967 
  4768,  1684,  1538,   982,   981,  5928, 11991, 11670, 11669, 12037,  3818 
  4769,   981,    28,   595,  1538,  3313,  6466, 12032, 12037, 12036,  5335 
  4770,  1409,  1535,   976,   586,  5568, 10697, 11941,  5567,  5322, 10686 
  4771,  1532,  1267,  1266,   984, 10679,  4330, 11828, 11085,  4329,  4326 
  4772,  1915,  2018,  2119,  1916,  7892, 10806, 10712,  7490,  7893, 10931 
  4773,  1530,  1682,  1684,   982,  5924,  6111,  5929, 10142, 11566, 11670 
  4774,  1519,   186,   965,   185,  9251,  3282,  8772, 11521,  2325,  3790 
  4775,  1222,  1223,  1625,  1572,  4203, 11443, 11442, 11613, 12117,  5723 
  4776,   403,  1769,   404,  1843, 10463, 12008,  2556,  7406, 10465,  7407 
  4777,   406,   262,  1810,  1809, 12118,  7045, 11307, 10529,  6945,  7066 
  4778,  1137,  1545,  1665,  1687,  9524,  5874, 10474, 11080,  5934,  5937 
  4779,  1407,  1224,  1345,  1664, 10695,  4784, 11437,  5972,  9128, 10238 
  4780,   689,   688,  1822,   630,  2896,  6981,  6980,  6810,  6746, 11525 
  4781,  1865,  1780,   385,  1864,  8759, 10333,  7430,  7224, 10443,  7371 
  4782,  1917,  2100,  2017,  1916, 10938, 10700,  7895,  7493, 10934,  7894 
  4783,  1140,  1050,  1410,  1535,  4073, 11200, 11575, 10704, 10699,  5439 
  4784,  1313,  1195,  1746,  1311,  4602, 12002, 12076,  4712,  4596,  9905 
  4785,    28,  1538,  1530,    57, 12036,  5565, 10922,  2784,  5336,  5307 
  4786,  1866,  1780,   385,  1865, 10921, 10333,  7370,  7227,  8759,  7430 
  4787,  1062,  1579,  1172,  1061,  8973, 12018,  4553,  3561, 12081,  4569 
  4788,   389,  1558,  1009,   388,  5393,  9472,  9175,  2541,  5394,  9176 
  4789,  1407,  1664,  1345,  1625,  5972, 10238, 11437,  5722,  5973, 10250 
  4790,  1407,  1625,  1345,  1223,  5722, 10250, 11437, 10696, 11443,  4641 
  4791,   195,   974,    58,   598,  3300, 10975,  6489,  6488, 10974,  2775 
  4792,  1341,  1636,  1193,  1290, 10538, 10537,  4737,  4738, 11002,  4579 
  4793,  2054,   434,  2124,  1927, 11270,  8983,  8537, 10954,  7521, 12026 
  4794,   320,  2060,   447,   446,  8209, 11755, 11856, 10851, 11771,  2600 
  4795,   444,  2059,   318,   445, 11944,  8207, 11781,  2598, 11263, 10805 
  4796,   715,  1835,  1891,  1890,  7013,  9490,  9560,  9559,  9573,  7302 
  4797,  1728,  1356,  1749,  1758, 11739, 10073,  6333,  6331, 10074,  6356 
  4798,  1360,  1348,  1349,  1758,  4847,  4791,  4848, 10661, 10662, 11249 
  4799,   716,   658,   715,  1891,  6789,  6786,  2923, 10517,  7301,  9560 
  4800,  1374,  1611,  1022,  1612,  5680, 11998,  9473,  5682,  5684, 12043 
  4801,  1071,   445,   319,  1072,  9368, 10804,  3587,  3591,  9369,  3589 
  4802,   320,   446,   319,  2130, 10851, 10850,  2469,  8354, 11919,  8355 
  4803,  1212,  1721,  1213,  1322, 12012, 11714,  4173,  4635, 11584,  4636 
  4804,  1321,  1721,  1767,  1722, 12010,  6379, 10411, 10412,  6139,  6380 
  4805,   711,  1886,   652,   710, 12101,  7285,  6817,  2918, 10571,  6778 
  4806,  2130,  2060,   320,   446,  8543,  8209,  8354, 11919, 11771, 10851 
  4807,  1546,  1378,  1667,  1191,  5356,  5886,  5885,  8946, 10205,  9973 
  4808,   221,   362,   994,   220,  9697, 10845,  3343,  2368, 10831,  3342 
  4809,  1328,  1303,  1233,  1669,  4669,  4565,  4667,  9102, 10019,  9044 
  4810,  1353,  1744,  1753,  1748, 10428,  6296, 10427, 10100,  6302,  6339 
  4811,  1265,  1542,  1335,   974, 11815, 11221,  4696,  4323, 10976,  4695 
  4812,  1378,   362,   994,  1546,  4916, 10845, 10747,  5356,  5355, 10786 
  4813,  1082,   457,   331,   458, 12107, 11901,  3620, 10478,  2611, 10479 
  4814,   442,  1934,   441,  2128,  7543,  7542,  2595,  8821, 10759, 11727 
  4815,  1833,  1886,   711,   710, 10437, 12101,  6867,  6866, 10571,  2918 
  4816,   832,  1983,   833,   753, 10585, 10682,  3045,  8149,  7691,  8150 
  4817,  1139,   585,   197,   196, 12016,  6467,  3806,  3807,  6460,  2340 
  4818,  1937,  2156,  2087,  1990,  9991,  8506,  9990,  7934,  9860, 11267 
  4819,   444,  2129,   318,  2059, 11782,  8352, 11781, 11944,  8542,  8207 
  4820,   961,   179,  1599,  1389,  3273, 12022,  9032, 10485, 10484,  5850 
  4821,  1599,   179,   565,  1389, 12022,  6423,  5555,  5850, 10484,  5276 
  4822,   304,  2052,   430,  2122,  8193, 11409, 11408,  8338,  8590, 11797 
  4823,   212,  1527,   579,   578, 12065,  5299,  6449,  6450,  5298,  2752 
  4824,  1613,  1190,  1547,  1270,  9445, 12033,  5687, 11361,  4340, 10853 
  4825,  1588,   457,  1082,   458,  5484, 12107, 11704,  5483,  2611, 10478 
  4826,  1412,   429,  1055,  1537,  5001, 10328, 11512,  5334,  5884, 11454 
  4827,   895,     8,  1444,  1432,  3139,  9099, 11370, 12119, 12120,  5074 
  4828,  2054,  2162,  2093,  1927,  8630,  8512,  8633, 10954, 11090, 10955 
  4829,  2123,  1924,  2164,  2095,  8979, 10399,  8625,  8624,  8980,  8514 
  4830,  1095,  1696,  1273,  1619,  9856,  9854,  4354, 10071,  6004, 10507 
  4831,  1433,    94,   895,  1432, 11391,  3138, 11864,  5493, 12121, 12119 
  4832,    84,     6,    81,   809,  2206,  3121,  3122,  7617,  3021, 10781 
  4833,  1433,   468,    94,  1432,  5043,  6586, 11391,  5493,  5042, 12121 
  4834,  1928,  2161,  1929,  2001, 10014,  9143,  7529,  7917, 11849,  7918 
  4835,   895,  1432,  1444,  1706, 12119,  5074, 11370, 12066,  6050,  6052 
  4836,   895,    94,     8,  1432,  3138,  2218,  3139, 12119, 12121, 12120 
  4837,  2061,  2085,  2153,  1941,  8658,  8563,  8661,  8745,  8746, 10872 
  4838,  1981,  1982,  2152,   831,  7689,  9930, 11592, 11054, 11947,  8402 
  4839,  1904,  1905,  2043,   412,  7459, 11217,  9844,  7455,  7457, 11679 
  4840,  2061,   322,   448,   449,  8211, 10867, 10320,  8866, 10869,  2602 
  4841,  1422,  1593,  1113,   918,  5757,  8903, 11737, 11170,  8904,  3882 
  4842,     8,  1432,    36,  1444, 12120,  5041,  2795,  9099,  5074,  5073 
  4843,   971,  1545,  1687,  1539, 10137,  5934, 11081,  8810,  5580,  5935 
  4844,  1625,  1698,  1617,  1342,  5883,  6182,  6181,  9908, 12013, 11953 
  4845,  1610,  1316,  1727,  1206,  8853,  8855,  6153, 11594,  4615, 11773 
  4846,  1355,  1336,  1762,  1359,  4823, 10106, 11241,  4850,  4845,  8844 
  4847,   594,  1601,  1144,   207,  5574, 11082, 10092,  6465, 12116,  3816 
  4848,  1552,  1326,  1649,  1292, 10470, 10467,  5967,  9998,  4692,  9997 
  4849,     8,    94,    36,  1432,  2218,  6587,  2795, 12120, 12121,  5041 
  4850,  1642,  1242,  1643,  1751,  9304,  9302,  5795,  6215, 10190,  6288 
  4851,   892,  1099,   474,    89,  3859,  9955,  8871,  3133,  3671,  6606 
  4852,    94,   468,    36,  1432,  6586,  2622,  6587, 12121,  5042,  5041 
  4853,  2067,  1952,  1953,   460,  8895,  7601, 10824, 11236,  7597,  7599 
  4854,   454,   922,   455,   328, 11180,  9041,  2608, 12049,  3616,  9042 
  4855,  1387,  1007,   385,  1006,  9820, 11268,  4943, 11063,  3390, 11062 
  4856,  1731,  1298,  1313,  1342, 10969,  4833, 10977, 11952,  4743,  4812 
  4857,   452,   325,   326,  2133, 11966,  2475, 10178,  9530,  8361,  8360 
  4858,    39,   493,   923,  1454,  2651,  9182,  9343,  5108,  5107,  8738 
  4859,   594,   207,  1144,   206,  6465,  3816, 10092,  6462,  2350,  3817 
  4860,  1614,  1199,  1563,  1393,  9310, 12072,  5709,  5695, 10607,  5590 
  4861,   895,  1706,  1444,   894, 12066,  6052, 11370,  3677, 12087,  9101 
  4862,   594,   207,   595,  1601,  6465,  6464,  2770,  5574, 12116,  5575 
  4863,   401,  1393,  1563,  1014,  4958,  5590,  5410, 11396, 12105, 11395 
  4864,   975,  1542,    58,   974, 10566,  5344, 10564,  3805, 10976, 10975 
  4865,   671,  1813,   612,   670,  6958, 11388,  6717,  2878,  6959,  6714 
  4866,  1771,   401,  1813,   258, 11939,  9525,  7072,  6940,  9527,  7142 
  4867,   724,  1840,   358,    34,  9499,  7148,  9498,  4526,  7147,  2510 
  4868,   993,  1190,  1547,  1378,  4096, 12033,  9413, 10433, 10206,  5362 
  4869,  2082,  1978,   828,  2150, 11234, 11350,  8254,  8560, 10780,  8397 
  4870,  1548,  1193,   997,   996, 10551,  4105, 11005,  9407,  4104,  3353 
  4871,  1367,   274,   275,   347, 11059,  2423, 10226,  4883,  3950,  3951 
  4872,  1144,  1601,  1576,  1699, 11082,  5996,  8909,  8910,  6011,  6204 
  4873,  1594,   115,   911,   500, 10952,  3170, 10135,  5509,  6661, 10279 
  4874,  1796,  1798,  1837,  1898,  7016,  7024,  7138, 11787, 11928,  9621 
  4875,   906,  1466,  1650,  1648, 11519,  5812, 11518, 12040,  5807,  5992 
  4876,  1467,  1326,  1552,  1648, 11906, 10470,  5984,  5808, 11907,  6126 
  4877,  1196,  1298,  1731,  1342,  4535, 10969, 11400,  4740,  4743, 11952 
  4878,  1895,  1798,  1896,  1898,  8889, 12092,  7317,  7437, 11928,  7438 
  4879,  1321,  1721,  1212,  1322, 12010, 12012,  4633,  4637, 11584,  4635 
  4880,  1214,  1739,  1603,  1602, 12079,  6221, 11328, 11327,  6220,  5657 
  4881,  1739,  1214,  1603,  1213, 12079, 11328,  6221, 11713,  4176, 10285 
  4882,  1321,  1352,  1320,  1755,  4802,  4801,  4634, 10193, 10200, 10194 
  4883,  1896,  1798,  1796,  1898, 12092,  7016, 10548,  7438, 11928, 11787 
  4884,  1785,   378,  1873,  1826,  9409,  7359, 11884,  6990,  8896, 11057 
  4885,   114,   500,  1462,   911,  6662,  5128,  9916,  3171, 10279,  9918 
  4886,  1871,  1825,  1803,   380, 10903,  7088, 10305,  7429, 12053, 12052 
  4887,   969,   968,  1515,   190,  3795,  9893,  9892,  3290,  3287, 11153 
  4888,  1871,   380,  1803,  1872,  7429, 12052, 10305,  7245,  7362, 10307 
  4889,   238,   930,  1118,   380,  3380,  3732,  4463, 11650, 11183, 11032 
  4890,  1601,  1699,   981,  1538,  6011, 11924, 12115,  5645,  6012, 12037 
  4891,   377,   236,   235,  1004,  9362,  2383,  9574,  9355,  3373,  3372 
  4892,   371,  1800,   370,   229,  9787,  9788,  2523, 11824,  6899,  9599 
  4893,   501,   115,  1594,   500,  6658, 10952,  5510,  2660,  6661,  5509 
  4894,   430,  1923,  2122,  2052,  7509,  9751, 11797, 11409,  9756,  8590 
  4895,  1463,  1275,  1662,  1110,  9831, 10364,  6029,  8906,  4367, 11488 
  4896,  2122,  2165,  2009,  1922,  8613, 10924,  9749,  9750, 11207,  7906 
  4897,  1739,  1323,  1213,  1322, 10740,  4638, 11713, 11583,  4640,  4636 
  4898,   410,   409,  1402,  1036,  2563,  4982,  4981, 10147, 11689, 10149 
  4899,  1035,  1230,  1569,  1402,  4228, 11276,  8975,  8977, 11143,  5593 
  4900,  1794,  1892,  1893,   717,  9571,  7308,  9458,  6872,  9312,  9311 
  4901,   371,   372,   230,  1149,  2524, 10601, 10795, 11360,  9081,  3834 
  4902,  1084,  1083,   459,  1589,  3628, 11472, 11174,  9743,  8837,  5486 
  4903,  1233,  1589,  1234,  1630,  8835,  9744,  4240,  9104,  5751,  8933 
  4904,  2065,  1949,  1973,  1950, 10058,  7956,  9959,  9960,  7592,  7957 
  4905,  1658,  1659,  1268,  1124,  5847, 11193, 11631, 11029, 11195,  4398 
  4906,   430,  1923,  1922,  2122,  7509,  7511,  7507, 11797,  9751,  9750 
  4907,  1730,  1693,  1169,  1659,  6164, 10683, 11823,  6249,  6075, 11194 
  4908,   285,  2042,   410,   284,  8172, 10350, 10348,  2434,  8173, 10610 
  4909,   938,  1510,  1658,  1124, 10870,  5843, 10941,  3890, 11687, 11029 
  4910,   109,   504,    43,  1466,  6665,  2664,  6664, 10315,  5140,  5139 
  4911,   296,   295,   421,  1048,  2445,  9394, 11254,  3519,  3518, 11255 
  4912,  1230,  1217,  1623,  1402,  4500,  9754,  9757, 11143, 11278,  5719 
  4913,   421,  1047,  1408,  1048, 11573, 10794,  4993, 11255,  3520, 12104 
  4914,   169,  1487,   534,   533,  8928,  5197,  6529,  6530,  5196,  2699 
  4915,  1257,   952,  1495,  1677,  4302,  8774,  9216,  8832,  8775,  5910 
  4916,  1774,   395,   252,  1817, 10815, 10817,  6932,  7053, 11811,  7042 
  4917,  1408,  1047,  1265,  1048, 10794,  4483, 11354, 12104,  3520,  4484 
  4918,  1883,   707,  1789,   649, 10785,  6862, 10812,  7276,  6775,  9683 
  4919,    22,   956,  1491,   955,  3264,  9688, 10642,  3261,  3778, 10287 
  4920,   956,  1482,    47,  1491,  9690,  5186, 10112,  9688,  5209,  5208 
  4921,  1487,   533,   169,  1131,  5196,  6530,  8928,  8930,  8931,  3773 
  4922,  1926,  2004,  2162,  1927,  7913, 11089, 10249,  7523,  7914, 11090 
  4923,  1267,  1663,  1266,  1226, 11432,  9870,  4330,  4568, 10381,  4552 
  4924,  1532,  1531,  1266,  1663,  5566,  9869, 11828,  5867,  5866,  9870 
  4925,  1169,  1659,  1693,  1124, 11194,  6075, 10683,  4014, 11195, 10685 
  4926,   770,  2000,   769,   849,  7742,  7741,  2981,  8168, 12122,  8152 
  4927,   693,  1824,   694,  1869,  6986,  6985,  2901,  9603,  9677,  9602 
  4928,   158,   544,   157,  1597,  6567,  6564,  2293, 11202,  5536, 11205 
  4929,  2140,  1958,  2039,   466, 10119,  7868, 10117, 10757,  7615,  7864 
  4930,  1507,   937,    45,   555, 10674, 10346,  5246,  5247, 10347,  2724 
  4931,   147,   936,    45,   519,  3224, 10223,  6497,  6498, 11495,  2682 
  4932,  1543,   970,    25,  1138,  9981,  3291,  9979, 11337,  3905,  3800 
  4933,  1705,  1226,  1334,  1253, 10380,  4750, 11568, 11798,  4485,  4731 
  4934,   693,   692,  1782,   634,  2900,  6849,  6848,  6806,  6752, 11129 
  4935,  1866,   633,  1867,  1781,  7226,  7228,  7230, 10722,  9375,  9373 
  4936,  1705,  1226,  1253,  1414, 10380,  4485, 11798,  6042, 10379, 10388 
  4937,  1414,  1226,  1577,  1663, 10379, 12059,  5646,  5868, 10381,  5869 
  4938,  1288,  1226,  1266,  1663,  4506,  4552,  4443,  9879, 10381,  9870 
  4939,  1120,   524,   381,  1555, 11795,  4938, 11188, 11796,  5523,  5385 
  4940,  1518,   564,   177,   563,  5274,  6418, 10966,  5273,  2735,  6417 
  4941,   406,   405,   262,  1809,  2558,  8798, 12118, 10529,  8800,  6945 
  4942,   961,   390,   389,   247, 10915,  2542,  9471,  3398,  9540,  9538 
  4943,   382,   381,   239,  1824,  2534, 11189, 11536,  9671, 11343,  6987 
  4944,   397,  1010,   396,  1391,  9584, 10818,  2549,  4954,  9586,  4955 
  4945,  1243,  1380,  1290,  1193, 10314, 10313,  4468,  4459, 12035,  4579 
  4946,  1154,   405,   261,   262,  8783,  8799,  3848,  3849,  8798,  2409 
  4947,  2013,  1919,  2098,  2167,  7900,  8970, 10040,  9403,  9404,  8517 
  4948,  1294,  1217,  1732,  1623,  4767,  9668,  9441,  9442,  9754,  6365 
  4949,  1240,  1565,  1291,  1018, 11903, 10497,  4707,  4258,  8784,  4458 
  4950,  1621,  1180,  1291,  1395,  9783,  4739, 11899,  5715,  9785, 10498 
  4951,  1250,  1556,  1472,  1281, 10647,  5815, 11068,  4403,  9952, 10004 
  4952,   667,  1842,   609,   608, 10575,  7154,  6804,  6811,  7153,  2814 
  4953,  1443,  1101,  2181,   894, 10113, 10715, 10612, 10115,  3920, 10716 
  4954,   890,    86,  1437,  1098,  3128,  8963,  8953,  3851,  3670, 11304 
  4955,  1899,  1810,  1838,  1809, 10837,  7121, 10648, 10528,  7066,  7139 
  4956,  2137,  1952,  2067,   460,  8894,  8895,  8550, 10836,  7597, 11236 
  4957,  1057,  1577,  1288,  1413,  9764,  9763,  4446,  9563,  5599, 11826 
  4958,   212,  1527,   986,  1146, 12065,  9639,  3323,  3825, 11604,  3913 
  4959,  2080,   824,  2148,  1974,  8250,  8393,  8558, 10011,  9323,  9321 
  4960,  1885,   709,  1790,  1884, 11681,  6864, 12091,  7284, 11769, 11768 
  4961,   895,    94,  1433,   896,  3138, 11391, 11864,  3678,  3141, 10310 
  4962,   369,   901,   999,  1103,  9945,  4109, 10577,  9947,  3925,  4380 
  4963,   429,  1576,   430,  1056,  5450,  5449,  2583, 10327,  9734, 11288 
  4964,  1943,   450,   451,  2062,  7569,  2604,  7570,  9611, 10999,  9201 
  4965,  1445,    39,   923,  1454,  5076,  9343,  8736,  5109,  5108,  8738 
  4966,  1569,  1091,  1401,  1400, 11275,  9919,  5724,  5725,  9920,  4979 
  4967,  1536,   589,   590,   978,  5326,  2765,  5327, 10343, 11480, 11225 
  4968,  1097,  1230,  1294,  1666,  4229,  4503,  4502, 12058,  9758,  9759 
  4969,   408,   282,    80,  1091,  8988,  3480, 11702, 12123,  3648,  3647 
  4970,   704,  1829,   645,   703,  6997, 10863,  6815,  2911,  6998,  6768 
  4971,   107,   516,  1595,   108,  6676,  5517, 11783,  2233,  6675, 11917 
  4972,   202,   589,   201,   978,  6482,  6483,  2345,  3307, 11480,  3308 
  4973,   590,   589,   202,   978,  2765,  6482,  6480, 11225, 11480,  3307 
  4974,   844,  2090,  1995,  2158,  8270, 10917, 11909,  8413,  8568, 11351 
  4975,  1581,  1067,   441,  1418, 11463, 11303,  5464,  5603, 10899,  5013 
  4976,   917,  1450,  1112,   121, 11466, 11413,  3881,  3182, 11467,  3712 
  4977,  1035,   282,   408,  1091,  3481,  8988, 12060,  3649,  3648, 12123 
  4978,  1224,  1286,  1345,  1664,  4611,  4765,  4784,  9128,  9130, 10238 
  4979,   408,  1091,  1401,  1569, 12123,  9919,  4980,  5426, 11275,  5724 
  4980,  1035,  1091,   408,  1569,  3649, 12123, 12060,  8975, 11275,  5426 
  4981,  2080,  1974,  2148,  1949, 10011,  9321,  8558, 10012,  8006,  9579 
  4982,  2133,  2151,  2063,  1945,  8667,  8666,  8546,  9531, 10086,  9533 
  4983,  1768,  1899,  1838,  1809, 11386, 10648,  7122,  7116, 10528,  7139 
  4984,   611,   669,  1812,   610,  6712,  6956,  9711,  2816,  6713, 11107 
  4985,  1737,  1336,  1327,  1762, 10105,  4701, 10317,  6348, 10106, 11956 
  4986,  1867,  1804,  1782,  1868,  9546,  7113, 11128,  7233,  9548, 11622 
  4987,   315,   442,   441,  2128, 10793,  2595, 10792,  8351,  8821, 11727 
  4988,  1499,  1127,  1064,   945, 10000,  4027,  9292,  9018,  3893,  4028 
  4989,   393,   251,   965,   394, 10511,  3406,  8770,  2546, 12109, 11444 
  4990,   670,  1770,  1845,   611,  6824, 10582, 11452,  6715,  9948,  7162 
  4991,  1121,  1479,  1386,  1480,  8755,  5976, 10594, 11504,  5181,  6259 
  4992,   437,  2126,   311,   438, 11453,  8347,  8958,  2591,  9383, 12099 
  4993,  1845,  1770,  1812,   611, 10582,  7073,  9710,  7162,  9948,  9711 
  4994,  1152,  1520,   965,   394,  9267,  9253,  4055, 11962,  5704, 11444 
  4995,   965,   251,  1152,   394,  3406,  3844,  4055, 11444, 12109, 11962 
  4996,   435,  1579,  1062,  1061,  5456,  8973, 11728, 11698, 12081,  3561 
  4997,  1759,  1593,  1422,   918,  5798,  5757,  6336, 10509,  8904, 11170 
  4998,   554,  1506,   154,    50,  5244,  9720,  6575,  2723,  5245,  6574 
  4999,  1506,   154,  1505,   554,  9720, 10183,  5547,  5244,  6575,  5243 
  5000,   609,  1843,   668,   610,  7156, 10761,  6711,  2815,  7157,  6710 
  5001,  1486,  1677,  1131,  1175,  5911, 12051,  8929, 11841, 11578,  4040 
  5002,   679,   621,   620,  1854,  6730,  2826,  6731, 10625,  7190,  7189 
  5003,  1855,   621,   679,  1854,  7192,  6730, 10718,  7194,  7190, 10625 
  5004,   260,  1769,   403,   259,  6943, 10463, 11445,  2407,  6944, 11404 
  5005,   541,  1494,   540,   951,  5216,  5215,  2707, 10667,  9215, 10962 
  5006,  1218,  1219,  1343,  1622,  4190,  4752,  4751, 11879, 11890,  9454 
  5007,  1563,  1015,  1199,  1688, 11168,  4130, 12072,  5939, 11167,  9248 
  5008,   400,  1393,  1014,  1013,  4959, 12105, 12112, 11793, 11794,  3420 
  5009,  1614,  1688,  1563,  1199,  5985,  5939,  5709,  9310,  9248, 12072 
  5010,  1315,  1204,  1205,  1611,  4612,  4149,  4613, 11985, 11630, 11997 
  5011,  1970,  1952,  2146,  2078,  7961,  8893,  9996,  9970, 11666,  8556 
  5012,  1817,   251,  1775,   394,  6969,  6929,  6966, 11902, 12109, 11118 
  5013,   634,   633,   692,  1781,  2839,  6753,  6752,  9374,  9375,  6846 
  5014,  1854,   394,   395,  1817,  7389,  2547,  7390, 10638, 11902, 11811 
  5015,   463,  1088,   337,  1087, 11478,  3638, 10820, 10495,  3640,  3636 
  5016,   535,   171,  1596,  1132,  6534, 10530,  5530, 11212,  3774, 10141 
  5017,  1400,  1230,  1097,  1666, 11277,  4229, 11837,  5878,  9758, 12058 
  5018,  1236,  1235,  1086,  1590,  4246,  4242,  4244, 11141, 11140, 10810 
  5019,   398,  1850,   397,  1773,  7396,  7395,  2550,  9315, 10604,  9587 
  5020,  1822,  1780,   386,   244,  7069, 10442,  8766,  7126,  6919, 10494 
  5021,  1855,   622,  1856,  1818,  7193,  7195,  7197, 11252, 10884, 10882 
  5022,   937,   148,    17,   555,  3225,  2281,  3226, 10347,  6578,  6576 
  5023,  1543,   599,  1544,  1138,  5346,  5347,  5349, 11337, 11375, 11331 
  5024,  1159,  1100,   892,  1641,  3967,  3869,  3968, 11477,  9465,  8864 
  5025,   298,  1050,   424,  1051,  3524, 11199,  9085,  3526,  3528, 11905 
  5026,  1515,   191,   562,  1516, 11152,  6410,  5268,  5552, 11976,  5269 
  5027,  1742,  1340,  1308,  1344, 12093,  4804, 11943, 10263,  4770,  4814 
  5028,   400,  1013,  1014,   257, 11793,  3420, 12112, 11438,  3416,  3418 
  5029,  1227,  1256,  1654,  1228,  4416, 10458,  8839,  4221,  4554,  8841 
  5030,  1877,  1828,   701,  1787, 10518,  7061, 10640, 11904,  7096,  6996 
  5031,  1228,  1070,  1420,  1582,  4219, 12042, 11415,  8842,  9779,  5648 
  5032,   443,  1582,  1070,  1653,  5466,  9779, 11298,  5604,  5605,  9778 
  5033,  1295,  1312,  1387,  1007,  4688,  9818, 11076,  4704,  4597,  9820 
  5034,  1264,  1286,  1224,  1689,  4442,  4611,  4480,  9123,  9124,  9129 
  5035,  2027,  2173,   873,   874,  8850,  8444, 10554, 10217,  8443,  3086 
  5036,   192,   599,    25,  1138,  6493,  6491,  2333,  3799, 11375,  3800 
  5037,  1541,  1540,   972,  1689,  5577,  9062,  9061,  5942,  5941,  9122 
  5038,  1877,   702,   644,  1787, 10641,  6766,  7259, 11904,  6859, 12085 
  5039,   725,   726,  1797,   723,  2935, 10789, 11718,  6392,  6389,  6880 
  5040,   150,  1124,   558,  1510,  3750, 12124,  6581, 10309, 11687,  5255 
  5041,   558,  1124,  1511,  1510, 12124, 10689,  5257,  5255, 11687,  5259 
  5042,   656,   714,  1889,   655,  6784,  9568,  7295,  2861,  6785,  7294 
  5043,   232,   373,   374,  1150,  9096,  2526,  9098,  3836, 11027, 11961 
  5044,  1792,   655,  1889,   713, 11874,  7294, 11138,  6868,  6782, 11534 
  5045,   176,   175,   958,  1484,  2314,  3268,  3267, 12102,  9935, 12025 
  5046,  1735,  1734,  1258,  1674,  6195,  8949, 11740,  6194,  6189,  8951 
  5047,  1651,  1484,   958,  1483,  5820, 12025,  9244,  5819,  5527,  9922 
  5048,  1792,   713,  1889,  1834,  6868, 11534, 11138,  7100,  7010, 11016 
  5049,   558,   150,   151,  1124,  6581,  2284,  6584, 12124,  3750,  3749 
  5050,   151,  1511,   558,  1124, 11097,  5257,  6584,  3749, 10689, 12124 
  5051,  1188,  1686,  1269,   989,  9364,  9363,  4370,  4092, 11948,  4336 
  5052,  1269,  1525,   990,   989, 12027,  9372,  4335,  4336,  9646,  3829 
  5053,   996,   222,   363,   995,  3348, 10080,  9798,  3350,  3346,  9797 
  5054,  1929,  2161,  1928,  2125,  9143, 10014,  7529, 11302,  8635, 10015 
  5055,   450,   324,   451,  2062,  9708, 10568,  2604, 10999,  8213,  9201 
  5056,  1338,  1391,  1262,  1010,  9583, 11626,  4534,  4532,  9586,  4533 
  5057,   245,  1806,   388,   387,  6920,  9335,  9536,  9607,  9337,  2540 
  5058,  1774,  1853,   396,   395, 11449,  7392, 10814, 10815,  7391,  2548 
  5059,   818,  1968,   737,  1967, 10843,  7645,  8164, 10091,  7647,  7643 
  5060,  1188,  1685,  1287,  1312,  9777,  9936,  4434,  4598, 11820,  4772 
  5061,  1376,   357,  1431,  1019,  4911,  5354,  5950,  9254,  9825,  9255 
  5062,   264,   467,    35,   357,  9826,  2621,  4627,  8734,  4913,  2509 
  5063,   404,  1811,   261,  1809, 11272,  7044,  9349, 11273,  7043,  6946 
  5064,   406,  1810,  1899,  1809, 11307, 10837,  7421, 10529,  7066, 10528 
  5065,  1246,  1164,  1735,  1301,  4276, 11748, 11741,  4711,  4710, 11742 
  5066,  1967,   818,   736,   737, 10091,  8144,  7642,  7643,  8164,  2948 
  5067,   400,   257,  1014,   401, 11438,  3418, 12112,  2553, 11946, 11396 
  5068,   428,  1054,  1412,  1055, 11119, 10632,  5002, 11716,  3540, 11512 
  5069,  2145,   736,  1966,  1967,  9887,  7640, 10090,  9117,  7642,  7644 
  5070,   271,  1025,   351,  1370,  3451, 11424,  5148, 11363, 11426,  4893 
  5071,  1245,  1292,  1734,  1649,  4541,  9313, 12074, 10468,  9997,  6254 
  5072,   272,  1027,   349,   273,  3456, 10772,  4865,  2421,  3457,  4465 
  5073,  1027,  1028,  1210,  1606,  3461,  4163,  4162,  9503, 10725,  9502 
  5074,  1706,  1225,  1163,  1708, 11973,  4210, 11177,  6060, 11677, 11676 
  5075,   409,   284,   283,  1036, 11688,  2433, 12057, 11689,  3484,  3483 
  5076,  1738,  1763,  1327,  1325,  6350, 12070, 11484, 11732,  9771,  4665 
  5077,  1742,  1344,  1308,  1347, 10263,  4814, 11943, 10220,  4817,  4781 
  5078,  2113,   411,  1904,   412, 10670,  7454,  9843, 11678,  2565,  7455 
  5079,  1816,  1851,  1852,   618, 10368,  7185,  9140, 10541,  7181,  7183 
  5080,  1822,   688,  1779,   630,  6981,  6842,  7056, 11525,  6746,  9316 
  5081,   410,   284,  2112,   409, 10610,  8316, 10609,  2563, 11688, 12000 
  5082,   294,  1047,   421,   295,  3515, 11573,  9393,  2444,  3516,  9394 
  5083,  1621,  1157,  1291,  1180, 10233,  4756, 11899,  9783,  4685,  4739 
  5084,   979,  1575,  1053,  1054, 10558, 10982,  4079,  4075, 10634,  3537 
  5085,  1917,   424,   425,  2049,  7491,  2578,  7492, 10937,  9087, 11161 
  5086,    67,  1094,    68,    75, 10826, 10827,  2185,  3109,  3657,  3110 
  5087,  2126,  1930,  2091,  1931,  8966,  8964,  8639, 10777,  7535,  9601 
  5088,   627,  1861,  1860,   685,  7210,  7212,  7208,  6799,  9378, 11591 
  5089,  2112,   284,   283,   409,  8316,  2433,  8317, 12000, 11688, 12057 
  5090,  2124,  2162,  2054,  1927,  8631,  8630,  8537, 12026, 11090, 10954 
  5091,  2124,   434,  2054,   308,  8983, 11270,  8537,  8342, 11548,  8197 
  5092,   435,   434,   308,  2054,  2588, 11548, 11122, 11123, 11270,  8197 
  5093,  1778,   388,   245,  1821, 11224,  9536,  6923,  7055, 11980,  7101 
  5094,   840,  1991,   760,  2156,  9177,  7714,  8048,  8409,  9863,  9859 
  5095,  1184,  1289,  1145,  1714,  4448,  4447,  4080,  9419,  9417,  9418 
  5096,  1398,  1157,    68,  1094, 10232,  9867,  4971, 10581,  4479, 10827 
  5097,   916,  1274,  1458,  1248,  4387,  9298, 10430,  4281,  4388,  9299 
  5098,  1279,  1741,  1184,  1334, 11762, 11641,  4773,  4690, 11569,  4759 
  5099,  1656,  1253,  1254,  1578, 10644,  4649, 10681,  5838, 10387, 10159 
  5100,  2065,  1949,   457,   456, 10058,  7588, 10057,  9985,  7587,  2610 
  5101,   923,    39,    14,   493,  9343,  2798,  3194,  9182,  2651,  6624 
  5102,   212,   211,   986,   578,  2357,  3324,  3323,  6450,  6445, 12024 
  5103,   939,    18,  1123,  1512,  3230,  3748,  3747, 11831, 11261, 11100 
  5104,   939,  1671,  1279,  1171, 11832, 11822,  4394,  4020,  9505,  4404 
  5105,  1730,  1741,  1279,  1671,  6231, 11762, 11763,  6165,  6228, 11822 
  5106,  1376,  1019,  1271,  1020,  9254,  4346,  9256, 11110,  3437,  4347 
  5107,  1093,  1241,  1240,  1396,  4259,  4261,  4257, 10415, 10416,  9810 
  5108,   285,   284,   410,  1037,  2434, 10610, 10348,  3487,  3486, 11674 
  5109,  1752,  1340,  1742,  1344, 10266, 12093,  6394, 10262,  4770, 10263 
  5110,  1317,  1609,  1727,  1206, 11788,  6152,  9111,  4617, 11775, 11773 
  5111,   285,  1037,   410,   411,  3487, 11674, 10348, 10349,  9927,  2564 
  5112,   725,   723,  1797,   722,  6392,  6880, 11718, 11156,  6878,  7019 
  5113,    65,   889,  2141,    64,  3104,  8379,  8378,  3100,  6377, 11579 
  5114,  1885,  1884,  1790,   369,  7284, 11768, 12091,  7343,  7426, 11309 
  5115,  1529,  1147,  1522,  1712, 11133,  9013,  5564,  6094, 11499,  6092 
  5116,   369,  1103,   999,   368,  9947,  4380, 10577,  2521, 11990, 11893 
  5117,   421,  1047,  1048,   295, 11573,  3520, 11255,  9394,  3516,  3518 
  5118,  1481,  1281,  1168,   933, 11334,  4438, 11245, 11341,  4400,  4011 
  5119,  1306,  1307,  1745,  1667,  4582, 11777, 11776,  9972,  9974,  6273 
  5120,  1131,  1677,  1293,  1175, 12051,  8833,  4493,  4040, 11578,  4492 
  5121,  1959,  2110,  2038,   808,  9430,  9426,  7867,  7858,  9427,  7856 
  5122,  1462,  1645,  1176,   911,  6067,  9772, 11522,  9918, 10136,  4381 
  5123,  1796,   721,   663,  1839,  6876,  6709, 10546, 10547, 10270,  7411 
  5124,  1357,  1347,  1359,  1765,  4835,  4843,  4846, 10338, 11559,  8843 
  5125,  1359,  1347,  1762,  1765,  4843, 11972,  8844,  8843, 11559,  6403 
  5126,  1486,  1677,   952,  1131,  5911,  8775,  8773,  8929, 12051,  4304 
  5127,  1662,  1645,  1594,  1179,  5862,  5864,  5863, 10150,  9774, 10928 
  5128,  1874,   698,   641,   699, 10352,  6762,  7250,  9242,  2906,  6808 
  5129,  1900,  2040,  2039,  2070,  7974,  7977,  7889, 11043, 10947, 10992 
  5130,  1002,  1383,  1244,  1001, 11231, 11073,  4345,  3369, 11230,  4344 
  5131,  1250,  1556,  1302,  1006, 10647,  9951,  4650,  4653, 11064,  4588 
  5132,  1188,  1557,  1312,  1007, 11819,  9819,  4598,  4114,  9361,  4597 
  5133,  1151,   241,   242,   384,  3840,  2389,  3841, 10801, 10723, 10799 
  5134,   386,  1780,   243,   244, 10442,  6917, 11246, 10494,  6919,  2391 
  5135,   519,   936,   935,   147, 11495,  3743, 11496,  6498,  3224,  3221 
  5136,   813,   812,  2074,   731,  3025,  8238,  8237,  8033,  8074, 10031 
  5137,   726,  1839,  1797,  1840,  7145, 10271, 10789,  7146,  7149, 10456 
  5138,  1796,  1839,  1896,  1898, 10547,  7423, 10548, 11787,  7439,  7438 
  5139,  1962,   732,   813,   731,  7628,  8032, 11659,  7627,  2943,  8033 
  5140,  1662,  1594,  1110,  1179,  5863,  8908, 11488, 10150, 10928,  4377 
  5141,  2074,   812,  1961,   731,  8238,  9796, 10030, 10031,  8074,  7625 
  5142,  1390,  1718,  1177,  1521,  6270, 11369,  9660,  6271,  6123, 11572 
  5143,  1946,  2150,  2134,  2081, 11102,  8722, 11175, 11103,  8500,  8671 
  5144,  1097,  1091,  1400,    79,  3666,  9920, 11837,  3665,  3650, 11730 
  5145,  1157,    75,    68,  1094,  3864,  3110,  9867,  4479,  3657, 10827 
  5146,   247,  1820,  1777,   390,  7141,  7039,  6926,  9540,  9541,  9658 
  5147,  1240,  1565,   406,  1396, 11903,  5413,  9809,  9810,  5625,  4965 
  5148,  1660,  1183,  1287,  1304,  9675,  4433, 11376,  9993,  4571,  4573 
  5149,    74,    66,    67,  1397,  3107,  2184,  3108, 10187,  4969,  4970 
  5150,   415,   289,  1042,   416, 11977,  3500, 11381,  2569, 10752, 11656 
  5151,  1045,   293,   419,   292,  3510,  9656, 11281,  3509,  2442, 12020 
  5152,  1625,  1342,  1617,  1731,  9908, 11953,  6181,  6250, 11952,  6191 
  5153,  1946,  2150,  1977,  1978, 11102,  9236,  7952,  8005, 10780,  7677 
  5154,  2024,  2103,  1911,  1912, 10355,  9106,  7887,  7888, 11460,  7479 
  5155,  1984,  1985,  2153,   834,  7698, 10973, 10067, 11242, 10886,  8403 
  5156,  1818,   680,  1855,   622,  6971, 10719, 11252, 10884,  6732,  7193 
  5157,  1143,   980,   593,  1412,  3954, 11357, 12125, 10631, 11511,  5331 
  5158,  1973,  2148,  2079,   823,  9578,  8498,  9961, 12098,  8394,  8247 
  5159,   594,  1537,  1144,  1601,  5333, 10093, 10092,  5574,  5997, 11082 
  5160,   743,   823,  1973,   742,  8015, 12098,  7661,  2954,  8038,  7660 
  5161,  1856,  1818,  1775,  1855, 10882,  7054, 11345,  7197, 11252, 10717 
  5162,  1973,   743,  2148,   823,  7661,  9322,  9578, 12098,  8015,  8394 
  5163,   593,  1143,  1412,   592, 12125, 10631,  5331,  2768, 11026,  5330 
  5164,   766,   846,  2159,   845,  8107,  8415, 10916,  8106,  3058,  8416 
  5165,   824,   823,  2148,   743,  3036,  8394,  8393,  8016,  8015,  9322 
  5166,   833,   753,  1984,   754,  8150,  7693, 10671,  8151,  2965,  7694 
  5167,  1988,  1938,  2155,  1989,  8002, 10965, 10980,  7710,  7936, 11937 
  5168,  1291,  1565,  1621,  1395, 10497,  5714, 11899, 10498,  5592,  5715 
  5169,  1692,  1270,  1216,  1215, 10198,  4341, 10197, 12007,  4749,  4182 
  5170,  2057,   315,   441,  2128,  8202, 10792, 11662,  8478,  8351, 11727 
  5171,  1070,   317,   443,  1069,  3583,  9156, 11298,  3585,  3581,  9983 
  5172,   397,  1561,  1011,  1010,  5406, 11615,  9115,  9584,  9585,  3411 
  5173,  1313,  1195,  1690,  1746,  4602, 11981, 12075, 12076, 12002,  6275 
  5174,  1211,  1604,  1605,  1029, 12050,  5663, 11786,  4166, 11784, 11772 
  5175,  1984,   753,   833,  1983,  7693,  8150, 10671,  7695,  7691, 10682 
  5176,  2133,  2062,   451,   325,  8483,  9201,  9200,  8361,  8212, 10567 
  5177,   316,  1069,   443,   317,  3580,  9983,  9768,  2466,  3581,  9156 
  5178,   316,   317,   443,  2058,  2466,  9156,  9768,  8205,  8204,  9154 
  5179,   843,   764,  1994,  2158,  8050,  7724,  8816,  8414, 12126,  8818 
  5180,   844,   764,   843,  2158,  8103,  8050,  3056,  8413, 12126,  8414 
  5181,  2075,  2139,  2144,  1956,  8690,  8688,  8494, 11430, 11402, 10212 
  5182,  1702,  1631,  1236,  1429,  6048, 10664, 10663,  6034,  5758, 11479 
  5183,  1086,  1235,  1085,  1590,  4242,  4241,  3634, 10810, 11140,  8920 
  5184,  1119,   929,  1477,  1554,  3933, 10393,  8881,  8883, 10666,  5818 
  5185,   844,   764,  1995,   765,  8103,  7726, 11909,  8104,  2976,  7727 
  5186,  1173,  1736,  1657,  1679,  9528,  6198,  9022, 10935,  6201,  5917 
  5187,  1994,   764,  1995,  2158,  7724,  7726,  7728,  8818, 12126, 11351 
  5188,   639,   696,   697,  1784,  6758,  2904,  6761, 10397,  6853,  6852 
  5189,  1995,   764,   844,  2158,  7726,  8103, 11909, 11351, 12126,  8413 
  5190,   238,   237,  1803,   379,  2385,  6910,  6909, 11994,  8899, 11332 
  5191,  2155,  1938,  2087,  1989, 10965, 11920,  8565, 11937,  7936, 11857 
  5192,  2163,   775,   854,   853, 10047,  8055,  8423,  8424,  8052,  3066 
  5193,  1075,   918,  1422,  1113,  3997, 11170, 10321,  4225,  3882, 11737 
  5194,  1407,  1223,  1044,  1572, 10696,  4201, 11692,  5642, 12117, 11614 
  5195,   484,   483,   122,  1759,  2641,  6619,  6618,  5092,  5091, 10508 
  5196,   854,   775,  2006,   776,  8055,  7759, 11932,  8054,  2987,  7760 
  5197,   752,  1983,   832,   753,  7690, 10585,  8165,  2964,  7691,  8149 
  5198,  1795,   361,   360,  1894, 11836,  2513,  8892,  9297,  7327,  7326 
  5199,   344,  1363,   279,  1033,  4872, 11003,  4867, 11422, 11004,  3475 
  5200,  1797,  1840,  1898,  1837, 10456,  7323, 11421,  7103,  9501,  9621 
  5201,  1044,  1223,  1222,  1572,  4201,  4203,  4199, 11614, 12117, 11613 
  5202,   428,  1575,  1412,  1054,  5446,  5445,  5002, 11119, 10634, 10632 
  5203,   914,   913,  1277,  1455,  3707,  4383,  4382,  9185,  8752,  8887 
  5204,  1691,  1456,   914,  1455,  5949, 10376,  9184,  5948,  5505,  9185 
  5205,   894,  1443,  1225,  1444, 10115, 10114,  4207,  9101,  5075, 11974 
  5206,   342,   343,  1034,   280,  2494, 10720, 11157,  6266,  4709,  3478 
  5207,  1216,  1377,   992,  1270, 10195, 10713,  4337,  4341, 10196,  4338 
  5208,   758,  1989,  2155,   838,  7708, 11937, 11936,  8047,  9842,  8407 
  5209,  1038,  1403,   411,   412,  9461,  4984,  9933,  9431,  4983,  2565 
  5210,  1706,  1432,  1636,   895,  6050,  5775,  6051, 12066, 12119, 11863 
  5211,   286,   285,   411,  1038,  2435, 10349, 11721,  3490,  3489,  9933 
  5212,  2064,   328,   455,   329,  8217,  9042,  9793,  8216,  2478,  9040 
  5213,   455,   328,  2064,   454,  9042,  8217,  9793,  2608, 12049, 12084 
  5214,   454,   453,   327,  2134,  2607, 10971, 12127, 12062, 11853,  8363 
  5215,  2168,  1917,  2120,  2049, 11509, 11232,  8617,  8618, 10937,  8470 
  5216,  1928,   435,  2054,  1927,  7524, 11123, 10953,  7526,  7522, 10954 
  5217,  1625,  1407,  1572,  1223,  5722,  5642,  5723, 11443, 10696, 12117 
  5218,  1255,  1172,  1415,  1061,  4299,  8993,  8992,  4539,  4569,  9000 
  5219,  2105,  2173,  2027,   874,  8583,  8850,  8849,  8300,  8443, 10217 
  5220,  1170,  1227,  1653,  1069,  4391,  9515,  9513,  4409,  4217, 11299 
  5221,  1126,  1063,  1416,   944,  4216, 10849,  9014,  3892,  4051, 10534 
  5222,  2002,   850,   771,   772, 10116,  8140,  7747,  7748,  8112,  2983 
  5223,   454,  2134,   327,   328, 12062,  8363, 12127, 12049,  8362,  2477 
  5224,  2159,   846,   766,  1997,  8415,  8107, 10916, 10913, 11051,  7732 
  5225,  1987,  2154,   836,  2086,  9691,  8405, 11803,  9693,  8564,  8262 
  5226,  2106,  2174,  2029,   876,  8584, 11950, 10956,  8302,  8445, 10957 
  5227,  1073,  1072,  1421,  1248,  3594, 11673, 10673,  4538,  4659,  9301 
  5228,   454,   328,   327,  1080, 12049,  2477, 12127, 11384,  3614,  3613 
  5229,  1155,   456,   455,   329,  9590,  2609,  9552,  3857,  9591,  9040 
  5230,   331,  1081,   330,   457,  3619,  3618,  2480, 11901, 10737, 10738 
  5231,   331,   330,  2065,   457,  2480,  8219,  8218, 11901, 10738, 10057 
  5232,   331,   457,  1082,  1081, 11901, 12107,  3620,  3619, 10737,  3622 
  5233,   331,   332,   458,  2136,  2481, 10480, 10479,  8367,  8366, 10038 
  5234,   454,  1080,   327,   453, 11384,  3613, 12127,  2607, 11385, 10971 
  5235,  2141,  1960,  2072,  2073, 11629, 11420,  8491,  8724,  8917,  8725 
  5236,  1235,  1428,  1085,  1590,  9737,  8921,  4241, 11140,  5612,  8920 
  5237,  1856,  1775,   393,  1855, 11345, 11117,  7386,  7197, 10717,  7387 
  5238,   730,   731,  1961,   812,  2942,  7625,  7624,  8014,  8074,  9796 
  5239,  1057,  1413,  1288,  1185,  9563, 11826,  4446,  4213, 11292,  4445 
  5240,  1959,   809,  2179,   808,  7620, 10958,  9428,  7858,  3020,  9429 
  5241,  1084,  1589,   460,  1428,  9743,  5485,  9817,  9742,  5649,  5034 
  5242,  1531,   581,   209,   983,  5309,  6453, 11264,  9137,  9136,  3317 
  5243,  1326,   907,  1244,  1648,  4661,  4270,  4662, 11907, 11908, 11072 
  5244,  2079,  1950,  1973,  1972,  9962,  7957,  9961, 11044,  7958,  7662 
  5245,   505,   907,   110,   908, 11489,  3162,  6667,  9058,  3696,  3165 
  5246,  2179,   885,   809,   886,  8456,  8029, 10958,  8455,  3098,  8030 
  5247,  1244,   907,   906,  1648,  4270,  3695,  4271, 11072, 11908, 12040 
  5248,   408,  1401,    80,     2,  4980, 10063, 11702,  2561,  4977,  3120 
  5249,  1326,   907,  1467,  1245,  4661,  9055, 11906,  4686,  4273,  9053 
  5250,  1940,  2061,   448,  1941,  8743, 10320,  7561,  7565,  8745,  7563 
  5251,    83,   282,   408,  2180,  8169,  8988,  8987,  8459,  8314,  9723 
  5252,  1466,   907,  1467,  1648, 11812,  9055,  5511,  5807, 11908,  5808 
  5253,   408,  1091,    80,  1401, 12123,  3647, 11702,  4980,  9919, 10063 
  5254,  2155,  1989,  2087,   838, 11937, 11857,  8565,  8407,  9842,  8264 
  5255,   832,  2084,   833,  1983,  8258,  8257,  3045, 10585, 10586, 10682 
  5256,  1944,   451,   452,  2133,  7572,  2605,  7573,  9202,  9200,  9530 
  5257,   616,  1815,  1849,   674, 10591,  9517,  7175,  6798,  6963,  9518 
  5258,  2146,  1969,  1970,   820,  9046,  7653,  9996,  8389,  9494,  9971 
  5259,   338,   339,  1089,   465,  2488,  3642,  3641, 10838, 10259, 10502 
  5260,  1814,  1847,  1848,   614, 11014,  7173, 11015, 10455,  7169,  7171 
  5261,   950,  1256,  1493,  1227,  4301, 10908, 10907,  4414,  4416,  9575 
  5262,  1771,  1814,   400,   256,  7050, 11013, 11440,  6939,  7118, 11439 
  5263,  1178,  1517,  1683,   960, 10383,  5926, 10382,  4047,  9036,  9035 
  5264,   848,  2000,  1999,  2092, 12128,  7743, 11130,  8274, 10028, 11131 
  5265,  1089,   339,  1090,   465,  3642,  3644,  3646, 10502, 10259,  9805 
  5266,   895,  1432,  1636,  1433, 12119,  5775, 11863, 11864,  5493,  5776 
  5267,  1999,  2000,   848,   769,  7743, 12128, 11130,  7739,  7741,  8135 
  5268,   849,  2092,  2001,  2000,  8273, 11203,  8797, 12122, 10028,  7746 
  5269,   154,  1505,   554,   941, 10183,  5243,  6575,  3233, 10172, 10170 
  5270,  2094,  2004,  1926,  2005,  9664,  7913, 10248, 11142,  7758,  7998 
  5271,  2163,   853,  2094,  2005,  8424,  8277,  8513, 10045, 10046, 11142 
  5272,  2094,   853,   774,  2005,  8277,  8053,  9663, 11142, 10046,  7756 
  5273,   862,   784,  2014,  2015,  8156,  7784,  9739, 10127,  7786,  7788 
  5274,   770,   849,  2001,  2000,  8168,  8797,  7744,  7742, 12122,  7746 
  5275,   109,   907,   505,   504,  3163, 11489,  6668,  6665, 11813,  2665 
  5276,   849,  2000,   848,  2092, 12122, 12128,  3061,  8273, 10028,  8274 
  5277,  2100,   864,  2017,   787,  8290, 11925, 10700, 10701,  8120,  7793 
  5278,  1910,  2104,  2025,  2026,  9479, 11284,  7885,  7990, 11113,  7821 
  5279,  2168,   864,  2017,  2100,  8433, 11925, 11829,  8578,  8290, 10700 
  5280,  1789,  1800,  1881,  1830,  7091, 11159, 11086,  7071,  7092, 10798 
  5281,  1735,  1716,  1258,  1301,  6196, 10914, 11740, 11742, 10289,  4550 
  5282,   769,  2000,   848,   849,  7741, 12128,  8135,  8152, 12122,  3061 
  5283,  1222,  1572,  1698,  1406, 11613,  5881, 10363, 11611,  5596,  5882 
  5284,  1929,  2092,  2001,  2161,  9141, 11203,  7918,  9143,  8511, 11849 
  5285,  2168,  2016,  2017,   864,  9307,  7794, 11829,  8433, 10062, 11925 
  5286,   418,   292,  2116,   291,  9329,  8325,  9328, 11457,  2441,  8326 
  5287,   290,   291,   417,  2045,  2440, 11695, 10402,  8179,  8178, 10404 
  5288,   418,   292,   419,  2046,  9329, 12020,  2572,  9330,  8181,  9344 
  5289,  2097,  2011,   859,   780,  9889, 12129,  8283, 11842,  7774,  8117 
  5290,  1035,   409,   283,  1036,  8976, 12057,  3482,  3485, 11689,  3483 
  5291,  1081,  1426,  1588,  1278,  9803,  5610, 12106,  4472, 11238, 11239 
  5292,   807,  2037,   806,   883,  7853,  7852,  3018,  8070, 10034,  8071 
  5293,  2109,  2037,  2178,   883, 10033, 10162,  8528,  8307, 10034,  8454 
  5294,  1858,   391,  1819,  1777,  7383, 12048, 10081,  9686, 11833,  6972 
  5295,  1190,  1306,  1764,  1667,  4577,  9745,  9444, 10192,  9972,  6363 
  5296,  2041,   409,   408,  1901, 12056,  2562,  9722,  9718,  7447,  7446 
  5297,  2028,   797,   798,   875,  7825,  3009,  7826, 10236,  8129,  8136 
  5298,   925,  1278,  1249,  1644,  4385,  4384,  4284, 10022, 11240, 10021 
  5299,  1588,  1249,  1082,  1278, 11958,  4497, 11704, 11239,  4384,  4530 
  5300,   862,   863,   785,  2015,  3075,  8158,  8157, 10127, 10088,  7787 
  5301,  1081,  1278,  1588,  1082,  4472, 11239, 12106,  3622,  4530, 11704 
  5302,   230,  1788,   231,   372,  6901,  6900,  2378, 10601, 11729, 10600 
  5303,  2016,   786,   864,   863,  7790,  8137, 10062, 10061,  8159,  3076 
  5304,  1936,  2059,  2156,  2129, 12001,  8650, 10120, 10121,  8542,  8651 
  5305,  1801,   374,   232,  1829, 10856,  9098,  6904,  7136,  9097,  7140 
  5306,  1836,   361,  1795,  1894, 10834, 11836,  7081, 10844,  7327,  9297 
  5307,   447,  2060,  2131,  1939, 11755,  8481, 11753,  7558,  9682,  9687 
  5308,  1936,  2059,  1937,  2156, 12001,  9992,  7553, 10120,  8650,  9991 
  5309,   447,  2060,   320,   321, 11755,  8209, 11856, 11754,  8208,  2470 
  5310,  1961,  2074,  1962,  2040, 10030, 10029,  7629,  7976, 11022,  7987 
  5311,   364,  1793,  1834,  1889,  9800,  7008, 11018,  7334, 10225, 11016 
  5312,  1156,   467,   341,  1019, 10180,  9485,  3861,  3969,  9824,  3668 
  5313,   279,  1033,   278,   344,  3475,  3474,  2427,  4867, 11422,  4866 
  5314,  2072,  2071,   727,   888,  8377, 11931, 11715,  8234,  8231,  4797 
  5315,   345,   278,  1364,   344,  5103,  9968,  4875,  2496,  4866,  4874 
  5316,  1900,   887,   727,  2071, 11041,  4849,  7442, 11042,  8232, 11931 
  5317,   727,   887,   888,  2071,  4849,  3102,  4797, 11931,  8232,  8231 
  5318,  2072,   888,   727,   728,  8234,  4797, 11715, 11419,  4796,  2938 
  5319,  2134,  1946,  1947,   454, 11175,  7583, 12083, 12062,  7579,  7581 
  5320,  1979,  2151,  1980,  1945, 10085, 11056,  7683,  7950, 10086,  7948 
  5321,  2072,   889,   888,   728,  8233,  3103,  8234, 11419,  6376,  4796 
  5322,  1946,  2063,  2082,  1945, 10075,  8669,  9495,  7580,  9533,  9497 
  5323,   895,   896,  1636,  1290,  3678, 10311, 11863,  4451,  4453, 11002 
  5324,    95,   896,  1434,  1433,  3140, 10282, 10603, 11390, 10310,  5494 
  5325,  1071,   445,   444,   318,  9368,  2598, 11220,  3586, 10805, 11781 
  5326,  1893,   361,  1836,  1894,  7328, 10834,  9459,  7311,  7327, 10844 
  5327,  1987,  2086,   836,   757,  9693,  8262, 11803,  7703,  9872,  8094 
  5328,   110,   505,   109,   907,  6667,  6668,  2236,  3162, 11489,  3163 
  5329,   909,    42,   908,  1468, 10932,  9059,  3697, 11816,  5144,  9060 
  5330,  1988,  2086,   837,  2155, 10979,  8261, 10967, 10980,  8505,  8408 
  5331,  1002,  1384,  1003,  1292,  8848, 10304,  3839,  4460,  9999,  4461 
  5332,  1942,  2084,  2153,  2132, 10070,  8503, 10069, 10877,  8721,  8660 
  5333,  1552,  1326,  1467,  1649, 10470, 11906,  5984,  5967, 10467,  5809 
  5334,   220,  1795,  1836,   361,  6884,  7081,  7125, 10833, 11836, 10834 
  5335,  1423,   919,  1114,  1077, 12108,  3883,  9005, 11474,  4000,  3999 
  5336,  1423,   919,  1585,  1451, 12108,  8879,  5633,  5799, 10545,  5760 
  5337,  1930,  2126,  2055,   437,  8966,  8476, 11310,  7530, 11453, 11311 
  5338,   849,  2161,  2001,  2092,  8420, 11849,  8797,  8273,  8511, 11203 
  5339,   256,   255,  1772,   399,  2403,  6937,  6936,  9519, 10219,  9520 
  5340,  1585,   919,  1423,  1077,  8879, 12108,  5633,  8878,  4000, 11474 
  5341,   231,  1788,   373,   372,  6900,  9685, 10595, 10600, 11729,  2525 
  5342,  1123,  1279,   939,  1671,  4392,  4394,  3747, 11844, 11822, 11832 
  5343,   373,  1000,   231,   372, 11028,  3364, 10595,  2525,  9079, 10600 
  5344,   873,  2026,   795,  2104, 11108,  7819,  8125,  8297, 11113, 11757 
  5345,   373,  1788,  1880,   372,  9685, 10492,  7415,  2525, 11729,  7414 
  5346,   675,  1815,   616,   674,  6962, 10591,  6723,  2882,  6963,  6798 
  5347,  1118,   930,   139,   523,  3732,  3211,  3729, 11344, 11992,  6511 
  5348,   415,  2115,   289,   416, 10709,  8323, 11977,  2569, 10255, 10752 
  5349,  1407,  1664,  1573,  1224,  5972,  6013,  5597, 10695,  9128, 11586 
  5350,  2116,  1910,   418,   417, 10007,  7472,  9328, 10739,  7471,  2571 
  5351,   139,   930,   524,   523,  3211, 11651,  6513,  6511, 11992,  2687 
  5352,    59,  1539,   193,   596,  5337,  8812,  6484,  2772,  5338,  6485 
  5353,   859,  2011,   781,   780, 12129,  7775,  8118,  8117,  7774,  2992 
  5354,   554,   153,   154,   941,  6572,  2288,  6575, 10170,  3234,  3233 
  5355,  1312,  1685,  1287,  1615, 11820,  9936,  4772,  9346,  5975,  9345 
  5356,   876,  2029,   799,   798, 10957,  7829,  8161,  8160,  7828,  3010 
  5357,   440,   439,  2127,  1932,  2593,  9704,  9616,  7537,  7536,  9703 
  5358,  1504,  1656,   941,  1505,  5836, 10052, 10050,  5546,  5837, 10172 
  5359,  1312,  1300,  1672,  1615,  4694,  8927, 12061,  9346,  9347,  6217 
  5360,  2160,  1998,  2091,  1930,  9577,  9600,  8510,  8965,  7921,  8964 
  5361,   734,  2144,   815,   816, 10857,  8386,  8080,  8081,  8385,  3028 
  5362,  2160,  2092,  1999,  1930,  8570, 11131,  9576,  8965,  9555,  7999 
  5363,  1328,  1744,  1669,  1630,  9702,  6261,  9102,  9103,  6294,  5892 
  5364,   459,  1083,   333,   332, 11472,  3624,  9963,  9964,  3623,  2482 
  5365,   745,   825,   826,  2149,  8040,  3038,  8085, 10858,  8396,  8395 
  5366,  1085,   460,   334,   461,  9816, 10891,  3629,  8919,  2614,  8997 
  5367,  2097,  2166,   859,  2011,  8516,  8430,  8283,  9889,  9890, 12129 
  5368,  1166,  1293,  1701,  1175,  4494, 11047, 10252,  4375,  4492,  9827 
  5369,  1970,  1969,  2146,  1952,  7653,  9046,  9996,  7961,  7962,  8893 
  5370,  2065,  2079,  1973,  2148,  8677,  9961,  9959,  8728,  8498,  9578 
  5371,  2131,  2061,  1940,  2085,  8544,  8743, 11250,  8659,  8658,  8744 
  5372,   953,  1487,   169,  1131,  8914,  8928,  3258,  3772,  8930,  3773 
  5373,  1660,  1304,  1287,  1615,  9993,  4573, 11376,  6170,  9848,  9345 
  5374,  1287,  1685,  1660,  1615,  9936,  5981, 11376,  9345,  5975,  6170 
  5375,  1676,  1293,  1299,  1257,  8831,  4654,  8901,  8830,  4666,  4691 
  5376,  1676,  1709,  1277,  1293,  6312,  8888,  8900,  8831, 10318,  4601 
  5377,   311,  2126,   437,  2055,  8347, 11453,  8958,  8198,  8476, 11311 
  5378,  1625,  1664,  1345,  1754,  5973, 10238, 10250,  6387,  6386, 10237 
  5379,   986,  1527,   212,   578,  9639, 12065,  3323, 12024,  5298,  6450 
  5380,  1999,   769,   848,   768,  7739,  8135, 11130,  7738,  2980,  8111 
  5381,   391,   963,   248,  1135, 11447,  3401,  9561,  9150,  3949,  4473 
  5382,  2091,  1997,  2159,  1931, 11050, 10913,  8569,  9601,  7923, 11922 
  5383,   569,   963,   568,   182,  9782, 11211,  2740,  6429,  3278,  6430 
  5384,   859,  2166,   781,  2011,  8430, 11913,  8118, 12129,  9890,  7775 
  5385,  1195,  1754,  1311,  1182, 12003, 10251,  4596,  4120,  9380,  4595 
  5386,  1915,  2170,  2101,  2020, 10693,  8520,  9544,  7891, 11147,  9633 
  5387,  1057,   431,   430,   304,  9564,  2584,  9562,  3544, 11291, 11408 
  5388,  2009,  2096,   778,   857, 10960, 11462,  7768, 10923,  8281,  8072 
  5389,   979,  1142,  1053,  1411,  3955,  4070,  4079, 10744, 11372, 10981 
  5390,  1922,  2011,  1921,  2097,  7905,  7904,  7508, 11206,  9889,  9888 
  5391,  1914,  2170,  1915,  2020, 11198, 10693,  7487,  7890, 11147,  7891 
  5392,  2021,  2170,  1914,  2020, 10873, 11198,  7983,  7806, 11147,  7890 
  5393,   795,   872,  2025,   794,  8124, 11282,  7817,  3006,  8123,  7816 
  5394,  2021,  2170,  2102,  1914, 10873,  8580,  9001,  7983, 11198, 10589 
  5395,   424,  1410,  1051,  1050,  4998, 11326, 11905, 11199, 11200,  3528 
  5396,  1914,  2048,  2170,  2118, 10691,  8608, 11198, 10692,  8533,  8729 
  5397,  1625,  1311,  1746,  1754,  9907,  9905,  6334,  6387, 10251,  6306 
  5398,  1721,  1321,  1767,  1322, 12010, 10411,  6379, 11584,  4637, 11582 
  5399,  2035,  2108,   881,  2177, 11285,  8305, 10611,  9733,  8527,  8452 
  5400,   804,  2034,   881,  2035,  7844, 10774,  8133,  7846,  7848, 10611 
  5401,  1689,  1264,  1265,  1408,  9123,  4522, 11353,  5995, 11975, 11354 
  5402,  1603,  1721,  1213,  1212,  6135, 11714, 10285, 10284, 12012,  4173 
  5403,    78,  1096,    70,  1568,  3662, 10504,  3115,  9119,  9120,  5422 
  5404,  2071,  1960,  1900,  2040, 11608,  7866, 11042, 10946,  7975,  7974 
  5405,   792,   791,   869,  2022,  3003,  8024,  8025,  7808,  7807, 12130 
  5406,   890,   471,  1437,    86,  8954,  5051,  8953,  3128,  6600,  8963 
  5407,    77,  1399,    70,  1096, 10417,  4973,  3114,  3661,  9858, 10504 
  5408,   902,   512,   103,   511, 11621,  6688,  3152, 11320,  2673,  6689 
  5409,  1569,  1402,  1230,  1666,  5593, 11143, 11276,  5877,  5880,  9758 
  5410,  1613,  1739,  1764,  1323,  6223,  6402,  6364,  9447, 10740,  9446 
  5411,  1166,  1465,  1455,   913,  9940,  5137, 10892,  3990,  8750,  8752 
  5412,  1096,  1568,  1097,  1294,  9120,  9118,  3667,  4501, 10054,  4502 
  5413,   792,   869,  2171,  2022,  8025,  8440, 10809,  7808, 12130, 11209 
  5414,  2021,  2022,  2102,   791,  7809, 11765,  9001,  7805,  7807,  9003 
  5415,  1669,  1744,  1328,  1303,  6261,  9702,  9102, 10019, 10374,  4669 
  5416,   583,   985,  1533,  1532, 11084, 10260,  5313,  5312, 10678,  5316 
  5417,  1445,    14,   924,   923,  9342,  3197, 10510,  8736,  3194,  3724 
  5418,   985,   583,    29,   210, 11084,  6456,  3321,  3322,  6457,  2355 
  5419,   936,    17,    45,   937,  3223,  2788, 10223,  3744,  3226, 10346 
  5420,  1387,  1672,  1295,  1473,  6197, 11684, 11076,  5980,  5899, 11075 
  5421,  1145,   985,  1533,    29,  3912, 10260,  9391,  3823,  3321, 11109 
  5422,   934,    16,  1481,    44,  3220, 11514, 11333, 11024,  2787,  5183 
  5423,  1860,  1861,  1778,   685,  7212, 11223, 11935, 11591,  9378,  6841 
  5424,  1192,  1637,  1308,  1307,  8947, 11136,  4583,  4581, 11134,  4585 
  5425,  1867,   383,  1805,  1804,  7367, 10095, 10721,  9546,  9547,  7110 
  5426,   312,  1065,  1064,   438,  3568,  3570,  3566,  9384,  9133,  9131 
  5427,  1026,  1370,  1209,  1208, 11877, 11707,  4159,  4157, 11708,  4161 
  5428,   869,   791,  2102,  2022,  8024,  9003,  8293, 12130,  7807, 11765 
  5429,  1205,  1611,  1728,  1315, 11997,  6156, 11633,  4613, 11985,  9438 
  5430,   143,  1479,   144,   527, 11338,  9672,  2275,  6518,  5177,  6512 
  5431,  1203,  1204,  1612,  1021,  4146, 11416,  9726,  4143,  4144, 11636 
  5432,  1300,  1736,  1304,  1314, 12088,  9995,  4777,  4606, 11964,  4757 
  5433,   689,  1865,   631,  1864,  8758,  7222,  6800, 11065,  7224,  7220 
  5434,  1672,  1312,  1251,  1300, 12061,  4687,  8926,  8927,  4694,  4548 
  5435,  1205,  1611,  1022,  1373, 11997, 11998,  4147, 11127,  5679, 10742 
  5436,  1859,   626,  1860,  1820,  7205,  7207,  7209,  9659, 11228,  9545 
  5437,  1313,  1311,  1746,  1342,  4712,  9905, 12076,  4812,  4768,  9906 
  5438,  1240,  1092,   406,  1018,  4256,  9811,  9809,  4258,  3842, 10532 
  5439,   862,   861,  2014,   784,  3074, 11766,  9739,  8156,  8155,  7784 
  5440,  1191,  1546,  1637,  1667,  8946,  5778,  8945,  9973,  5885,  5887 
  5441,  1240,  1018,   406,  1565,  4258, 10532,  9809, 11903,  8784,  5413 
  5442,  2009,  2096,   857,  2165, 10960,  8281, 10923, 10924,  8515,  8428 
  5443,   263,  1810,   406,   262,  6951, 11307, 10362,  2410,  7045, 12118 
  5444,   430,  1056,  1057,   304, 11288,  3546,  9562, 11408,  3542,  3544 
  5445,  1154,  1017,   404,  1395,  3952,  9350,  9351, 10499,  9401,  4963 
  5446,  1009,   961,  1134,  1558,  4113,  3783,  4559,  9472,  9031,  9029 
  5447,   263,   262,   406,  1018,  2410, 12118, 10362,  3431,  3430, 10532 
  5448,  1743,  1637,  1667,  1307,  6251,  5887,  6252, 11135, 11134,  9974 
  5449,   932,  1479,   144,   143,  8754,  9672,  3215,  3216, 11338,  2275 
  5450,   261,   405,   404,  1809,  8799,  2557,  9349,  6946,  8800, 11273 
  5451,  1367,  1029,  1605,  1604, 10227, 11772,  5661,  5659, 11784,  5663 
  5452,   902,  1149,   371,   229,  3979, 11360, 11359,  3362,  3833, 11824 
  5453,  2171,   869,  2102,  2022,  8440,  8293,  8521, 11209, 12130, 11765 
  5454,  1107,  1165,  1650,  1551,  4364, 10103, 11520,  9093, 10102,  5964 
  5455,  1867,   384,  1805,   383,  7368, 10617, 10721,  7367,  2536, 10095 
  5456,  1031,  1366,  1603,  1030, 11855,  5656, 10988,  3470,  9988,  9987 
  5457,  2130,  1938,  2087,  2155, 10964, 11920,  8652,  8720, 10965,  8565 
  5458,  1013,   256,   257,   400,  3415,  2404,  3416, 11793, 11439, 11438 
  5459,  1393,  1198,  1197,  1617, 10608,  4128, 11720,  5694, 11792,  9422 
  5460,  1262,  1560,  1153,  1391, 12014,  9325,  4594, 11626,  5404,  9326 
  5461,  1367,   347,   275,  1366,  4883,  3951, 10226,  4885,  4881, 10228 
  5462,   254,  1773,   255,   398,  6933,  6935,  2402,  9114,  9315,  9223 
  5463,   802,  2107,   879,  2033, 10420,  8303,  8131,  7840, 10885,  9775 
  5464,  1817,   394,   252,   251, 11902, 12131,  7042,  6969, 12109,  2399 
  5465,  1404,  1040,  1220,  1194, 11550,  4192, 10446, 11547,  4107,  4193 
  5466,  1405,  1040,  1404,  1194, 10156, 11550,  5430,  9977,  4107, 11547 
  5467,  1339,  1627,  1220,  1194,  9911, 11544,  4818,  4785,  9978,  4193 
  5468,   217,   358,   991,   281, 11093, 10750,  3334,  3333, 10751,  3336 
  5469,  1353,  1748,  1753,  1355, 10100,  6339, 10427,  4821, 10097, 12132 
  5470,   432,  1414,  1059,  1058,  5006, 10386, 10016, 10017, 11570,  3552 
  5471,  1441,   475,   476,    90,  5063,  2631,  5064, 10055,  6608,  6609 
  5472,  1051,   977,  1600,  1141,  4067, 11362, 11139,  4066,  3908,  8761 
  5473,  1837,   218,   217,   358,  7023,  2365,  7020,  9500, 11179, 11093 
  5474,   897,    96,  1435,   898,  3142, 11392, 10325,  3680,  3145,  9654 
  5475,    96,     9,    37,  1435,  2221,  2796,  6591, 11392, 10257,  5048 
  5476,  2046,   292,   419,   293,  8181, 12020,  9344,  8180,  2442,  9656 
  5477,   977,   588,  1410,  1600, 11036,  5325, 11576, 11362,  5570,  5743 
  5478,   589,   588,   200,  1600,  2764,  6479,  6481,  5571,  5570,  8762 
  5479,   298,  1051,   425,   299,  3526, 11317, 11160,  2448,  3527, 11987 
  5480,  1354,  1353,  1753,  1355,  4811, 10427,  9909,  4822,  4821, 12132 
  5481,  1753,  1748,  1761,  1355,  6339,  6388,  6362, 12132, 10097, 11738 
  5482,   980,  1143,   593,   205,  3954, 12125, 11357,  3312,  3814,  6468 
  5483,  1354,  1753,  1761,  1355,  9909,  6362, 11216,  4822, 12132, 11738 
  5484,   346,   276,  1031,   277,  3737,  3468, 11854,  3736,  2425,  3469 
  5485,  1144,   981,  1601,  1699,  4058, 12115, 11082,  8910, 11924,  6011 
  5486,   435,   309,   308,  1061, 11124,  2458, 11122, 11698,  3557,  3556 
  5487,   981,  1538,   595,  1601, 12037,  5335, 12032, 12115,  5645,  5575 
  5488,  1792,  1887,  1888,   654,  9649,  7293,  9647,  9877,  7289,  7291 
  5489,   305,  1058,   432,   306,  3547, 10017, 10049,  2455,  3548, 10018 
  5490,  1548,  1193,  1616,  1380, 10551, 10539,  5701,  5638, 12035,  5824 
  5491,  1068,  1067,  1581,  1129,  3579, 11463,  9941,  4018,  4034, 10434 
  5492,  1885,   368,   369,  1832,  7342,  2521,  7343, 10570,  9386, 11892 
  5493,   436,  1062,   435,  1579, 11371, 11728,  2589,  5455,  8973,  5456 
  5494,  1066,  1418,  1128,  1580, 11458, 10900,  4031,  9089,  5747, 10623 
  5495,  1079,  1424,   921,  1115, 10579, 10129,  3992,  3993,  9512,  3930 
  5496,   498,   112,   113,  1461,  6651,  2240,  6654,  5124, 11672,  8905 
  5497,  1646,  1248,  1247,   915, 10476,  4496, 10483, 10475,  4282,  4279 
  5498,   499,  1461,   113,  1109,  5125,  8905,  6653, 11510, 11482,  3701 
  5499,  1365,   277,   345,   346, 11106,  4525,  4877,  4878,  3736,  2497 
  5500,  1459,   497,   909,    42,  5120, 10933, 11743,  5119,  2656, 10932 
  5501,  1236,  1237,  1702,  1429,  4249, 11722, 10663, 11479, 11807,  6034 
  5502,   338,   465,  2069,   339, 10838, 10764,  8227,  2488, 10259,  8226 
  5503,   447,  1073,  1584,  1074, 11605, 10672,  5470, 11603,  3597, 10060 
  5504,  1449,   917,  1274,  1458, 11465,  4359, 10426,  5508, 11878,  9298 
  5505,  1702,  1237,  1591,  1429, 11722, 11746,  6033,  6034, 11807,  5613 
  5506,  1943,  2152,  1981,  1982, 11049, 11592,  7946,  7945,  9930,  7689 
  5507,   276,  1030,   275,  1366,  3466,  3465,  2424, 11869,  9988, 10228 
  5508,   477,    91,  1442,   476,  6603, 11744,  5067,  2632,  6607,  5066 
  5509,  1821,   629,  1779,   687, 11079,  9317,  7075,  6978,  6744,  6843 
  5510,  1442,    91,  1100,  1441, 11744,  3673, 11557,  5068, 10056,  9463 
  5511,   395,   394,   252,  1817,  2547, 12131, 10817, 11811, 11902,  7042 
  5512,   334,   460,  2137,  2067, 10891, 10836,  8368,  8223, 11236,  8550 
  5513,   459,  1083,  1427,  1589, 11472,  8836,  5031,  5486,  8837,  5611 
  5514,    12,   913,    41,  1111,  3175,  8751,  2800,  3705,  3704,  8779 
  5515,    41,   503,    12,  1111,  2663,  6657,  2800,  8779,  8780,  3705 
  5516,   252,   394,  1152,   251, 12131, 11962,  3845,  2399, 12109,  3844 
  5517,  1152,   394,   252,   395, 11962, 12131,  3845, 10235,  2547, 10817 
  5518,  1951,  1952,  2078,  2066,  7598, 11666,  8747,  8749, 10822,  8681 
  5519,   761,  2088,   840,   841,  9179,  8266,  8017,  8018,  8265,  3053 
  5520,  1961,  1960,  2142,  2040,  7626, 11609,  9795,  7976,  7975, 10945 
  5521,  2032,  2107,   802,  2033, 11379, 10420,  7838,  7842, 10885,  7840 
  5522,  1673,  1300,  1251,  1252,  8925,  4548,  8924, 10629,  4547,  4511 
  5523,   934,    44,  1481,  1472, 11024,  5183, 11333, 11066,  5159,  5184 
  5524,   406,   405,  1018,   262,  2558,  8785, 10532, 12118,  8798,  3430 
  5525,  1284,  1301,  1716,  1711,  4551, 10289,  9694,  9695, 10290,  6244 
  5526,  1569,  1230,  1400,  1666, 11276, 11277,  5725,  5877,  9758,  5878 
  5527,  1009,  1388,  1269,  1008,  9537, 11501,  4600,  3396, 12030,  4599 
  5528,    74,  1094,    67,    75,  3656, 10826,  3108,  2194,  3657,  3109 
  5529,  1382,  1150,  1470,   373, 10276, 10278,  5156,  4930, 11027,  5693 
  5530,  1000,   904,  1382,  1150,  3987, 10275, 10299,  3838,  3983, 10276 
  5531,  1188,  1557,  1008,  1686, 11819,  9360,  4115,  9364,  6167,  9365 
  5532,  1382,   904,  1000,  1106, 10275,  3987, 10299, 10298,  3922,  3980 
  5533,   415,   288,   289,  2044, 11546,  2438, 11977, 10710,  8177,  8176 
  5534,   414,  2114,   288,  2044,  9196,  8320,  9195, 12133,  8531,  8177 
  5535,  1191,  1667,  1637,  1307,  9973,  5887,  8945,  4580,  9974, 11134 
  5536,   205,  1143,   593,   592,  3814, 12125,  6468,  6469, 11026,  2768 
  5537,  1167,  1117,  1155,  1587,  4356,  4374,  4116,  8740, 11502, 11329 
  5538,  1686,   387,  1008,  1388,  5581, 11881,  9365,  5582,  4945, 12030 
  5539,  1452,  1425,   454,  1080,  5477,  5028,  5478, 10775,  9913, 11384 
  5540,   245,  1008,  1388,  1009,  3392, 12030,  9535,  3394,  3396,  9537 
  5541,  1190,  1667,  1764,  1613, 10192,  6363,  9444,  9445,  6108,  6364 
  5542,   455,  1425,  1587,   922,  5027,  5609,  5482,  9041,  9914, 11503 
  5543,  1823,  1865,  1866,   632,  8757,  7227, 10906, 10651,  7223,  7225 
  5544,  1452,   453,  1079,  1080,  5479, 11492, 11330, 10775, 11385,  3615 
  5545,  1079,   453,   327,  1080, 11492, 10971,  3611,  3615, 11385,  3613 
  5546,  1587,  1117,  1453,  1454, 11502,  9189,  6064,  5762,  9181,  5110 
  5547,   132,  1117,  1453,   131,  3722,  9189,  9158,  2261,  3723,  9033 
  5548,  1907,  2114,   414,  2044, 11912,  9196,  7463, 11725,  8531, 12133 
  5549,   414,   288,   415,  2044,  9195, 11546,  2568, 12133,  8177, 10710 
  5550,  1907,   414,   415,  2044,  7463,  2568,  7464, 11725, 12133, 10710 
  5551,  1180,  1157,  1095,  1619,  4685,  3863,  4430, 10505, 10506, 10071 
  5552,   311,   310,   436,  1063,  2460,  9007,  8957,  3563,  3562,  8959 
  5553,  1139,  1534,   585,   196, 10562,  5321, 12016,  3807, 11214,  6460 
  5554,   975,   196,   584,  1534,  3301,  6461,  9738, 10565, 11214,  5318 
  5555,  1939,  2060,  2086,  1938,  9682,  8654,  9680,  7559, 11770, 10963 
  5556,   505,   907,  1467,   504, 11489,  9055,  5142,  2665, 11813,  5141 
  5557,   389,  1820,  1860,  1778,  9539,  9545,  7379, 11222,  7085, 11935 
  5558,  1044,  1406,  1222,  1043, 11612, 11611,  4199,  3508, 10730,  4198 
  5559,   231,   373,   232,  1150, 10595,  9096,  2379,  3835, 11027,  3836 
  5560,  1009,   245,   246,   388,  3394,  2393,  3395,  9176,  9536,  9174 
  5561,   305,   431,   432,  1058, 11290,  2585, 10049,  3547, 11967, 10017 
  5562,  1595,   107,   904,   516, 11783,  3156, 11431,  5517,  6676, 12039 
  5563,  1199,  1014,  1563,  1393,  4129, 11395, 12072, 10607, 12105,  5590 
  5564,  1595,   516,   904,  1470,  5517, 12039, 11431,  5651,  5155, 10277 
  5565,  1564,  1017,  1201,  1395,  9400,  4136, 10422,  5624,  9401, 10531 
  5566,   693,  1869,  1782,  1824,  9603,  9630,  6848,  6986,  9677,  7124 
  5567,  1022,  1204,  1612,  1611,  4145, 11416, 12043, 11998, 11630,  5684 
  5568,  1603,  1214,  1031,  1213, 11328,  4174, 10988, 10285,  4176,  4172 
  5569,  1320,  1755,  1352,  1351, 10194, 10200,  4801,  4799,  9231,  4803 
  5570,   199,   977,   200,   588,  3306,  3305,  2343,  6473, 11036,  6479 
  5571,  1866,   632,   691,  1823,  7225,  6751, 10905, 10906, 10651,  6982 
  5572,   928,  1161,  1717,   959,  3972, 11752,  8801,  3866,  3973,  8804 
  5573,  1119,  1554,  1475,  1161,  8883,  5903,  8885,  4010, 12041, 12067 
  5574,  2116,  2104,  2046,  1910,  8710,  8705,  8324, 10007,  9479,  9480 
  5575,  1475,  1554,  1717,  1161,  5903,  5382,  6121, 12067, 12041, 11752 
  5576,   559,    18,  1123,   151,  6585,  3748, 11096,  6583,  2285,  3751 
  5577,  1309,  1342,  1196,  1617,  4741,  4740,  4592, 10164, 11953, 11532 
  5578,  1232,  1303,  1280,  1633,  4564,  4563,  4542,  9609, 10020,  9608 
  5579,  1280,  1707,  1249,  1633, 11192, 11805,  4421,  9608,  6056,  9610 
  5580,   943,  1496,  1255,  1172, 11703,  8990,  4297,  4022,  8991,  4299 
  5581,   916,   917,  2182,  1458,  3710, 11993, 11321, 10430, 11878, 11323 
  5582,   916,    13,  2182,   917,  3180, 11858, 11321,  3710,  3183, 11993 
  5583,   917,  2182,  1449,    13, 11993, 11979, 11465,  3183, 11858, 10878 

** Names based on BC35111
*NSET,NSET=BC35111 
31, 
33, 
34, 
35, 
62, 
63, 
64, 
65, 
264, 
265, 
266, 
267, 
268, 
269, 
270, 
271, 
272, 
273, 
274, 
275, 
276, 
277, 
278, 
279, 
280, 
281, 
342, 
343, 
344, 
345, 
346, 
347, 
348, 
349, 
350, 
351, 
352, 
353, 
354, 
355, 
356, 
357, 
723, 
724, 
725, 
726, 
727, 
728, 
887, 
888, 
889, 
2412, 
2413, 
2414, 
2415, 
2416, 
2417, 
2418, 
2419, 
2420, 
2421, 
2422, 
2423, 
2424, 
2425, 
2426, 
2427, 
2428, 
2429, 
2430, 
2493, 
2494, 
2495, 
2496, 
2497, 
2498, 
2499, 
2500, 
2501, 
2502, 
2503, 
2504, 
2505, 
2506, 
2507, 
2508, 
2509, 
2871, 
2931, 
2932, 
2933, 
2934, 
2935, 
2936, 
2937, 
2938, 
2939, 
3100, 
3101, 
3102, 
3103, 
3104, 
3736, 
3737, 
3902, 
3946, 
3947, 
3950, 
3951, 
4465, 
4525, 
4526, 
4527, 
4627, 
4628, 
4708, 
4709, 
4795, 
4796, 
4797, 
4849, 
4851, 
4862, 
4863, 
4865, 
4866, 
4867, 
5103, 
5147, 
5148, 
5319, 
5320, 
5569, 
6266, 
6269, 
6289, 
6290, 
6320, 
6328, 
6329, 
6376, 
6377, 
6383, 
6389, 
6390, 
6391, 
6392, 
7440, 
8733, 
8734, 
** Names based on BC122222
*NSET,NSET=BC122222 
1, 
2, 
3, 
4, 
5, 
6, 
66, 
67, 
68, 
69, 
70, 
71, 
72, 
73, 
74, 
75, 
76, 
77, 
78, 
79, 
80, 
81, 
82, 
83, 
84, 
85, 
2183, 
2184, 
2185, 
2186, 
2187, 
2188, 
2189, 
2190, 
2191, 
2192, 
2193, 
2194, 
2195, 
2196, 
2197, 
2198, 
2199, 
2200, 
2201, 
2202, 
2203, 
2204, 
2205, 
2206, 
2207, 
2208, 
3105, 
3106, 
3107, 
3108, 
3109, 
3110, 
3111, 
3112, 
3113, 
3114, 
3115, 
3116, 
3117, 
3118, 
3119, 
3120, 
3121, 
3122, 
3123, 
3124, 
3125, 
3126, 
3127, 
