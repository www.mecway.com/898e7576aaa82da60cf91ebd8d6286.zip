  1773,   274,  1028,  1367,  1029,  3460, 11423, 11059,  3462,  3464, 10227 
  1774,   351,  1025,  1371,  1370, 11424, 11425,  4895,  4893, 11426,  4897 
  1775,  1551,   373,  1470,  1150,  5374,  5693,  5692, 11427, 11027, 10278 
  1776,  1024,  1023,  1372,  1206,  3449, 11407, 11428,  4151,  4150, 11429 
  1777,  1957,  2139,  2075,  1956, 10888,  8690, 10191,  7613, 11402, 11430 
  1778,  1803,   237,  1826,   379,  6910,  7036,  7035, 11332,  8899,  8898 
  1779,  1595,  1470,   904,  1107,  5651, 10277, 11431,  9094,  9434,  3876 
  1780,  1532,  1663,  1267,  1710,  5867, 11432, 10679,  6079,  6078, 10680 
  1781,   403,  1017,  1016,  1564, 11433,  3429,  9283,  5412,  9400,  9284 
  1782,  1045,  1407,   419,  1573, 10694,  4991, 11281, 11434,  5597,  5436 
  1783,  1042,  1272,  1405,  1571,  4351,  9975, 11383, 11435, 11436,  5595 
  1784,  1407,  1223,  1345,  1224, 10696,  4641, 11437, 10695,  4206,  4784 
  1785,   400,   256,   257,  1771, 11439,  2404, 11438, 11440,  6939,  6938 
  1786,   958,   959,  1675,  1260,  3781,  8805, 11441,  4310,  4309,  8808 
  1787,  1625,  1223,  1222,  1342, 11443,  4203, 11442,  9908,  4755,  4742 
  1788,   965,  1520,  1519,   394,  9253,  5285,  8772, 11444,  5704,  5398 
  1789,   260,  1017,  1016,   403,  3427,  3429,  3425, 11445, 11433,  9283 
  1790,   392,   963,   249,   391,  9168,  3402,  9167,  2544, 11447, 11446 
  1791,   572,   186,   187,  1520,  6435,  2326,  6425,  5283,  9252, 11448 
  1792,  1701,  1652,  1464,   912,  6026,  5894,  6027, 11324,  9832,  9835 
  1793,  1853,   396,  1816,  1774,  7392,  9138,  9139, 11449, 10814,  7068 
  1794,   386,   385,  1387,  1007,  2538,  4943,  4942,  9359, 11268,  9820 
  1795,   606,  1841,  1838,  1768, 10181, 10208,  7123,  6950, 11387,  7122 
  1796,   983,  1531,  1530,  1682,  9137,  5563,  9135, 11450,  5925,  5924 
  1797,   953,  1275,  1488,  1652,  4410, 11165,  8913, 11451,  9833,  5823 
  1798,   404,  1017,   260,   403,  9350,  3427, 10167,  2556, 11433, 11445 
  1799,   670,  1813,  1845,  1770,  6959, 11186, 11452,  6824,  7049, 10582 
  1800,  1126,  1597,   157,  1498,  9015, 11205,  3759,  9016,  5829, 11204 
  1801,  2126,   438,   437,  1930,  9383,  2591, 11453,  8966,  7531,  7530 
  1802,  1537,  1055,   980,  1144, 11454,  4061, 10779, 10093,  4078,  3911 
  1803,   429,  1576,  1056,  1055,  5450,  9734, 10327, 10328, 11455,  3543 
  1804,  1537,  1576,   429,  1055,  5993,  5450,  5884, 11454, 11455, 10328 
  1805,  1537,  1055,  1144,  1576, 11454,  4078, 10093,  5993, 11455,  8909 
  1806,   418,   291,  1044,   292, 11457,  3506, 11456,  9329,  2441,  3507 
  1807,  1418,  1066,  1128,  1067, 11458,  4031, 10900, 10899,  3576,  4038 
  1808,   931,   141,   526,   142,  3213,  6516,  9477,  3212,  2273,  6520 
  1809,  2024,  1912,  2023,  2103,  7888,  7879,  7815, 10355, 11460, 11459 
  1810,  1385,   138,  1477,   522, 10394, 10392,  6224,  5173,  6510,  5171 
  1811,  1144,  1055,  1056,  1576,  4078,  3543,  4211,  8909, 11455,  9734 
  1812,  1143,  1575,   979,  1054, 10633, 10558,  3910,  4074, 10634,  4075 
  1813,  1267,  1663,  1705,  1710, 11432,  6043, 11461, 10680,  6078,  6081 
  1814,  1266,  1531,   983,  1682,  9869,  9137,  4327,  9868,  5925, 11450 
  1815,  2157,  1935,  2058,  2128, 10126,  9160,  8646,  8647,  9604,  8541 
  1816,   851,  2162,  2003,  2093,  8422, 11088,  9873,  8275,  8512,  9875 
  1817,   778,   856,   857,  2096,  8057,  3069,  8072, 11462,  8282,  8281 
  1818,  1581,  1129,  1067,  1418, 10434,  4034, 11463,  5603,  9937, 10899 
  1819,  1468,  1245,   907,   908,  9052,  4273,  9054,  9060,  4272,  3696 
  1820,  1930,  1929,  2055,  2092,  7532,  9142, 11310,  9555,  9141,  8637 
  1821,   158,   157,  1126,  1597,  2293,  3759,  3758, 11202, 11205,  9015 
  1822,   151,   559,   558,  1511,  6583,  2728,  6584, 11097,  5258,  5257 
  1823,   155,   542,   943,  1125,  6547,  8961,  3237,  3757, 11464,  3891 
  1824,  1449,  1450,   917,   121,  5090, 11466, 11465, 11411, 11467,  3182 
  1825,  1501,  1129,   164,   948, 10157,  3764,  8875,  8876,  3938,  3248 
  1826,   961,  1558,   389,  1389,  9031,  5393,  9471, 10485,  5392,  4947 
  1827,  1580,  1066,   946,  1128,  9089,  4032,  9088, 10623,  4031,  3894 
  1828,  1488,  1132,   953,   170, 11166,  3897,  8913, 10356,  3775,  3257 
  1829,  1368,   273,   274,   348,  9163,  2422, 10481,  4886,  3947,  3946 
  1830,   946,  1127,  1065,  1417,  3940,  4037,  4036,  9090,  9144,  9134 
  1831,  1946,  1979,  2082,  1978,  7951,  9496,  9495,  8005,  7680, 11234 
  1832,   507,  1102,    98,   900, 11468,  3682,  6673, 11469,  3926,  3149 
  1833,    98,   508,   507,   900,  6677,  2669,  6673,  3149, 11368, 11469 
  1834,  1819,  1807,   392,  1857,  7040,  8937, 11470, 10082,  8939,  7431 
  1835,   624,   682,   683,  1858,  6736,  2890,  6739,  7201, 10083,  9399 
  1836,  1423,   486,   487,  1114,  5096,  2644,  5097,  9005,  9006, 11471 
  1837,  1386,  1168,  1481,  1281, 11244, 11245,  6260,  9950,  4438, 11334 
  1838,  1585,  1113,  1451,   919, 10803, 10802,  5760,  8879,  3932, 10545 
  1839,  1381,  1102,   507,   900,  9481, 11468,  5965,  9483,  3926, 11469 
  1840,  1918,  2167,  2120,  1919,  9319,  8620,  9327,  7499,  9404, 10754 
  1841,  1425,   922,   454,  1080,  9914, 11180,  5028,  9913,  3856, 11384 
  1842,   333,  1083,   459,  1084,  3624, 11472,  9963,  3626,  3628, 11174 
  1843,   477,  1442,  1101,  1443,  5067, 11314, 11313,  5069,  5071, 10113 
  1844,  1078,  1077,  1423,  1114,  3609, 11474, 11473,  4005,  3999,  9005 
  1845,  1640,  1738,  1159,  1641,  6211, 11476, 11475,  5789,  6212, 11477 
  1846,  1591,  1088,   463,  1087, 10943, 11478,  5490, 11306,  3640, 10495 
  1847,   979,   203,   591,   204,  3310,  6475, 10556,  3309,  2347,  6478 
  1848,  1236,  1590,  1086,  1429, 11141, 10810,  4244, 11479,  5634, 10811 
  1849,  1100,  1242,  1642,  1641,  4263,  9304,  9464,  9465, 10189,  5792 
  1850,  1536,   589,   978,  1600,  5326, 11480, 10343,  5622,  5571, 10341 
  1851,   340,  2140,   466,   339,  8374, 10757,  9808,  2489,  8375,  9812 
  1852,  1882,  1831,   370,  1800, 11145, 11481,  7346,  9786,  7030,  9788 
  1853,   507,   508,  1381,   900,  2669,  5689,  5965, 11469, 11368,  9483 
  1854,  1284,  1711,  1491,   955,  9695,  6087,  9696,  4419, 10286, 10287 
  1855,    68,  1567,    76,  1157,  5420,  9851,  3111,  9867,  9853,  3862 
  1856,   337,   336,   463,  1087,  2486, 10840, 10820,  3636,  3635, 10495 
  1857,  1461,  1647,  1109,  1462,  5806, 11483, 11482,  5129,  6065,  9917 
  1858,  1738,  1737,  1640,  1327,  6213,  6209,  6211, 11484, 10317, 11485 
  1859,  1649,  1245,  1467,  1468, 10468,  9053,  5809,  5810,  9052,  5512 
  1860,  1282,  1003,  1004,  1553,  4703,  3374,  4505, 11486, 11487,  8795 
  1861,   526,  1478,   931,   143,  5175,  9815,  9477,  6519, 10602,  3214 
  1862,  2003,   773,   851,   772,  7751,  8114,  9873,  7750,  2984,  8113 
  1863,   215,  1524,   216,   577,  8936,  9644,  2362,  6441,  5293,  6444 
  1864,  1662,  1179,  1110,  1275, 10150,  4377, 11488, 10364,  4417,  4367 
  1865,   505,   907,   908,  1468, 11489,  3696,  9058,  5143,  9054,  9060 
  1866,  2141,   889,  2072,   728,  8379,  8233,  8491, 11490,  6376, 11419 
  1867,  1015,   401,  1014,   258, 11394, 11396,  3423,  3421,  9527,  3419 
  1868,  1812,   669,   668,   610,  6956,  2876,  6957, 11107,  6713,  6710 
  1869,   408,    85,    83,  2180,  7445,  3125,  8987,  9723, 11348,  8459 
  1870,  1108,   497,   498,   112, 10366,  2657, 10936,  3698,  6652,  6651 
  1871,   117,  1464,   116,   912, 11171, 11491,  2244,  3172,  9835,  3173 
  1872,  1424,   452,  1079,   453,  5026, 10893, 10579,  5025,  2606, 11492 
  1873,   182,  1135,   568,   181,  3787,  9148,  6430,  2321,  3788,  6427 
  1874,   249,   392,  1819,  1807,  9167, 11470,  7041,  6928,  8937,  7040 
  1875,  1709,  1293,  1676,  1677, 10318,  8831,  6312,  6313,  8833,  6109 
  1876,  1467,   907,   505,  1468,  9055, 11489,  5142,  5512,  9054,  5143 
  1877,  1174,  1276,  1647,  1176,  4574, 10294, 10301,  4408,  4537, 11493 
  1878,  1425,   130,   131,   922, 10488,  2260, 11494,  9914,  3193,  3192 
  1879,   936,   519,   935,  1474, 11495, 11496,  3743, 10549,  5163, 10550 
  1880,   998,   226,   367,   225,  3355, 11497,  9661,  3354,  2373, 11498 
  1881,   987,  1147,  1529,  1712,  3914, 11133, 10462, 10123, 11499,  6094 
  1882,  1269,  1719,  1686,  1388, 11500,  6263,  9363, 11501,  6264,  5582 
  1883,  1587,  1117,  1155,   922, 11502,  4374, 11329, 11503,  3886,  4226 
  1884,  1480,   933,  1168,  1121, 11340,  4011, 11243, 11504,  3935,  4012 
  1885,  1503,   940,   939,   152, 11506,  3752, 11505, 11507,  3232,  3229 
  1886,  1705,  1663,  1267,  1226,  6043, 11432, 11461, 10380, 10381,  4568 
  1887,   367,   366,   998,   225,  2519,  9662,  9661, 11498, 11233,  3354 
  1888,  1587,  1425,  1453,   922,  5609,  6072,  6064, 11503,  9914, 11508 
  1889,  1662,  1488,  1596,  1132,  5865,  5821,  5861, 10151, 11166, 10141 
  1890,  1866,  1781,   691,   633, 10722,  6847, 10905,  7226,  9375,  6750 
  1891,  2168,  2016,  1918,  1917,  9307,  7897,  9306, 11509,  7896,  7496 
  1892,   499,   113,   114,  1109,  6653,  2241,  6663, 11510,  3701,  3700 
  1893,  2013,   861,   782,   783, 10042,  8154,  7780,  7781,  8166,  2994 
  1894,  1529,  1528,   213,   987,  5306,  9049,  9157, 10462,  9048,  3326 
  1895,  1453,  1117,  1587,   922,  9189, 11502,  6064, 11508,  3886, 11503 
  1896,  1453,  1425,   131,   922,  6072, 11494,  9033, 11508,  9914,  3192 
  1897,   131,  1117,  1453,   922,  3723,  9189,  9033,  3192,  3886, 11508 
  1898,  1660,  1523,  1685,   988,  5853,  5930,  5981, 11377,  9348,  9339 
  1899,   980,  1537,   206,   593, 10779, 10094,  3311, 11357,  5332,  6463 
  1900,  1480,   933,  1121,   145, 11340,  3935, 11504, 11335,  3218,  3739 
  1901,  2142,   812,  1961,  2074,  8381,  9796,  9795,  8592,  8238, 10030 
  1902,   912,  1275,  1463,  1110,  4366,  9831,  9830,  3927,  4367,  8906 
  1903,  1412,  1143,   980,  1055, 10631,  3954, 11511, 11512,  4062,  4061 
  1904,  1055,  1054,  1412,  1143,  3540, 10632, 11512,  4062,  4074, 10631 
  1905,  1575,   427,  1053,  1054,  5447,  9882, 10982, 10634, 11120,  3537 
  1906,  2157,  1993,  1934,  2089, 10783,  7930, 11513,  8567, 11105, 10760 
  1907,  2098,  1919,  2013,  1920,  8970,  7900, 10040,  8971,  7502,  7901 
  1908,   301,   427,  1053,   300,  9205,  9882,  3533,  2450,  9206,  3532 
  1909,  1480,  1121,  1168,  1386, 11504,  4012, 11243,  6259, 10594, 11244 
  1910,  1566,  1623,  1217,  1402,  5718,  9754,  9753,  5416,  5719, 11278 
  1911,  1157,  1567,  1095,  1619,  9853,  9852,  3863, 10506,  5711, 10071 
  1912,     3,   263,   407,  1092,  4265,  8777,  8776,  3651,  3843,  8790 
  1913,   220,   361,   994,   993, 10833, 10746,  3342,  3340, 10432,  3344 
  1914,   404,   405,  1154,  1395,  2557,  8783,  9351,  4963,  4962, 10499 
  1915,   716,  1892,  1794,   717,  9570,  9571,  6873,  2924,  9312,  6872 
  1916,   529,    16,    44,  1481,  6501,  2787,  2693,  5182, 11514,  5183 
  1917,  2032,   878,   802,  2107, 11150,  8130,  7838, 11379,  8304, 10420 
  1918,   404,  1017,   403,  1564,  9350, 11433,  2556,  5411,  9400,  5412 
  1919,  1012,   399,  1013,  1562,  9397, 11515,  3417,  9395,  5408, 11516 
  1920,   934,   933,  1481,    16,  3741, 11341, 11333,  3220,  3217, 11514 
  1921,   404,   260,   261,  1811, 10167,  2408,  9349, 11272,  6955,  7044 
  1922,   905,  1471,  1650,  1466,  9084,  5811, 11517, 10144,  5516,  5812 
  1923,   905,  1466,  1650,   906, 10144,  5812, 11517,  3694, 11519, 11518 
  1924,  1107,  1551,  1650,  1471,  9093,  5964, 11520,  9092,  5774,  5811 
  1925,  1107,  1471,  1650,   905,  9092,  5811, 11520,  3921,  9084, 11517 
  1926,  1559,   185,  1519,   964, 10996, 11521,  5282, 10419,  3279,  8771 
  1927,   905,   906,  1650,  1165,  3694, 11518, 11517,  3989,  3988, 10103 
  1928,  1107,   905,  1650,  1165,  3921, 11517, 11520,  4364,  3989, 10103 
  1929,  1647,  1645,  1176,  1462,  6066,  9772, 11493,  6065,  6067, 11522 
  1930,  1543,   599,    25,    53,  5346,  6491,  9979,  5345,  2776,  2780 
  1931,   538,   537,   173,  1490,  2703,  6538,  6537,  5205,  5204, 10425 
  1932,   899,     9,    37,   506,  3147,  2796, 10535, 11523,  6669,  2667 
  1933,   250,   392,   249,  1807, 10335,  9167,  2397,  6927,  8937,  6928 
  1934,   243,  1007,   386,   244,  3388,  9359, 11246,  2391,  3389, 10494 
  1935,   452,   451,  1586,  1078,  2605,  5475,  5474, 10894, 11524,  8984 
  1936,  1187,  1657,  1509,  1173,  9153,  5841,  9151,  4558,  9022,  9020 
  1937,   690,   632,  1823,   691,  6748, 10651,  6845,  2898,  6751,  6982 
  1938,  1822,  1864,   689,   630,  8768, 11065,  6980, 11525,  7219,  6810 
  1939,  2171,  1912,  1913,  2117, 11266,  7863, 11265,  8702, 11527, 11526 
  1940,  1779,  1806,  1862,  1821,  7083,  9336, 11528,  7075,  7084, 11529 
  1941,    44,   934,   518,  1472, 11024, 11023,  2680,  5159, 11066,  5160 
  1942,  1713,  1187,  1173,  1657, 11196,  4558,  9529,  6101,  9153,  9022 
  1943,  1658,  1187,  1713,  1657,  9152, 11196,  6098,  5844,  9153,  6101 
  1944,  1831,  1883,   369,  1790, 11219,  7344, 11530,  7001, 11531, 11309 
  1945,   366,   225,   367,  1799, 11233, 11498,  2519,  9286,  6891,  9285 
  1946,  1196,  1197,  1617,  1392,  4125,  9422, 11532, 11533,  9424,  5706 
  1947,   714,   713,  1889,   655,  2921, 11534,  9568,  6785,  6782,  7294 
  1948,  1012,  1197,  1196,  1392,  4123,  4125,  4122,  9396,  9424, 11533 
  1949,  1562,  1197,  1012,  1392,  9423,  4123,  9395,  5589,  9424,  9396 
  1950,  1126,  1498,   157,   944,  9016, 11204,  3759,  3892, 11535,  3239 
  1951,   931,   239,   240,   382,  3382,  2387,  3383,  9220, 11536,  9670 
  1952,  1236,  1429,  1086,  1087, 11479, 10811,  4244,  4245, 10496,  3637 
  1953,   156,  1498,  1497,   944, 11538,  5226, 11537,  3240, 11535, 10533 
  1954,  1341,  1163,  1706,  1290,  4762, 11177, 11000,  4738,  4452, 11001 
  1955,  1148,  1694,  1189,  1243, 10438,  9549,  4094,  4455, 10239,  4508 
  1956,   898,     9,    96,  1435,  3144,  2221,  3145,  9654, 10257, 11392 
  1957,  1125,   156,  1497,   944,  3756, 11537, 11539,  3942,  3240, 10533 
  1958,  1207,  1371,  1024,  1025, 11540, 10174,  4153,  4154, 11425,  3452 
  1959,    89,   475,  1440,    90,  6605,  5061,  8822,  2213,  6608, 11541 
  1960,  1201,  1200,  1394,  1620,  4138,  9727, 10590,  9257,  9258,  5713 
  1961,   157,  1498,   156,   944, 11204, 11538,  2292,  3239, 11535,  3240 
  1962,  1812,  1844,  1843,  1769,  9712,  7161, 11542,  7048, 10464, 10465 
  1963,  1174,  1711,  1284,   955, 10302,  9695,  4420,  4025, 10286,  4419 
  1964,  1346,  1756,  1350,  1351, 11052, 10440,  4853,  4854,  9230,  4800 
  1965,   626,   684,   685,  1820,  6740,  2892,  6812, 11228,  6977,  6976 
  1966,  2076,  2144,  1965,   816,  8554, 10211, 10377,  8242,  8385, 11543 
  1967,  1404,  1220,  1628,  1627, 10446,  9261,  5735,  5733, 11544,  5738 
  1968,   414,  1041,   415,   288, 11545, 11382,  2568,  9195,  3498, 11546 
  1969,  1958,  2143,  2069,  2140, 10948,  8629, 11039, 10119,  8691,  8490 
  1970,   367,  1791,  1799,   225, 10552,  7028,  9285, 11498,  6894,  6891 
  1971,  1404,  1627,  1405,  1194,  5733,  5732,  5430, 11547,  9978,  9977 
  1972,  1220,  1627,  1404,  1194, 11544,  5733, 10446,  4193,  9978, 11547 
  1973,  1983,  2084,  1942,  1982, 10586, 10070,  8004,  7692,  9932,  7944 
  1974,  1159,  1327,  1640,  1231,  4663, 11485, 11475,  4232,  4664,  9466 
  1975,   226,  1791,   367,   225,  6893, 10552, 11497,  2373,  6894, 11498 
  1976,  1519,   964,   393,  1559,  8771,  8769,  5399,  5282, 10419,  5396 
  1977,  1880,  1829,   373,  1879, 10596,  9095,  7415,  7269, 10890,  7350 
  1978,  1060,   307,   308,   434,  3553,  2457,  3554,  9902,  9903, 11548 
  1979,  1640,   892,  1099,  1439,  8862,  3859, 11549,  5784,  8872,  9956 
  1980,  1404,  1040,   413,  1039, 11550, 11551,  4986, 10448,  3497, 11552 
  1981,   892,  1159,  1640,  1231,  3968, 11475,  8862,  4230,  4232,  9466 
  1982,   991,  1216,   359,   992,  4312, 10861, 10587,  3830,  4337,  9288 
  1983,  1344,  1160,  1752,  1340,  4763, 11553, 10262,  4770,  4735, 10266 
  1984,  1075,  1422,   448,   449, 10321,  5022, 10866, 10868,  5021,  2602 
  1985,   125,   486,   124,  1451,  6637,  6630,  2254,  9010,  5095, 11554 
  1986,  1112,  1422,  1075,   918, 10322, 10321,  3998,  3713, 11170,  3997 
  1987,  1151,   383,  1386,  1479, 11555,  4941, 10593,  8753,  5977,  5976 
  1988,  1344,  1160,  1242,  1751,  4763,  4264,  4764, 10264, 11556, 10190 
  1989,   458,  2136,  1951,  1950, 10038, 11347,  7593,  7591, 10037,  7595 
  1990,  1970,  2078,   740,  1971,  9970,  9969,  7652,  7656, 11037,  7654 
  1991,   370,  1831,  1882,  1883, 11481, 11145,  7346,  7345, 11219,  7278 
  1992,  1442,  1642,  1100,   893,  5791,  9464, 11557, 11558,  9305,  3865 
  1993,  1346,  1347,  1357,  1765,  4782,  4835,  4834, 11053, 11559, 10338 
  1994,   773,   852,   774,  2004,  8115,  8116,  2985,  7753,  9665,  7754 
  1995,   843,   764,   763,  1994,  8050,  2975,  8051,  8816,  7724,  7723 
  1996,   188,   574,  1136,   966,  6414, 11560,  3791,  3284, 11561,  3945 
  1997,  1678,  1285,  1261,  1718, 10584,  4441,  9747,  6125, 11563, 11562 
  1998,  1513,  1718,  1521,  1285,  6124,  6123,  5550, 11564, 11563, 11565 
  1999,  1404,   413,  1570,  1039,  4986,  5428,  5643, 10448, 11552, 10449 
  2000,  1899,  1842,   405,  1809,  7418,  7409,  7435, 10528, 11274,  8800 
  2001,  1530,   982,   983,  1682, 10142,  3819,  9135,  5924, 11566, 11450 
  2002,  1977,  2081,   827,  2150, 10950,  8251,  9235,  9236,  8500,  8398 
  2003,  1710,  1705,  1334,  1741,  6081, 11568, 11567,  6300,  6230, 11569 
  2004,  1059,  1058,  1414,  1226,  3552, 11570, 10386,  4215,  4214, 10379 
  2005,  1390,  1521,  1177,   966,  6271, 11572,  9660, 11571,  9958,  4044 
  2006,   421,  1047,   294,   420, 11573,  3515,  9393,  2574,  8943,  9125 
  2007,  1177,  1136,  1390,   966,  4045,  9270,  9660,  4044,  3945, 11571 
  2008,   446,  1073,   320,  1072, 11574,  3592, 10851, 10852,  3594,  3590 
  2009,   587,  1410,  1140,   977,  5324, 11575, 10703, 11035, 11576,  3957 
  2010,  1584,  1422,   448,  1074,  5632,  5022,  5469, 10060, 10323, 10880 
  2011,   587,  1140,   199,   977, 10703,  3808,  6474, 11035,  3957,  3306 
  2012,  1110,  1179,  1594,   911,  4377, 10928,  8908,  3879,  4378, 10135 
  2013,  2085,  1985,  2153,  1941, 10897, 10973,  8563,  8746,  7941, 10872 
  2014,  1676,  1257,  1654,  1494,  8830, 11577,  6085,  5908,  9217,  5828 
  2015,   912,  1652,  1275,  1175,  9832,  9833,  4366,  4376,  9829,  4411 
  2016,  2028,  2027,  2105,  1909,  7827,  8849, 10224,  7882,  7883,  8851 
  2017,  1500,  1128,   947,  1418, 11197,  3939, 10619,  5813, 10900,  9938 
  2018,  1841,  1842,  1768,   608,  7155, 10065, 11387,  7152,  7153, 10064 
  2019,   840,   761,   760,  1991,  8017,  2972,  8048,  9177,  7715,  7714 
  2020,  1293,  1677,  1701,  1175,  8833,  6354, 11047,  4492, 11578,  9827 
  2021,  1487,  1175,   953,  1652,  9828,  4039,  8914,  5822,  9829, 11451 
  2022,  1662,  1652,  1488,  1275,  6030,  5823,  5865, 10364,  9833, 11165 
  2023,  1133,  1490,  1489,  1740, 10424,  5206, 10408, 10636,  6226,  6240 
  2024,   810,    64,  2141,   729,  8010, 11579,  8380,  8011,  2940, 11580 
  2025,  1841,  1899,  1768,  1842,  7419, 11386, 11387,  7155,  7418, 10065 
  2026,  1911,  2046,   419,  1912,  9107,  9344,  7475,  7479, 11581,  7477 
  2027,  2027,   874,   796,   797, 10217,  8127,  7822,  7823,  8128,  3008 
  2028,  1767,  1322,  1739,  1721, 11582, 11583,  6382,  6379, 11584,  6222 
  2029,   297,  1050,  1049,   423,  3523,  3525,  3522,  9064, 10025, 11365 
  2030,  1687,  1754,  1665,  1182,  6305,  6304,  5937,  9381,  9380, 11585 
  2031,  1046,  1224,  1573,  1264,  4205, 11586,  8940,  4481,  4480, 11587 
  2032,  2147,   821,   741,   822,  8392,  8084, 10520,  8391,  3034,  8037 
  2033,  1050,  1140,  1410,   977,  4073, 11575, 11200,  4072,  3957, 11576 
  2034,  1713,  1736,  1173,  1186,  6199,  9528,  9529, 10124, 11588,  4660 
  2035,  1045,  1407,  1573,  1224, 10694,  5597, 11434,  4204, 10695, 11586 
  2036,  1297,  1314,  1679,  1252,  4604, 11589, 10767,  4536,  4605, 11590 
  2037,  1860,   626,   685,  1820,  7207,  6812, 11591,  9545, 11228,  6976 
  2038,  1981,  2152,  2083,   831, 11592,  8502,  9225, 11054,  8402,  8255 
  2039,   749,   750,  1980,   830,  2961,  7682,  7681,  8089,  8138, 11593 
  2040,  1206,  1205,  1610,  1316,  4152, 11595, 11594,  4615,  4614,  8853 
  2041,  1209,  1208,  1607,  1319,  4161, 11596, 11098,  4624,  4623, 11099 
  2042,  1410,   977,  1051,  1050, 11576,  4067, 11326, 11200,  4072,  3528 
  2043,  1064,  1127,  1499,  1417,  4027, 10000,  9292,  9132,  9144,  5457 
  2044,  2058,  2129,  1936,  2088,  8479, 10121,  9159,  8649,  8648,  9146 
  2045,  1777,   390,   248,   247,  9658,  9320,  6925,  6926,  9540,  2395 
  2046,  1456,   915,   914,   119,  9187,  3708, 10376,  9188,  3179,  3176 
  2047,   998,   999,   367,   226,  3358, 10444,  9661,  3355,  3356, 11497 
  2048,  1162,  1102,  1381,   999,  3974,  9481, 11597,  4343,  4369,  9482 
  2049,  2089,  1934,  1994,  1993, 10760,  7928,  8817, 11105,  7930,  7725 
  2050,   487,   126,   920,  1114,  6641,  3189,  9847, 11471,  3716,  3931 
  2051,  1768,  1842,  1899,  1809, 10065,  7418, 11386,  7116, 11274, 10528 
  2052,  2157,   841,   762,   842,  8412,  8019,  9624,  8411,  3054,  8020 
  2053,   433,   306,  1059,   307, 11598,  3550, 11071,  9901,  2456,  3551 
  2054,   125,   126,   487,  1114,  2255,  6641,  6639,  3717,  3716, 11471 
  2055,   998,   999,  1162,  1381,  3358,  4343,  4342,  9862,  9482, 11597 
  2056,  1133,  1490,  1174,   955, 10424, 11599,  4026,  3943, 10288,  4025 
  2057,  1283,  1501,  1419,  1502, 11600,  6091, 10875, 10874,  5237,  5834 
  2058,  1723,  1606,  1319,  1210,  6141,  9218,  9210, 11601,  9502,  4626 
  2059,  1319,  1606,  1209,  1210,  9218,  9504,  4624,  4626,  9502,  4164 
  2060,  2101,  2019,   866,  2169,  9542,  9277,  8292,  8579,  9279,  8435 
  2061,  1723,  1210,  1319,  1320, 11601,  4626,  9210,  9211,  4629,  4631 
  2062,  1423,   450,  1077,   451,  5024,  9707, 11474,  5023,  2604, 11602 
  2063,  2105,  2173,  2045,  1909,  8583,  8606,  8604,  8851,  8852, 10616 
  2064,   448,   447,  1584,  1074,  2601,  5470,  5469, 10880, 11603, 10060 
  2065,  1268,  1146,   986,  1527,  4332,  3913,  4333,  9641, 11604,  9639 
  2066,  1607,  1319,  1724,  1606, 11099,  9212,  6144,  5669,  9218,  6143 
  2067,  1421,   446,  1073,   447,  5020, 11574, 10673,  5019,  2600, 11605 
  2068,  1354,  1330,  1750,  1632,  4810, 10176, 11040,  9836,  9837,  6286 
  2069,  1134,  1518,   177,   960, 10390, 10966,  3785,  3899,  9034,  3271 
  2070,  1581,  1501,  1283,   948,  5833, 11600, 11606, 11607,  8876,  4413 
  2071,  2072,  1960,  1900,  2071, 11420,  7866, 11418,  8377, 11608, 11042 
  2072,   466,  2140,   340,  2070, 10757,  8374,  9808, 10993,  8553,  8229 
  2073,  1960,  2073,   811,  2142,  8917,  8235,  8916, 11609,  8492,  8382 
  2074,  1750,  1631,  1632,  1330,  6285,  5767,  6286, 10176, 11011,  9837 
  2075,   591,   203,   979,  1142,  6475,  3310, 10556, 11610,  3812,  3955 
  2076,  1243,  1715,  1668,   897, 10241,  6114, 10240,  4266, 10281, 10326 
  2077,  1406,  1044,  1222,  1572, 11612,  4199, 11611,  5596, 11614, 11613 
  2078,  1011,  1561,  1298,  1010, 11615, 10043,  4529,  3411,  9585,  4528 
  2079,  1668,  1715,  1434,   897,  6114,  6113,  5888, 10326, 10281, 10283 
  2080,  2032,  1905,  2107,  2033,  7877, 11287, 11379,  7842,  7876, 10885 
  2081,  1903,  2177,  2109,  2042,  9731,  8587, 11616, 10756,  8597,  8594 
  2082,  2157,  2089,  1934,  2128,  8567, 10760, 11513,  8647,  8719, 10759 
  2083,  1015,   402,  1563,   401,  9170,  5409, 11168, 11394,  2554,  5410 
  2084,  1651,  1259,  1282,  1384,  9245,  4406,  9246,  6169, 10296, 11617 
  2085,  1174,  1490,  1711,   955, 11599,  6086, 10302,  4025, 10288, 10286 
  2086,  1763,  1344,  1742,  1347,  9769, 10263,  6357,  9770,  4817, 10220 
  2087,  1371,  1025,  1207,  1608, 11425,  4154, 11540,  5671, 11618,  9594 
  2088,   487,   486,   125,  1114,  2644,  6637,  6639, 11471,  9006,  3717 
  2089,  1191,   995,  1192,  1546,  4099,  4101,  4103,  8946, 10787,  8948 
  2090,   364,   222,   363,   996,  9801, 10080,  2516,  9406,  3348,  9798 
  2091,  1873,   698,   697,   640, 11620,  2905, 11619,  7247,  6763,  6760 
  2092,  1831,  1790,   369,   228,  7001, 11309, 11530,  7004,  6896, 11305 
  2093,  1324,  1153,  1261,  1560,  4658,  4655,  4646,  9333,  9325,  9748 
  2094,   370,   511,   512,   902,  5875,  2673,  4929,  9597, 11320, 11621 
  2095,  1869,  1868,  1782,  1824,  7236, 11622,  9630,  9677, 11623,  7124 
  2096,  1346,  1352,  1745,  1351,  4816, 10391, 11624,  4854,  4803, 11625 
  2097,  1782,  1868,  1804,  1824, 11622,  9548,  7113,  7124, 11623,  7037 
  2098,  1661,  1338,  1391,  1262, 11405,  9583,  6176, 11253,  4534, 11626 
  2099,  2125,  2055,  1929,  2161,  8538,  9142, 11302,  8635,  8634,  9143 
  2100,   144,  1480,   528,  1479, 11627,  5179,  6505,  9672,  5181,  5178 
  2101,   913,  1111,  1465,    41,  3704,  8781,  8750,  8751,  8779,  5136 
  2102,   923,  1117,   493,   132,  3995,  9180,  9182,  3195,  3722,  6622 
  2103,    23,   960,   177,   563,  3272,  3271,  2316,  6413, 10371,  6417 
  2104,  1464,   117,   116,   502, 11171,  2244, 11491,  5132,  6660,  6655 
  2105,  1550,   372,   371,  1149,  5370,  2524,  5371,  9080,  9081, 11360 
  2106,  1550,  1105,   902,   512, 11163,  3874, 11358,  5515, 11628, 11621 
  2107,   543,  1498,  1497,   156,  5224,  5226,  5222,  6549, 11538, 11537 
  2108,   184,   963,   569,   183,  3789,  9782,  6432,  2323,  3277,  6437 
  2109,  1581,  1501,  1419,  1283,  5833,  6091,  5462, 11606, 11600, 10875 
  2110,  2157,  2128,  1934,  1935,  8647, 10759, 11513, 10126,  9604,  7547 
  2111,   397,  1010,   254,   253,  9584,  3408,  9113,  9588,  3407,  2401 
  2112,   538,   955,  1491,  1490, 10643, 10287,  5207,  5205, 10288,  5210 
  2113,  1384,  1259,  1003,  1292, 10296,  4470, 10304,  9999,  4469,  4461 
  2114,   956,   955,  1284,  1491,  3778,  4419,  4418,  9688, 10287,  9696 
  2115,   173,   955,   538,  1490,  3262, 10643,  6537, 10425, 10288,  5205 
  2116,   767,  1998,   847,   768,  7735, 10109,  8109,  2979,  7736,  8110 
  2117,   136,   137,   521,  1476,  2268,  6508,  6506,  8944, 11034,  5168 
  2118,  2141,  1960,   729,   728, 11629,  7622, 11580, 11490,  7860,  7444 
  2119,   536,   537,  1489,   172,  2702,  5203,  5202,  6536,  6535, 10407 
  2120,   267,  1374,   355,   354,  9475,  4905,  6329,  6328,  4904,  2506 
  2121,  1612,  1204,  1729,  1611, 11416, 11417,  6159,  5684, 11630,  6158 
  2122,  1849,   615,   616,   674,  7174,  2821,  7175,  9518,  6805,  6798 
  2123,  1720,  1527,  1658,  1268,  6130,  5856,  6242,  9640,  9641, 11631 
  2124,   778,  2096,  2009,  2008, 11462, 10960,  7768,  7766, 11280,  7770 
  2125,  1023,  1022,   268,  1373,  3446,  3442,  3444, 11126, 10742, 10743 
  2126,  1582,   443,  1070,   444,  5466, 11298,  9779,  5465,  2597, 11632 
  2127,  1728,  1316,  1610,  1205,  8854,  8853,  6155, 11633,  4614, 11595 
  2128,  1203,  1612,  1375,  1021,  9726,  5683, 11634,  4143, 11636, 11635 
  2129,  1554,   379,  1005,   929,  5379,  9605,  9606, 10666, 11030,  4110 
  2130,  1694,   997,  1148,   365, 11637,  3962, 10438,  4920, 11638, 10828 
  2131,   246,   245,  1778,   388,  2393,  6923,  6922,  9174,  9536, 11224 
  2132,   936,  1507,    45,  1474, 11639,  5246, 10223, 10549,  5521,  5164 
  2133,  1290,  1380,  1715,  1636, 10313,  6190, 10312, 11002,  6083,  6297 
  2134,  1673,  1252,  1507,  1679, 10629, 10630,  5902,  5918, 11590,  5915 
  2135,  1730,  1714,  1184,  1741,  6234,  9419, 11640,  6231,  6299, 11641 
  2136,  1243,   997,  1148,  1694,  4454,  3962,  4455, 10239, 11637, 10438 
  2137,  1020,  1021,  1375,   266,  3440, 11635, 11112,  3436,  3438, 11642 
  2138,  1375,  1021,   355,   266, 11635, 11643,  4907, 11642,  3438,  6290 
  2139,   443,   442,  1419,  1069,  2596,  5016,  5015,  9983,  9984, 11644 
  2140,  1518,   178,   177,   564, 11645,  2317, 10966,  5274,  6419,  6418 
  2141,   397,  1011,   254,  1010,  9115,  3409,  9113,  9584,  3411,  3408 
  2142,   201,   978,  1600,  1141,  3308, 10341,  8760,  3810,  3956,  8761 
  2143,   969,   970,  1680,  1263,  3796, 11647, 11646,  4318,  4317, 11648 
  2144,   381,   930,   238,   380, 11190,  3380, 11649,  2533, 11183, 11650 
  2145,   243,   385,   242,  1780, 11247, 10331,  2390,  6917, 10333,  6918 
  2146,   139,   930,   140,   524,  3211,  3210,  2271,  6513, 11651,  6515 
  2147,  2069,  1957,  1958,   465, 10846,  7616, 11039, 10764,  7612,  7614 
  2148,   631,   689,   690,  1865,  6800,  2897,  6749,  7222,  8758, 10650 
  2149,  1376,  1020,   265,  1019, 11110,  3435,  9250,  9254,  3437,  3434 
  2150,   386,  1007,  1008,   244,  9359,  3393,  9358, 10494,  3389,  3391 
  2151,  1913,   420,  2047,  2117,  7480, 11398, 11021, 11526, 11652,  8589 
  2152,   355,  1021,   267,   266, 11643,  3439,  6329,  6290,  3438,  2415 
  2153,   953,   170,   169,   534,  3257,  2307,  3258,  8915,  6532,  6529 
  2154,  1027,  1026,   272,  1369,  3458,  3454,  3456, 10773, 11653, 10771 
  2155,   407,  1810,   604,  1897,  9281,  6949,  9280,  7413, 10825,  9266 
  2156,  1375,  1374,   355,  1021,  4909,  4905,  4907, 11635, 11654, 11643 
  2157,  2039,  2070,   466,   467, 10992, 10993,  7864,  7865, 11187,  2620 
  2158,  1811,   666,  1768,  1842,  6954,  6820,  7046, 10576, 10066, 10065 
  2159,   355,  1374,   267,  1021,  4905,  9475,  6329, 11643, 11654,  3439 
  2160,   293,   420,   419,  2117,  9126,  2573,  9656,  8328, 11652, 11655 
  2161,  2120,  1917,  2168,  1918, 11232, 11509,  8617,  9327,  7496,  9306 
  2162,   426,  2050,  2120,   300, 10656,  8535, 10753,  9823,  8189,  8333 
  2163,  1811,  1842,  1768,  1809, 10576, 10065,  7046,  7043, 11274,  7116 
  2164,  1042,   289,   290,   416,  3500,  2439,  3501, 11656, 10752, 10403 
  2165,  1368,  1605,  1367,  1028,  5662,  5661,  4888,  9162, 10726, 11423 
  2166,  1281,  1481,   934,   933, 11334, 11333,  4399,  4400, 11341,  3741 
  2167,  2115,   416,   415,  1908, 10255,  2569, 10709, 10254,  7466,  7465 
  2168,   799,   876,   877,  2106,  8161,  3089,  8162, 10768,  8302,  8301 
  2169,   413,  1040,   414,   288, 11551, 11657,  2567,  9193,  3496,  9195 
  2170,   992,  1377,   993,  1270, 10713,  9414,  3341,  4338, 10196,  4339 
  2171,  1647,  1711,  1174,  1740,  6239, 10302, 10301,  6262,  6227, 11658 
  2172,   491,   131,  1453,  1425,  6621,  9033,  5106,  5504, 11494,  6072 
  2173,  1962,  2074,   813,  2143, 10029,  8237, 11659, 10745,  8493,  8384 
  2174,   392,  1858,  1819,  1857,  7384, 10081, 11470,  7431,  7203, 10082 
  2175,  1913,  1912,   420,  2117,  7863,  7478,  7480, 11526, 11527, 11652 
  2176,  1416,  1062,   436,  1579, 10782, 11371,  5010,  5630,  8973,  5455 
  2177,  2171,  1913,  2047,  2117, 11265, 11021,  8700,  8702, 11526,  8589 
  2178,  1940,  2154,  2131,  2085, 11251,  8656, 11250,  8744,  8504,  8659 
  2179,   800,  2106,   877,  2031, 10769,  8301,  8167,  7834, 11660, 11380 
  2180,   157,  1498,   543,   156, 11204,  5224,  6565,  2292, 11538,  6549 
  2181,  1295,  1007,  1387,  1006,  4704,  9820, 11076,  4657,  3390, 11063 
  2182,  1580,  1418,   440,  1066,  5747,  5014,  5460,  9089, 11458,  9620 
  2183,   440,  1418,  1067,  1066,  5014, 10899,  9619,  9620, 11458,  3576 
  2184,  1250,  1472,   934,  1281, 11068, 11066,  4286,  4403, 10004,  4399 
  2185,  1217,  1626,  1310,  1732,  9752,  9191,  4589,  9668,  6369,  9666 
  2186,   602,  1897,  1838,  1841,  7320,  9899,  9898,  7424,  7436, 10208 
  2187,  1214,  1602,  1031,  1032, 11327, 10989,  4174,  4175, 11010,  3473 
  2188,  1942,  1941,   449,  2132,  7568,  7564,  7566, 10877, 11661,  8867 
  2189,   473,    87,    88,   891,  6594,  2211,  6601, 10359,  3131,  3130 
  2190,   441,   440,  2057,  1933,  2594,  9618, 11662,  7540,  7539,  9626 
  2191,   905,  1466,   906,    10, 10144, 11519,  3694,  3158, 10146,  3161 
  2192,  1085,   461,  1086,  1590,  8919, 10898,  3634,  8920,  5488, 10810 
  2193,   353,   269,  1372,   352,  5319, 11663,  4899,  2504,  5320,  4898 
  2194,   458,  2136,   332,  2066, 10038,  8366, 10480, 11664,  8549,  8221 
  2195,  1372,   269,  1024,   352, 11663,  3447, 11428,  4898,  5320, 10036 
  2196,  1024,   269,  1372,  1023,  3447, 11663, 11428,  3449,  3445, 11407 
  2197,  1084,  1589,  1233,  1083,  9743,  8835,  4236,  3628,  8837,  4235 
  2198,  1372,   269,   353,  1023, 11663,  5319,  4899, 11407,  3445, 11406 
  2199,  1705,  1655,  1334,  1741,  6044, 11665, 11568,  6230,  6229, 11569 
  2200,  1159,  1242,  1100,  1641,  4362,  4263,  3967, 11477, 10189,  9465 
  2201,  2146,  1952,  2137,  2078,  8893,  8894,  8683,  8556, 11666,  8680 
  2202,    69,  1095,    77,    76, 10409,  3660,  3113,  3112,  3659,  2196 
  2203,   407,   406,   263,  1810,  2559, 10362,  8777,  9281, 11307,  6951 
  2204,  1299,  1229,  1629,  1228,  4543, 10926, 10242,  4546,  4224, 10243 
  2205,   942,   941,  1254,  1505,  3754,  4296,  4295, 10184, 10172, 10160 
  2206,  1695,  1626,  1732,  1310,  6247,  6369,  6178,  9192,  9191,  9666 
  2207,   905,  1471,  1595,  1107,  9084,  5615,  9082,  3921,  9092,  9094 
  2208,  1915,  2019,  2169,  2018,  7989,  9279,  9543,  7892,  7800, 10807 
  2209,   303,  2051,   429,   302,  8190,  9435,  9897,  2452,  8191, 10895 
  2210,  1639,  1202,   891,  1099,  9275,  4139,  9352, 11667,  4141,  3868 
  2211,  1334,  1655,  1705,  1656, 11665,  6044, 11568, 10645,  5839,  6041 
  2212,  1053,   427,   301,  1054,  9882,  9205,  3533,  3537, 11120,  3535 
  2213,  1943,  2062,  2083,  2152,  9611,  8665, 10421, 11049,  8662,  8502 
  2214,  1662,  1179,  1596,  1645, 10150, 10140,  5861,  5862,  9774,  5800 
  2215,  1075,   322,   323,   449,  3598,  2472,  3599, 10868, 10869,  8865 
  2216,  1943,  2062,  2152,  2132,  9611,  8662, 11049, 10997,  8545,  8663 
  2217,   954,  1489,  1596,  1645, 10406,  5618, 10139,  9773,  5801,  5800 
  2218,   114,  1462,   499,  1109,  9916,  5127,  6663,  3700,  9917, 11510 
  2219,  1185,   981,  1684,   982,  4083, 11669, 11668,  4082,  3818, 11670 
  2220,  1129,  1501,   550,  1598, 10157,  5233, 10158,  9451,  5621,  5543 
  2221,   113,   112,   910,  1461,  2240,  3169,  3168,  8905, 11672, 11671 
  2222,   716,  1835,  1892,  1891,  7012,  9488,  9570, 10517,  9490,  7305 
  2223,   399,  1392,  1012,   398,  4956,  9396,  9397,  2551,  4957,  9222 
  2224,  1176,  1109,  1462,   911,  4277,  9917, 11522,  4381,  3928,  9918 
  2225,  1583,  1421,   446,  1072,  5631,  5020,  5467,  9367, 11673, 10852 
  2226,  1037,   284,   410,  1036,  3486, 10610, 11674,  3488,  3484, 10147 
  2227,  1463,  1110,  1662,  1594,  8906, 11488,  6029,  5616,  8908,  5863 
  2228,  1598,   549,   550,   163,  5542,  2717,  5543,  9452,  6552,  6551 
  2229,  1203,  1635,  1375,  1612,  8829,  5955, 11634,  9726,  5961,  5683 
  2230,  1596,  1179,   954,  1645, 10140,  4048, 10139,  5800,  9774,  9773 
  2231,  1273,  1732,  1619,  1696,  9667,  6177, 10507,  9854,  6179,  6004 
  2232,  1376,   356,   265,  1020,  4910,  7440,  9250, 11110, 11111,  3435 
  2233,  1430,  1088,  1089,   464, 10942,  3643,  9492,  5038, 10944, 10501 
  2234,  1474,   519,   935,  1473,  5163, 11496, 10550,  5520,  5162, 11675 
  2235,  1163,  1708,  1225,  1340, 11676, 11677,  4210,  4776, 10267,  4734 
  2236,   518,  1472,   934,  1473,  5160, 11066, 11023,  5161,  5519, 11067 
  2237,  1566,  1036,  1217,  1037, 10148,  4183,  9753,  9928,  3488,  4184 
  2238,  2113,   412,  2043,   286, 11678, 11679,  8530,  8318,  9432,  8175 
  2239,   935,   934,  1250,  1473,  3742,  4286,  4285, 11675, 11067, 11069 
  2240,  1299,  1691,  1629,  1247, 10995,  6207, 10242,  4544, 11680, 10925 
  2241,   935,  1250,  1295,  1473,  4285,  4513,  4512, 11675, 11069, 11075 
  2242,  1867,  1868,  1782,   634,  7233, 11622, 11128,  7229,  7231, 11129 
  2243,   932,   383,   382,   240, 10615,  2535,  9813,  3384, 10808,  9670 
  2244,   241,   240,  1804,   383,  2388,  6914,  6913, 10096, 10808,  9547 
  2245,   931,   381,   239,   382,  9221, 11189,  3382,  9220,  2534, 11536 
  2246,  1805,   385,   242,   384, 10332, 10331,  6915, 10617,  2537, 10799 
  2247,  1068,  1581,   441,   442,  9941,  5464, 10791,  9943,  5463,  2595 
  2248,  1933,  2057,  2127,   440,  9626,  8540, 10005,  7539,  9618,  9616 
  2249,   934,   935,   518,  1473,  3742,  8756, 11023, 11067, 11675,  5161 
  2250,   935,   934,   518,   146,  3742, 11023,  8756,  3222,  3219,  6495 
  2251,  1885,   651,   710,   709,  7282,  6779, 10569, 11681,  6776,  2917 
  2252,  1066,   439,   440,  1580, 11682,  2593,  9620,  9089,  5461,  5460 
  2253,  1888,  1799,   366,  1887,  9648,  9286,  7337,  7293,  9287,  7338 
  2254,  1397,  1396,  1093,  1092,  4968, 10415, 10188,  8791,  8792,  3655 
  2255,    99,  1103,   100,   509,  3685,  3684,  2225,  6683,  9946,  6685 
  2256,  1672,  1474,   935,  1473,  5900, 10550, 11683,  5899,  5520, 11675 
  2257,  1253,  1656,  1414,  1578, 10644,  6022, 10388, 10387,  5838,  5600 
  2258,  1672,  1473,   935,  1295,  5899, 11675, 11683, 11684, 11075,  4512 
  2259,   242,  1006,  1302,   385,  3386,  4588,  3916, 10331, 11062, 11685 
  2260,  1417,   438,  1065,   439,  5012,  9133,  9134,  5011,  2592, 11686 
  2261,  1672,  1295,   935,  1251, 11684,  4512, 11683,  8926,  4514,  4288 
  2262,  1672,  1251,   935,  1474,  8926,  4288, 11683,  5900,  9871, 10550 
  2263,  1251,  1252,   936,  1474,  4511,  4290,  4287,  9871, 10628, 10549 
  2264,    45,  1507,   936,   937,  5246, 11639, 10223, 10346, 10674,  3744 
  2265,  1457,   496,   120,   495,  5116,  6646,  9642,  5115,  2654,  6645 
  2266,  1656,  1505,  1254,   941,  5837, 10160, 10681, 10052, 10172,  4296 
  2267,   941,   940,  1253,  1656,  3753,  4294,  4293, 10052, 10053, 10644 
  2268,   675,   617,  1850,  1851,  6722,  7178, 10605, 10606,  7180,  7182 
  2269,   407,     1,   601,   604,  2560,  2803,  7318,  9280,  6695,  6694 
  2270,   150,  1510,   938,  1124, 10309, 10870,  3227,  3750, 11687,  3890 
  2271,   410,   284,   409,  1036, 10610, 11688,  2563, 10147,  3484, 11689 
  2272,  1645,  1179,  1176,   911,  9774,  4050,  9772, 10136,  4378,  4381 
  2273,    51,  1512,    18,  1503,  5261, 11261,  2794,  5238,  5545, 11690 
  2274,  1717,  1004,   378,  1553,  8793,  9354,  5381,  6337,  8795,  5377 
  2275,  1282,  1384,  1003,  1553, 11617, 10304,  4703, 11486,  5697, 11487 
  2276,  1311,  1754,  1345,  1182, 10251, 10237,  4643,  4595,  9380,  4766 
  2277,  1045,  1044,   418,  1407,  3511, 11456, 11691, 10694, 11692,  4992 
  2278,   180,   181,   567,   962,  2320,  6428,  6426,  3276,  3275,  9166 
  2279,  1334,  1655,  1656,  1171, 11665,  5839, 10645,  4689,  9507, 10646 
  2280,  1137,  1665,  1544,  1195, 10474,  5873, 10473,  4118, 11694, 11693 
  2281,  1741,  1655,  1334,  1171,  6229, 11665, 11569, 10165,  9507,  4689 
  2282,  1137,   971,    26,  1545,  3797,  3294,  3798,  9524, 10137,  9522 
  2283,   382,  1824,   239,   240,  9671,  6987, 11536,  9670,  7038,  2387 
  2284,   169,   533,    21,  1131,  6530,  6528,  2306,  3773,  8931,  4043 
  2285,   418,   291,   417,  1044, 11457, 11695,  2571, 11456,  3506, 11696 
  2286,  1758,  1349,  1727,  1348, 11249, 10855,  6330, 10662,  4791,  9112 
  2287,   417,  1043,  1044,   291, 10729,  3508, 11696, 11695,  3504,  3506 
  2288,   438,   437,  1499,  1064,  2591,  5459,  5458,  9131, 11697,  9292 
  2289,  1273,  1732,  1695,  1619,  9667,  6178,  9866, 10507,  6177,  5988 
  2290,    80,    72,  1401,  1091,  3119,  4978, 10063,  3647,  9921,  9919 
  2291,   734,  2144,  1965,  1964, 10857, 10211,  7636,  7634, 10213,  7638 
  2292,  1061,   434,   435,  1415, 10675,  2588, 11698,  9000,  5008,  5007 
  2293,  2036,  1902,  2109,  2037,  7871, 10161, 11699,  7854,  7991, 10033 
  2294,  1504,   940,  1503,   552, 10051, 11506,  5541,  5240, 11700,  5239 
  2295,  1255,  1506,  1254,  1415, 11701, 11083,  4495,  8992,  6014,  8999 
  2296,  1669,  1589,  1233,  1630,  5890,  8835,  9044,  5892,  5751,  9104 
  2297,  1254,  1506,  1255,   942, 11083, 11701,  4495,  4295, 10185,  4298 
  2298,   408,     2,    80,   282,  2561,  3120, 11702,  8988,  8989,  3480 
  2299,   943,   942,  1255,  1506,  3755,  4298,  4297, 10519, 10185, 11701 
  2300,  1255,  1496,   943,  1506,  8990, 11703,  4297, 11701,  5548, 10519 
  2301,  1588,  1083,  1082,  1232, 11705,  3625, 11704, 11706,  4234,  4233 
  2302,  1749,  1356,  1332,  1760, 10073,  4828,  8859,  6353, 10072,  8857 
  2303,   990,    23,    54,   960,  3331,  2781,  9370,  3782,  3272, 10370 
  2304,  1209,  1370,  1607,  1208, 11707,  5668, 11098,  4161, 11708, 11596 
  2305,  1517,   990,    54,   960,  9371,  9370,  5271,  9036,  3782, 10370 
  2306,   990,  1517,  1525,  1719,  9371,  5562,  9372, 11709,  6128,  6127 
  2307,  1178,  1517,   990,  1719, 10383,  9371,  4311, 10384,  6128, 11709 
  2308,   990,  1517,  1178,   960,  9371, 10383,  4311,  3782,  9036,  4047 
  2309,  1528,  1529,   213,   580,  5306,  9157,  9049,  5302,  5304,  6448 
  2310,  1427,   458,  1588,  1083,  5032,  5483,  5650,  8836, 11710, 11705 
  2311,   370,  1104,   511,   902, 11711, 11712,  5875,  9597,  3924, 11320 
  2312,  1213,  1721,  1739,  1322, 11714,  6222, 11713,  4636, 11584, 11583 
  2313,  1528,  1527,   579,  1146,  5303,  5299,  5301,  9050, 11604,  9051 
  2314,  1588,   458,  1082,  1083,  5483, 10478, 11704, 11705, 11710,  3625 
  2315,   429,   302,  1055,   303, 10895,  3538, 10328,  9897,  2452,  3539 
  2316,  2072,   728,   727,  1900, 11419,  2938, 11715, 11418,  7443,  7442 
  2317,   429,   302,   428,  1055, 10895, 10896,  2582, 10328,  3538, 11716 
  2318,  1539,  1286,   972,  1540, 11077,  4427,  8811,  5576, 11717,  9062 
  2319,   725,   722,  1797,  1839, 11156,  7019, 11718,  7144, 10269, 10271 
  2320,  1830,   705,   647,   648,  7000,  6773, 10939, 11087,  6772,  2853 
  2321,   919,  1076,  1585,  1113,  4003,  8880,  8879,  3932,  4004, 10803 
  2322,  1002,  1552,  1244,  1383,  8846, 10469,  4345, 11231,  5691, 11073 
  2323,   375,  1552,  1002,  1383,  5376,  8846,  8884,  4932,  5691, 11231 
  2324,  2174,  2028,   875,  2105, 11719, 10236,  8446,  8524, 10224,  8299 
  2325,  1394,  1015,  1688,  1200, 10079, 11167,  5938,  9727,  4132,  9259 
  2326,    59,   600,    26,  1545,  2778,  6494,  2786,  5351,  5350,  9522 
  2327,   428,  1054,  1055,   302, 11119,  3540, 11716, 10896,  3536,  3538 
  2328,  1393,  1617,  1197,  1562,  5694,  9422, 11720,  5640,  5705,  9423 
  2329,  1339,  1221,  1698,  1624,  4729,  9264,  9262,  9912, 10762,  6010 
  2330,  1216,  1377,   359,   992, 10195,  4915, 10861,  4337, 10713,  9288 
  2331,    59,    26,   193,  1539,  2786,  2335,  6484,  5337, 10138,  8812 
  2332,  1218,  1626,  1310,  1217,  9865,  9191,  4590,  4187,  9752,  4589 
  2333,   286,   412,   411,  2113,  9432,  2565, 11721,  8318, 11678, 10670 
  2334,   620,   619,   678,  1853,  2825,  6729,  6728,  7187,  7186, 10639 
  2335,  1702,  1331,  1332,  1237,  9511,  4681,  9382, 11722,  4677,  4679 
  2336,  2174,  2106,  1907,  2044,  8584, 11724, 11723,  8603,  8713, 11725 
  2337,  1170,  1283,  1502,  1130,  4439, 10874,  9730,  4016,  4412, 10152 
  2338,   943,  1125,  1496,  1172,  3891, 11726, 11703,  4022,  4021,  8991 
  2339,   107,   515,   106,   904,  6682,  6678,  2232,  3156, 10788,  3157 
  2340,   308,  1061,  1060,   434,  3556,  3558,  3554, 11548, 10675,  9902 
  2341,  1227,  1582,  1654,  1493,  8840,  6021,  8839,  9575,  6077,  5827 
  2342,  2057,   441,  1934,  2128, 11662,  7542,  9625,  8478, 11727, 10759 
  2343,   435,  1062,   309,  1061, 11728,  3559, 11124, 11698,  3561,  3557 
  2344,  1000,   372,  1382,  1550,  9079,  4931, 10299,  9078,  5370,  5514 
  2345,  1951,  1952,  1970,  2078,  7598,  7961,  7960,  8747, 11666,  9970 
  2346,  1653,  1227,  1070,  1069,  9515,  4218,  9778, 11299,  4217,  3585 
  2347,  2180,  2110,  2041,  1901,  8730,  8708,  8315,  9724, 10830,  9718 
  2348,  1830,  1788,   230,   372,  7064,  6901,  7106, 10797, 11729, 10601 
  2349,   921,  1116,  1452,  1080,  3885, 10776, 10128,  4063,  4007, 10775 
  2350,  1305,  1202,  1158,  1638,  4575,  4450,  4576,  9554,  9276,  9072 
  2351,   903,  1000,  1382,  1550,  3981, 10299, 10297, 11162,  9078,  5514 
  2352,    72,    79,  1400,  1091,  3118, 11730,  4975,  9921,  3650,  9920 
  2353,  1225,  1708,  1752,  1340, 11677,  6292, 11731,  4734, 10267, 10266 
  2354,  1445,  1454,  1167,  1426,  5109,  8737,  8735,  6073,  5761,  8739 
  2355,   372,  1880,  1830,  1788,  7414, 10490, 10797, 11729, 10492,  7064 
  2356,  1639,  1231,  1202,  1099,  9467,  4477,  9275, 11667,  4231,  4141 
  2357,  1763,  1325,  1738,  1751,  9771, 11732,  6350,  6351, 11733,  6216 
  2358,  1196,  1561,  1298,  1011, 11401, 10043,  4535,  4121, 11615,  4529 
  2359,  1766,  1750,  1761,  1361,  6371,  6361,  6397, 11734, 11248, 11735 
  2360,  1075,  1422,  1585,  1113, 10321,  5608, 11736,  4225, 11737, 10803 
  2361,  1361,  1355,  1761,  1359,  4855, 11738, 11735,  4858,  4850,  8845 
  2362,  1166,  1709,  1455,  1465, 10272,  6069, 10892,  9940,  6068,  5137 
  2363,  1761,  1355,  1748,  1733, 11738, 10097,  6388,  6346, 10099,  6280 
  2364,  1360,  1766,  1760,  1758, 10451,  6370,  8858, 10661,  6401,  6359 
  2365,  1749,  1356,  1728,  1315, 10073, 11739,  6333,  9439,  4826,  9438 
  2366,  1728,  1348,  1316,  1356, 10234,  4787,  8854, 11739,  4825,  4824 
  2367,  1561,  1731,  1617,  1196,  6173,  6191,  5848, 11401, 11400, 11532 
  2368,  1640,  1327,  1159,  1738, 11485,  4663, 11475,  6211, 11484, 11476 
  2369,  1258,  1246,  1735,  1301,  4561, 11741, 11740,  4550,  4711, 11742 
  2370,  1707,   927,  1296,  1280, 11173,  4516, 10202, 11192,  4395,  4517 
  2371,  1497,  1579,  1125,   944,  5859,  8972, 11539, 10533,  8974,  3942 
  2372,  1108,   497,   909,  1459, 10366, 10933,  3877, 10367,  5120, 11743 
  2373,  1442,   893,  1100,    91, 11558,  3865, 11557, 11744,  3135,  3673 
  2374,  1735,  1246,  1258,  1734, 11741,  4561, 11740,  6195, 11745,  8949 
  2375,  1100,  1440,   892,  1641, 10410,  8863,  3869,  9465,  5787,  8864 
  2376,  1591,  1237,  1702,  1634, 11746, 11722,  6033,  5771, 11747,  6046 
  2377,  1735,  1164,  1670,  1697, 11748, 11749,  6205,  6206,  9199,  6037 
  2378,   440,   313,  2127,   439, 11750,  8349,  9616,  2593, 11751,  9704 
  2379,  1004,  1260,  1717,  1161,  4474,  8794,  8793,  4111,  4363, 11752 
  2380,  1258,  1292,  1734,  1246,  4562,  9313,  8949,  4561,  4540, 11745 
  2381,  1344,  1325,  1763,  1751,  4769,  9771,  9769, 10264, 11733,  6351 
  2382,  1005,  1004,  1717,  1161,  3377,  8793, 11191,  4112,  4111, 11752 
  2383,   447,   321,  2131,  2060, 11754,  8357, 11753, 11755,  8208,  8481 
  2384,  1629,  1676,  1299,  1654,  6225,  8901, 10242,  6025,  6085, 10244 
  2385,  1561,  1196,  1617,  1392, 11401, 11532,  5848,  5587, 11533,  5706 
  2386,  1937,   445,  2130,  2059,  7552, 11262, 10724,  9992, 11263,  8480 
  2387,  2058,  1935,   443,   442,  9160,  7546,  9154,  8819,  7545,  2596 
  2388,  1238,  1237,  1591,  1634,  4252, 11746, 11756, 10131, 11747,  5771 
  2389,   795,  2026,  2025,  2104,  7819,  7821,  7817, 11757, 11113, 11284 
  2390,   397,  1850,  1851,  1773,  7395,  7182,  7432,  9587, 10604, 10358 
  2391,   439,  1065,  1066,   313, 11686,  3573, 11682, 11751,  3569,  3571 
  2392,  1618,  1661,  1680,  1338,  6175,  6185,  6310,  9582, 11405, 10214 
  2393,  1338,  1263,  1661,  1680,  4718, 11758, 11405, 10214, 11648,  6185 
  2394,   434,   433,  1578,  1060,  2587,  5454,  5453,  9902,  9900, 10676 
  2395,   971,  1286,  1687,  1182,  4425, 10445, 11081,  4059,  4426,  9381 
  2396,  1515,   190,   968,  1514, 11153,  3287,  9893,  5551, 11759, 10524 
  2397,   793,   792,   870,  2023,  3004,  8026,  8063,  7811,  7810, 11760 
  2398,  1760,  1356,  1332,  1360, 10072,  4828,  8857,  8858,  4830,  4829 
  2399,   972,   596,  1539,  1540, 11257,  5338,  8811,  9062,  5339,  5576 
  2400,  2008,   856,   778,  2096,  9357,  8057,  7766, 11280,  8282, 11462 
  2401,   433,   432,  1414,  1059,  2586,  5006,  5005, 11071, 10016, 10386 
  2402,   312,  1065,   439,   313,  3568, 11686, 11761,  2462,  3569, 11751 
  2403,  1350,  1351,  1756,  1319,  4800,  9230, 10440,  4793,  4798, 10316 
  2404,  1184,  1741,  1279,  1730, 11641, 11762,  4773, 11640,  6231, 11763 
  2405,   312,   313,   439,  2056,  2462, 11751, 11761,  8201,  8200,  9706 
  2406,  1481,   933,  1480,   145, 11341, 11340,  5185, 11764,  3218, 11335 
  2407,  1361,  1354,  1750,  1761,  4856, 11040, 11248, 11735, 11216,  6361 
  2408,  2021,  1913,  2102,  2022,  7988, 10588,  9001,  7809,  7984, 11765 
  2409,   440,   313,  1066,   314, 11750,  3571,  9620,  9617,  2463,  3572 
  2410,  2013,   861,  2014,  2167, 10042, 11766,  7785,  9403,  8432,  9318 
  2411,   708,  1884,  1790,   709, 11767, 11768,  6865,  2916, 11769,  6864 
  2412,  1381,  1469,  1162,  1549,  5685,  8823, 11597,  5367,  5686,  8824 
  2413,  2060,  1938,  1939,   446, 11770,  7559,  9682, 11771,  7555,  7557 
  2414,   447,  2060,  1939,   446, 11755,  9682,  7558,  2600, 11771,  7557 
  2415,  1605,  1029,  1367,  1028, 11772, 10227,  5661, 10726,  3464, 11423 
  2416,   440,   313,   439,  1066, 11750, 11751,  2593,  9620,  3571, 11682 
  2417,  1642,  1242,  1100,   893,  9304,  4263,  9464,  9305,  4262,  3865 
  2418,  1727,  1316,  1317,  1206,  8855,  4619,  9111, 11773,  4615,  4617 
  2419,   389,  1820,  1778,   247,  9539,  7085, 11222,  9538,  7141,  6924 
  2420,   185,  1559,  1519,   571, 10996,  5282, 11521,  6433,  5279,  5280 
  2421,  1390,   395,  1324,  1718,  4952,  9331, 10210,  6270,  5402,  9332 
  2422,  1024,  1206,  1372,  1609,  4151, 11429, 11428, 11774, 11775,  5674 
  2423,  2102,  1913,  2171,  2022, 10588, 11265,  8521, 11765,  7984, 11209 
  2424,  1306,  1307,  1346,  1745,  4582,  4779,  4778, 11776, 11777, 11624 
  2425,  1816,  1853,  1774,   677,  9139, 11449,  7068,  6964, 11778,  6833 
  2426,  1272,  1571,  1221,  1624, 11436, 10732,  4352, 10763,  5720, 10762 
  2427,  1110,   501,  1463,   116,  8907,  5130,  8906,  3702,  6656, 11779 
  2428,  1561,   398,  1011,  1392,  5405,  9116, 11615,  5587,  4957, 10216 
  2429,  1176,  1109,  1647,  1462,  4277, 11483, 11493, 11522,  9917,  6065 
  2430,  1647,  1461,  1109,   910,  5806, 11482, 11483, 11780, 11671,  3878 
  2431,   443,  2129,   318,   444,  9155,  8352, 10731,  2597, 11782, 11781 
  2432,  2098,  2121,  2050,  1920,  8621,  8471,  8622,  8971, 10668,  8969 
  2433,  2157,  1935,  1934,  1993, 10126,  7547, 11513, 10783,  7929,  7930 
  2434,  1595,  1107,   904,   107,  9094,  3876, 11431, 11783,  3693,  3156 
  2435,  1029,  1604,  1030,  1212, 11784,  9989,  3467,  4168, 11785,  4169 
  2436,  2050,  2121,   301,   427,  8471,  8337,  8188,  9204,  9457,  9205 
  2437,  1920,   427,   428,  2121,  7500,  2581,  7501, 10668,  9457,  9449 
  2438,  1605,  1028,  1210,  1211, 10726,  4163, 11312, 11786,  4165,  4167 
  2439,  1921,  1920,   428,  2121,  7505,  7501,  7503,  9448, 10668,  9449 
  2440,  1797,  1839,  1796,  1898, 10271, 10547,  7114, 11421,  7439, 11787 
  2441,  1605,  1211,  1210,  1723, 11786,  4167, 11312,  6140,  9228, 11601 
  2442,  1767,  1352,  1764,  1323, 10201, 10199,  6400, 10741,  4832,  9446 
  2443,  1207,  1726,  1317,  1609,  9593, 11046,  4618,  9592,  6150, 11788 
  2444,   671,  1771,   672,  1847,  6827,  6826,  2879, 11789, 11791, 11790 
  2445,   672,  1847,  1771,  1814, 11790, 11791,  6826,  6961, 11014,  7050 
  2446,  1817,  1774,  1853,   678,  7053, 11449, 10637,  6968,  6832, 10639 
  2447,  1814,   400,  1847,  1771, 11013,  7433, 11014,  7050, 11440, 11791 
  2448,  1614,  1393,  1617,  1198,  5695,  5694,  5696,  9309, 10608, 11792 
  2449,   400,  1393,  1013,  1562,  4959, 11794, 11793,  5407,  5640, 11516 
  2450,  1814,   673,   672,   614,  6960,  2880,  6961, 10455,  6721,  6718 
  2451,  1368,  1367,   274,  1028,  4888, 11059, 10481,  9162, 11423,  3460 
  2452,  1339,  1624,  1698,  1614,  9912,  6010,  9262,  9308,  6267,  6192 
  2453,   910,  1109,  1647,  1176,  3878, 11483, 11780,  4278,  4277, 11493 
  2454,   419,  1912,  2046,  2117,  7477, 11581,  9344, 11655, 11527,  8467 
  2455,   524,   930,   140,  1120, 11651,  3210,  6515, 11795,  3887,  3735 
  2456,   931,  1120,   239,   381,  3934,  4464,  3382,  9221, 11188, 11189 
  2457,   228,   902,  1104,   370,  3361,  3924,  4456,  9598,  9597, 11711 
  2458,  1794,   362,   220,  1836,  9699, 10831,  6887,  7065, 10832,  7125 
  2459,   381,  1120,  1555,   931, 11188, 11796,  5385,  9221,  3934,  9219 
  2460,  1434,   896,    95,   897, 10282,  3140, 10603, 10283,  3679,  3143 
  2461,  1906,  2114,  2175,  2107, 11294,  8601, 10654, 11301,  8598,  8585 
  2462,  1922,   429,   430,  2122,  7506,  2583,  7507,  9750,  9896, 11797 
  2463,   531,   175,   532,  1484,  6525,  6524,  2696,  5190,  9935,  5191 
  2464,    11,    42,   110,   908,  2801,  6666,  2237,  3164,  9059,  3165 
  2465,  1334,  1656,  1705,  1253, 10645,  6041, 11568,  4731, 10644, 11798 
  2466,  1253,  1656,  1705,  1414, 10644,  6041, 11798, 10388,  6022,  6042 
  2467,  1125,  1496,  1579,  1497, 11726,  5745,  8972, 11539,  5223,  5859 
  2468,  1496,  1506,  1255,  1415,  5548, 11701,  8990,  5746,  6014,  8992 
  2469,   525,  1120,  1555,   524, 11799, 11796,  5524,  2688, 11795,  5523 
  2470,  1948,  1976,  2149,  1975,  7981,  9791,  9789,  7954,  7671, 10859 
  2471,   140,  1120,   525,   524,  3735, 11799,  6514,  6515, 11795,  2688 
  2472,  1278,  1446,  1426,  1644, 11181,  6057, 11238, 11240,  5796,  6032 
  2473,  1397,    74,  1094,    67, 10187,  3656, 10418,  4970,  3108, 10826 
  2474,     3,     1,   407,    32,  2191,  2560,  8776,  2492,  6701,  8778 
  2475,  2065,   457,  1950,  2136, 10057,  7590,  9960,  8486, 10039, 10037 
  2476,  1760,  1360,  1331,  1358,  8858,  4831,  8856, 11800,  4839,  4838 
  2477,  1339,  1627,  1628,  1220,  9911,  5738,  9260,  4818, 11544,  9261 
  2478,  1257,  1495,  1676,  1677,  9216,  5909,  8830,  8832,  5910,  6109 
  2479,  1614,  1628,  1339,  1627,  6219,  9260,  9308,  6268,  5738,  9911 
  2480,   798,   875,   876,  2029,  8136,  3088,  8160,  7828, 11801, 10957 
  2481,  1010,  1153,   396,  1391,  3918,  9324, 10818,  9586,  9326,  4955 
  2482,  1286,  1539,   972,   971, 11077,  8811,  4427,  4425,  8810,  3802 
  2483,  1177,  1285,  1521,  1718,  4437, 11565, 11572, 11369, 11563,  6123 
  2484,  1221,  1043,  1222,  1406,  4197,  4198,  4200, 10733, 10730, 11611 
  2485,  1042,  1571,  1221,  1272, 11435, 10732,  4196,  4351, 11436,  4352 
  2486,   756,  1986,   836,  1987,  7700, 11802,  8093,  7702,  7704, 11803 
  2487,  1420,  1229,  1629,  1583, 11414, 10926,  5749,  5606, 11804,  5748 
  2488,  1249,  1633,  1707,  1644,  9610,  6056, 11805, 10021,  6047,  6053 
  2489,   953,  1175,  1275,  1652,  4039,  4411,  4410, 11451,  9829,  9833 
  2490,  1277,  1691,  1299,  1247,  8886, 10995,  4545,  4510, 11680,  4544 
  2491,   448,   447,  2131,  1940,  2601, 11753, 11806,  7561,  7560, 11250 
  2492,  2067,  1953,  2146,  2077, 10824,  9047,  8682,  8685,  9039,  8496 
  2493,  1089,  1088,  1430,  1238,  3643, 10942,  9492,  4251,  4250, 11308 
  2494,  1093,  1094,  1398,  1397,  3658, 10581, 10413, 10188, 10418,  5418 
  2495,  1429,  1237,  1591,  1087, 11807, 11746,  5613, 10496,  4247, 11306 
  2496,  1965,  2144,   734,   816, 10211, 10857,  7636, 11543,  8385,  8081 
  2497,  2071,  2040,  1900,  2070, 10946,  7974, 11042,  8726, 10947, 11043 
  2498,  1508,  1509,  1173,  1122,  5253,  9020,  9021,  8763,  9024,  4024 
  2499,  1355,  1359,  1762,  1761,  4850,  8844, 11241, 11738,  8845,  6347 
  2500,  1712,  1736,  1713,  1186,  6200,  6199,  6132, 10125, 11588, 10124 
  2501,  1448,   926,   927,  1707, 11397,  3204, 10460,  6055, 11176, 11173 
  2502,     7,   471,   890,    86,  6593,  8954,  3129,  2209,  6600,  3128 
  2503,    30,   213,   987,  1529,  2359,  3326,  3325, 11132,  9157, 10462 
  2504,  1398,  1094,    67,  1397, 10581, 10826,  4972,  5418, 10418,  4970 
  2505,     7,  1436,   927,   890, 11297, 10487,  3202,  3129,  8955,  3205 
  2506,  2141,   889,   728,    64,  8379,  6376, 11490, 11579,  6377,  2939 
  2507,    38,  1436,   927,     7,  5049, 10487, 10459,  2797, 11297,  3202 
  2508,   910,   112,  1108,  1461,  3169,  3698,  3929, 11671, 11672, 11808 
  2509,   619,  1853,  1816,   677,  7186,  9139,  9238,  6726, 11778,  6964 
  2510,  1246,  1164,   909,  1670,  4276,  3986,  4274, 11809, 11749, 11810 
  2511,  1817,   395,  1853,  1774, 11811,  7391, 10637,  7053, 10815, 11449 
  2512,  1651,  1483,   957,  1674,  5819,  9924,  9923,  5962,  5905, 10300 
  2513,   442,  2128,  1935,  1934,  8821,  9604,  7545,  7543, 10759,  7547 
  2514,  1466,   907,   109,   504, 11812,  3163, 10315,  5140, 11813,  6665 
  2515,  1164,  1735,  1670,  1246, 11748,  6205, 11749,  4276, 11741, 11809 
  2516,  1086,   461,  1085,   335, 10898,  8919,  3634,  3632,  8998,  3630 
  2517,   678,  1854,   620,  1853, 10626,  7189,  6728, 10639,  7191,  7187 
  2518,   909,  1164,  1459,  1670,  3986, 11814, 11743, 11810, 11749,  5896 
  2519,  1265,  1542,  1541,  1408, 11815,  5578, 11355, 11354,  5740,  5990 
  2520,  1881,   372,  1830,  1800,  7349, 10797, 10798, 11159, 10796,  7092 
  2521,   725,  1839,  1797,   726,  7144, 10271, 11718,  2935,  7145, 10789 
  2522,  1459,    42,   909,  1468,  5119, 10932, 11743,  5513,  5144, 11816 
  2523,   242,   385,  1302,   384, 10331, 11685,  3916, 10799,  2537, 10800 
  2524,  2138,   335,   462,   336,  8371, 11817,  9766,  8370,  2485,  8995 
  2525,   988,   214,  1147,  1523,  3328,  3826,  3959,  9348,  9356,  9411 
  2526,  1724,  1725,  1756,  1319,  6148,  6322,  6321,  9212, 11818, 10316 
  2527,   462,   335,  2138,   461, 11817,  8371,  9766,  2615,  8998,  9834 
  2528,   989,  1524,   216,   215,  9340,  9644,  3329,  3330,  8936,  2362 
  2529,  1188,  1685,  1312,  1557,  9777, 11820,  4598, 11819,  5974,  9819 
  2530,   395,  1153,  1324,  1560, 11154,  4658,  9331,  5401,  9325,  9333 
  2531,  1151,  1121,  1386,  1168,  4591, 10594, 10593,  4652,  4012, 11244 
  2532,   576,  1524,   215,   577,  5292,  8936,  6442,  2749,  5293,  6441 
  2533,  1561,  1391,  1338,  1010,  5588,  9583,  9581,  9585,  9586,  4532 
  2534,  1261,  1718,  1324,  1560, 11562,  9332,  4646,  9748,  5403,  9333 
  2535,  1310,  1273,  1695,  1180,  4721,  9866,  9192,  4720,  4431,  9784 
  2536,   936,   937,  1507,  1252,  3744, 10674, 11639,  4290,  4289, 10630 
  2537,    30,    55,   213,  1529,  2782,  6447,  2359, 11132,  5305,  9157 
  2538,  1324,   395,   252,  1153,  9331, 10817,  4084,  4658, 11154,  3846 
  2539,  1279,  1693,  1730,  1671, 11821,  6164, 11763, 11822,  5969,  6165 
  2540,   103,   512,   902,  1105,  6688, 11621,  3152,  3689, 11628,  3874 
  2541,  1656,  1655,  1504,  1171,  5839,  5832,  5836, 10646,  9507, 10660 
  2542,   763,  2089,   843,  1994, 11104,  8267,  8051,  7723,  8817,  8816 
  2543,   252,   395,   396,  1153, 10817,  2548, 10816,  3846, 11154,  9324 
  2544,  1658,  1659,  1720,  1268,  5847,  6316,  6242, 11631, 11193,  9640 
  2545,  1279,  1693,  1169,  1730, 11821, 10683,  4393, 11763,  6164, 11823 
  2546,  1123,  1511,   151,  1124, 10688, 11097,  3751,  3936, 10689,  3749 
  2547,   902,   229,   371,   370,  3362, 11824, 11359,  9597,  9599,  2523 
  2548,  1145,  1289,  1526,  1714,  4447,  9415,  9390,  9418,  9417,  6103 
  2549,  1720,  1289,   986,  1268,  9416,  4449,  9638,  9640,  4466,  4333 
  2550,  1000,  1550,   903,  1149,  9078, 11162,  3981,  3915,  9080,  3984 
  2551,  1262,  1153,  1010,  1391,  4594,  3918,  4533, 11626,  9326,  9586 
  2552,   410,  1036,  1566,  1037, 10147, 10148,  5415, 11674,  3488,  9928 
  2553,  1678,  1718,  1261,  1560,  6125, 11562,  9747,  6355,  5403,  9748 
  2554,  1288,  1413,  1684,  1185, 11826,  6112, 11825,  4445, 11292, 11668 
  2555,  1521,    52,    24,   574,  5287,  2779,  9957,  5286,  2746,  6416 
  2556,  1188,  1557,  1686,  1685, 11819,  6167,  9364,  9777,  5974,  5982 
  2557,  1269,  1388,  1178,  1719, 11501, 11827,  4744, 11500,  6264, 10384 
  2558,  1532,  1663,  1266,  1267,  5867,  9870, 11828, 10679, 11432,  4330 
  2559,  1269,  1719,  1178,   990, 11500, 10384,  4744,  4335, 11709,  4311 
  2560,  2053,  1924,  1925,   432,  8978,  7517,  9566,  9567,  7513,  7515 
  2561,   386,   387,  1863,  1806,  2539,  7374,  7373, 10493,  9337, 10500 
  2562,   426,   427,  2050,   300,  2580,  9204, 10656,  9823,  9206,  8189 
  2563,   936,  1474,    45,   519, 10549,  5164, 10223, 11495,  5163,  2682 
  2564,   693,   636,   635,  1869,  6754,  2841,  6755,  9603,  7235,  7234 
  2565,  2017,  2016,  2168,  1917,  7794,  9307, 11829,  7895,  7896, 11509 
  2566,  1026,   350,   272,  1369, 11038,  4862,  3454, 11653,  4890, 10771 
  2567,  1191,  1378,   994,  1546, 10205, 10747,  4098,  8946,  5356, 10786 
  2568,  1510,  1659,  1658,  1124,  5845,  5847,  5843, 11687, 11195, 11029 
  2569,   278,  1032,  1364,  1033,  3472,  9967,  9968,  3474,  3476, 10705 
  2570,  1339,  1614,  1698,  1309,  9308,  6192,  9262,  4726, 10163,  9263 
  2571,   426,  1411,  1053,  1536,  5000, 10981,  9821,  5443,  5442, 11366 
  2572,  1614,  1617,  1309,  1198,  5696, 10164, 10163,  9309, 11792,  4608 
  2573,  1200,  1016,  1394,  1015,  4133,  9282,  9727,  4132,  3426, 10079 
  2574,  1108,  1459,   909,  1164, 10367, 11743,  3877,  3985, 11814,  3986 
  2575,  1511,  1659,  1510,  1124,  5846,  5845,  5259, 10689, 11195, 11687 
  2576,  1276,  1697,  1460,  1164,  9198,  6006, 11092,  4372,  9199, 11830 
  2577,  1521,   574,    24,   966,  5286,  6416,  9957,  9958, 11561,  3283 
  2578,  1108,  1276,  1460,  1164,  4371, 11092, 10365,  3985,  4372, 11830 
  2579,  2120,  2167,  2050,  1919,  8620,  8619,  8535, 10754,  9404,  8968 
  2580,    18,  1512,    51,   559, 11261,  5261,  2794,  6585,  5260,  2729 
  2581,  1503,  1512,   939,  1671,  5545, 11831, 11505,  5898,  5897, 11832 
  2582,  1460,  1697,  1459,  1164,  6006,  6008,  5123, 11830,  9199, 11814 
  2583,  1859,   391,  1858,  1777,  7382,  7383,  7206,  9657, 11833,  9686 
  2584,   927,  1436,  1448,  1296, 10487,  5084, 10460,  4516, 11834, 10204 
  2585,  1870,  1869,  1783,   381,  7239,  9676, 11835,  7364,  7365, 11342 
  2586,   219,   361,   360,  1795, 10879,  2513, 10748,  6885, 11836,  8892 
  2587,   660,   718,   661,  1894,  6793,  6792,  2866,  7309, 10821,  7310 
  2588,  1673,  1252,  1251,  1474, 10629,  4511,  8924,  5901, 10628,  9871 
  2589,   932,   383,  1151,  1479, 10615, 11555,  4462,  8754,  5977,  8753 
  2590,   718,  1795,   719,  1894,  6875,  6874,  2926, 10821,  9297,  9296 
  2591,  1893,  1836,   660,  1894,  9459, 10727,  7307,  7311, 10844,  7309 
  2592,  1034,  1362,   991,  1216,  9613, 10860,  3867,  4181,  9615,  4312 
  2593,  2109,   806,  2036,  2037, 10032,  7850, 11699, 10033,  7852,  7854 
  2594,  1842,  1843,   667,   609,  7158, 10573, 10575,  7154,  7156,  6804 
  2595,  1460,  1459,  1108,  1164,  5123, 10367, 10365, 11830, 11814,  3985 
  2596,  1487,  1131,   953,  1175,  8930,  3772,  8914,  9828,  4040,  4039 
  2597,  1400,  1568,  1097,    71,  5424,  9118, 11837,  4976,  5421, 11838 
  2598,   715,  1890,   657,   656,  9559,  7298,  6787,  6818,  7297,  2862 
  2599,   884,  2038,   807,  2178,  9425,  7855,  8073,  8453, 11172, 11839 
  2600,   766,   846,   767,  1997,  8107,  8108,  2978,  7732, 11051,  7733 
  2601,   765,  1996,  2090,   845,  7729, 10919, 10918,  8105, 10904,  8269 
  2602,  1701,  1293,  1709,  1677, 11047, 10318,  6071,  6354,  8833,  6313 
  2603,   265,   357,  1376,  1019,  8733,  4911,  9250,  3434,  9825,  9254 
  2604,  1957,  1963,  2075,  2143,  7972, 10133, 10191, 10847, 10231,  8591 
  2605,  1926,  2094,  2162,  2004, 10248,  8572, 10249,  7913,  9664, 11089 
  2606,  2127,  2090,  1933,  1932,  8643, 10006, 10005,  9703, 11840,  7541 
  2607,  1701,  1677,  1486,  1175,  6354,  5911,  6218,  9827, 11578, 11841 
  2608,  1486,  1131,  1487,  1175,  8929,  8930,  5198, 11841,  4040,  9828 
  2609,  1486,  1487,  1701,  1175,  5198,  6082,  6218, 11841,  9828,  9827 
  2610,  2106,   799,  2029,  2030, 10768,  7829, 10956, 10770,  7831,  7833 
  2611,  1581,  1598,  1129,  1418,  5830,  9451, 10434,  5603,  5814,  9937 
  2612,   202,   203,   590,  1142,  2346,  6476,  6480,  3813,  3812, 11373 
  2613,  1434,    95,    96,   897, 10603,  2220, 11146, 10283,  3143,  3142 
  2614,   859,   780,   858,  2097,  8117,  8058,  3071,  8283, 11842,  8284 
  2615,   513,  1105,   512,   104, 11843, 11628,  2674,  6690,  3688,  6691 
  2616,  1123,  1693,  1671,  1512, 10684,  5969, 11844, 11100,  5968,  5897 
  2617,  1189,  1668,   898,   897,  9551,  9653,  4268,  4269, 10326,  3680 
  2618,   590,   203,   591,  1142,  6476,  6475,  2766, 11373,  3812, 11610 
  2619,  1317,  1318,  1349,  1726,  4622,  4790,  4789, 11046,  9595, 10854 
  2620,  1720,  1289,  1169,  1730,  9416,  4549, 11845,  6235, 11846, 11823 
  2621,  1955,  2144,  2076,  2068, 10471,  8554, 11847,  9953,  8689,  8686 
  2622,  1034,  1216,  1033,  1363,  4181,  4180,  3479,  9612,  9614, 11004 
  2623,  1928,  2161,  2002,  2093, 10014, 11848,  7916, 10013,  8571,  9876 
  2624,  1796,  1896,   663,   720, 10548,  7316, 10546,  6877,  9487,  6796 
  2625,  2002,  2001,   850,  2161,  7749, 10003, 10116, 11848, 11849,  8419 
  2626,   342,   358,    34,   281,  4868,  2510,  2493,  6269, 10751,  4851 
  2627,  1260,  1553,  1675,  1282,  8796,  6340,  8808,  4407, 11486, 11850 
  2628,   993,  1378,   994,  1190, 10433, 10747,  3344,  4096, 10206,  4097 
  2629,   278,  1033,  1364,   344,  3474, 10705,  9968,  4866, 11422,  4874 
  2630,  1370,  1025,  1371,  1608, 11426, 11425,  4897,  5670, 11618,  5671 
  2631,  1370,  1608,  1607,  1208,  5670,  5672,  5668, 11708, 11851, 11596 
  2632,  1173,  1187,  1713,  1186,  4558, 11196,  9529,  4660,  4091, 10124 
  2633,  1757,  1349,  1350,  1318, 10452,  4794, 10439, 11852,  4790,  4792 
  2634,  2134,  2063,  1946,   453,  8484, 10075, 11175, 11853,  9534,  7578 
  2635,  2013,  2012,   782,   860,  7782,  7778,  7780, 10041,  9056,  8141 
  2636,   814,  2075,   815,   733,  8240,  8239,  3027,  8078, 10132,  8079 
  2637,  1954,  2076,  2068,  1955,  9077,  8686,  9075,  7607, 11847,  9953 
  2638,   286,  2113,   411,   285,  8318, 10670, 11721,  2435,  8319, 10349 
  2639,   414,  1404,  1405,  1040,  4985,  5430,  4988, 11657, 11550, 10156 
  2640,  1955,  1965,  1966,  2076,  7968,  7641,  7967, 11847, 10377, 10089 
  2641,  1713,  1187,   987,  1186, 11196,  4089, 10122, 10124,  4091,  4087 
  2642,  1331,  1631,  1702,  1760,  9509,  6048,  9511,  8856,  6341,  6344 
  2643,   346,   277,  1031,  1365,  3736,  3469, 11854,  4878, 11106, 10990 
  2644,  1750,  1753,  1354,  1632,  6360,  9909, 11040,  6286,  6303,  9836 
  2645,  1591,  1238,  1088,  1237, 11756,  4250, 10943, 11746,  4252,  4248 
  2646,   346,  1365,  1031,  1366,  4878, 10990, 11854,  4880,  4882, 11855 
  2647,   824,  1974,   744,   743,  9323,  7664,  8039,  8016,  7663,  2955 
  2648,  1055,   428,   429,  1412, 11716,  2582, 10328, 11512,  5002,  5001 
  2649,   745,  2149,   826,  1976, 10858,  8395,  8085,  7669,  9791, 10983 
  2650,  1634,  1703,  1238,  1333,  6049, 10107, 10131, 10076, 10078,  4682 
  2651,  1316,  1315,  1728,  1356,  4616,  9438,  8854,  4824,  4826, 11739 
  2652,  1575,   427,  1054,   428,  5447, 11120, 10634,  5446,  2581, 11119 
  2653,  1937,  1990,  1936,  2156,  7934,  7933,  7553,  9991,  9860, 10120 
  2654,  1332,  1333,  1749,  1634,  4684, 10077,  8859,  8860, 10076,  6283 
  2655,  1421,  1248,  1646,  1457,  9301, 10476,  5914,  5860, 10477,  5803 
  2656,   447,  1073,   320,   446, 11605,  3592, 11856,  2600, 11574, 10851 
  2657,   916,  1457,   915,  1248, 11286,  9643,  3709,  4281, 10477,  4282 
  2658,   914,   913,   494,   118,  3707, 11115, 10375,  3177,  3174,  6648 
  2659,   913,   494,    41,  1455, 11115,  2652,  8751,  8752,  5112,  5111 
  2660,  2087,  1989,  1937,  1990, 11857,  7935,  9990, 11267,  7713,  7934 
  2661,  2083,  2133,  1944,  2151,  8664,  9202,  9224,  8561,  8667, 11393 
  2662,   916,    13,    40,  2182,  3180,  2799, 10429, 11321, 11858, 11322 
  2663,  1617,  1197,  1309,  1198,  9422,  4593, 10164, 11792,  4128,  4608 
  2664,  1583,  1247,  1629,  1646, 11859, 10925,  5748,  6023, 10483,  6024 
  2665,  1126,   945,   158,  1597,  3941,  3242,  3758,  9015,  9019, 11202 
  2666,  1196,  1197,  1309,  1617,  4125,  4593,  4592, 11532,  9422, 10164 
  2667,   318,  2059,   319,   445,  8207,  8206,  2468, 10805, 11263, 10804 
  2668,  2091,  2056,  2126,  1931,  8638,  8539,  8639,  9601,  9886, 10777 
  2669,  2164,  1924,  1923,  2008, 10399,  7514, 10400, 11279,  7909,  7908 
  2670,   858,   780,  2010,  2097,  8058,  7772,  9714,  8284, 11842, 10929 
  2671,   580,   579,   213,  1528,  2753,  6451,  6448,  5302,  5301,  9049 
  2672,  1925,  1924,  2053,  2095,  7517,  8978,  9566,  8787,  8980,  8623 
  2673,    18,   552,  1503,   152,  6569,  5239, 11690,  2286,  6571, 11507 
  2674,   939,  1512,  1123,  1671, 11831, 11100,  3747, 11832,  5897, 11844 
  2675,  1183,  1304,  1712,  1186,  4571,  9994,  9674,  4088,  4572, 10125 
  2676,    19,   943,   155,    50,  3238,  3237,  2290,  2793,  8962,  6548 
  2677,  1202,  1638,  1305,  1336,  9276,  9554,  4575,  4699, 11860,  4700 
  2678,  1689,  1541,  1265,   973,  5942, 11355, 11353, 11861, 10986,  4324 
  2679,  1411,   426,  1053,   427,  5000,  9821, 10981,  4999,  2580,  9882 
  2680,  2170,   867,  2020,   790,  8438,  9634, 11147, 11148,  8076,  7802 
  2681,   347,   346,   275,  1366,  2498,  3902,  3951,  4881,  4880, 10228 
  2682,  2043,  2107,  2033,  2176,  8599, 10885, 10920,  8712,  8526,  9761 
  2683,  1038,  1403,  1570,  1219,  9461,  5626,  9929,  4188,  9462, 10778 
  2684,  1712,  1186,   987,  1147, 10125,  4087, 10123, 11499,  4086,  3914 
  2685,  1393,  1562,  1197,  1013,  5640,  9423, 11720, 11794, 11516,  4124 
  2686,  1639,  1336,  1737,  1733, 10035, 10105,  6208,  6184, 10104,  6210 
  2687,  1353,  1355,  1305,  1748,  4821,  4820,  4813, 10100, 10097,  9556 
  2688,  1904,  2034,  2035,  2108,  7993,  7848,  7874,  9845,  9891, 11285 
  2689,   418,  1044,  1045,   292, 11456,  3511, 11691,  9329,  3507,  3509 
  2690,  1922,  1921,   429,  2051,  7508,  7504,  7506, 11862,  9436,  9435 
  2691,  2113,   412,  1904,  2043, 11678,  7455,  9843,  8530, 11679,  9844 
  2692,  1636,   896,   895,  1433, 10311,  3678, 11863,  5776, 10310, 11864 
  2693,   429,  2122,  1922,  2051,  9896,  9750,  7506,  9435,  8472, 11862 
  2694,  1274,   917,  1450,  1112,  4359, 11466, 11865,  4358,  3881, 11413 
  2695,   543,  1498,   157,   544,  5224, 11204,  6565,  2711,  5225,  6564 
  2696,  1449,  1450,   121,   482,  5090, 11467, 11411,  5087,  5088,  6625 
  2697,  1932,  2056,  2127,  2159,  9705,  8477,  9703, 10911,  8641,  8640 
  2698,  2126,  1930,  1931,   438,  8966,  7535, 10777,  9383,  7531,  7533 
  2699,   122,   483,   121,  1450,  6619,  6626,  2251, 11412,  5089, 11467 
  2700,   122,   121,  1112,  1450,  2251,  3712,  3711, 11412, 11467, 11413 
  2701,  1427,  1232,  1233,  1083,  9043,  4237,  8834,  8836,  4234,  4235 
  2702,  1181,  1681,   970,  1263,  9294,  9293,  4057,  4320, 11866,  4317 
  2703,  1922,  2097,  1921,  2051, 11206,  9888,  7508, 11862,  8717,  9436 
  2704,   400,  1847,  1771,  1846,  7433, 11791, 11440,  7401,  7170,  8868 
  2705,  1536,   425,  1052,   426,  5444, 11316, 10344,  5443,  2579,  9822 
  2706,  1948,  1947,   455,  2064,  7586,  7582,  7584,  9881, 11867,  9793 
  2707,   259,   402,  1015,   258,  9172,  9170,  3422,  2406, 11868,  3421 
  2708,  1966,  1954,  1955,  2076,  7966,  7607,  7967, 10089,  9077, 11847 
  2709,  1922,  2122,  2097,  2051,  9750,  8627, 11206, 11862,  8472,  8717 
  2710,   259,   258,  1808,   402,  2406,  6942,  6941,  9172, 11868, 11218 
  2711,  1808,  1770,  1845,  1813,  7129, 10582, 10583,  7128,  7049, 11186 
  2712,  1808,   401,   402,   258,  9526,  2554, 11218,  6942,  9527, 11868 
  2713,   275,   346,   276,  1366,  3902,  3737,  2424, 10228,  4880, 11869 
  2714,   353,   269,   268,  1023,  5319,  2417,  6320, 11406,  3445,  3444 
  2715,    21,   533,  1486,  1131,  6528,  5195, 10324,  4043,  8931,  8929 
  2716,   653,  1833,   712,   654,  9067,  7007,  6781,  2859,  9069,  6780 
  2717,  1745,  1307,  1346,  1743, 11777,  4779, 11624,  6272, 11135, 11870 
  2718,  1350,  1725,  1757,  1318, 11871,  6324, 10439,  4792, 11872, 11852 
  2719,  1508,  1297,  1173,  1679,  8764,  4531,  9021,  5916, 10767, 10935 
  2720,  1679,  1252,  1507,  1297, 11590, 10630,  5915, 10767,  4536, 10766 
  2721,  1008,  1557,  1188,  1007,  9360, 11819,  4115,  3393,  9361,  4114 
  2722,  1767,  1323,  1739,  1322, 10741, 10740,  6382, 11582,  4640, 11583 
  2723,  2166,  1920,  1921,  2121,  9885,  7505,  9883,  8699, 10668,  9448 
  2724,  1724,  1723,  1320,  1755,  6145,  9211,  9213,  6319,  6318, 10194 
  2725,   586,   197,   976,   585,  6470,  3304, 10686,  2761,  6467, 11873 
  2726,  1792,  1888,  1889,   655,  9647,  7296, 11138, 11874,  7292,  7294 
  2727,   655,   713,  1792,   654,  6782,  6868, 11874,  2860,  6783,  9877 
  2728,  1566,  1217,  1626,  1218,  9753,  9752,  5729,  9864,  4187,  9865 
  2729,  1764,  1352,  1306,  1323, 10199,  4815,  9745,  9446,  4832,  4736 
  2730,  1904,  2108,  2035,  2177,  9845, 11285,  7874,  9732,  8527,  9733 
  2731,  1726,  1608,  1207,  1208,  6149,  9594,  9593,  9596, 11851,  4158 
  2732,  1674,   956,  1483,   957, 10959, 10369,  5905, 10300,  3779,  9924 
  2733,   978,   201,  1600,   589,  3308,  8760, 10341, 11480,  6483,  5571 
  2734,   957,  1259,  1651,  1674,  4308,  9245,  9923, 10300,  8952,  5962 
  2735,  1878,  1787,  1801,  1828,  9840,  7137, 10598, 10599,  7096,  7033 
  2736,   638,   696,   639,  1784,  6759,  6758,  2844, 10398,  6853, 10397 
  2737,   697,  1873,   639,  1784, 11619,  7246,  6761,  6852, 10423, 10397 
  2738,  1803,  1872,  1826,  1784, 10307, 11058,  7035,  7087, 10308,  7095 
  2739,  1370,  1208,  1025,  1608, 11708,  4156, 11426,  5670, 11851, 11618 
  2740,   696,  1784,  1871,  1825,  6853, 10306, 10901,  6988,  7076, 10903 
  2741,  1826,  1873,   697,  1784, 11057, 11619,  6992,  7095, 10423,  6852 
  2742,  1247,  1583,  1629,  1229, 11859,  5748, 10925,  4401, 11804, 10926 
  2743,  1960,  2142,   811,   730, 11609,  8382,  8916,  7623,  9794,  8013 
  2744,   400,   399,   256,  1814,  2552,  9519, 11439, 11013,  9521,  7118 
  2745,  1848,   399,   400,  1814,  7399,  2552,  7400, 11015,  9521, 11013 
  2746,  1723,  1321,  1755,  1722,  9227, 10193,  6318,  6142, 10412,  6317 
  2747,    32,     1,   407,   604,  6701,  2560,  8778,  2808,  6695,  9280 
  2748,  1357,  1360,  1350,  1766,  4861,  4852,  4859, 10337, 10451, 10441 
  2749,  1203,  1635,  1020,  1375,  8829,  9470,  4142, 11634,  5955, 11112 
  2750,  1757,  1725,  1350,  1756,  6324, 11871, 10439,  6326,  6322, 10440 
  2751,  1317,  1726,  1727,  1609, 11046,  6154,  9111, 11788,  6150,  6152 
  2752,  1772,   615,  1848,  1849, 11876,  7172, 11875,  9516,  7174,  7176 
  2753,  1370,  1208,  1026,  1025, 11708,  4157, 11877, 11426,  4156,  3455 
  2754,   916,  1274,   917,  1458,  4387,  4359,  3710, 10430,  9298, 11878 
  2755,   513,  1105,  1550,   512, 11843, 11163,  5150,  2674, 11628,  5515 
  2756,  1981,  1943,  2083,  2152,  7946, 10421,  9225, 11592, 11049,  8502 
  2757,  1346,  1352,  1306,  1745,  4816,  4815,  4778, 11624, 10391, 11776 
  2758,  1025,  1208,  1207,  1608,  4156,  4158,  4154, 11618, 11851,  9594 
  2759,   490,  1425,   130,   491,  5503, 10488,  6636,  2648,  5504,  6628 
  2760,  1343,  1626,  1218,  1622,  9455,  9865,  4751,  9454,  5731, 11879 
  2761,  1030,  1604,  1029,  1366,  9989, 11784,  3467,  9988,  5658, 10229 
  2762,   287,   288,   413,  2114,  2437,  9193, 11880,  8321,  8320,  9194 
  2763,  1871,   695,  1870,   637, 10902, 11060,  7242,  7240,  6807,  7238 
  2764,   694,   637,  1870,   695,  6756,  7238, 10435,  2902,  6807, 11060 
  2765,  2032,  1905,  1906,  2107,  7877,  7462,  7878, 11379, 11287, 11301 
  2766,  1323,  1322,  1767,  1352,  4640, 11582, 10741,  4832,  4836, 10201 
  2767,   245,   387,  1008,   244,  9607, 11881,  3392,  2392, 11882,  3391 
  2768,   694,  1870,  1783,   695, 10435, 11835,  6851,  2902, 11060,  6850 
  2769,  1570,   412,  1038,  1039,  5429,  9431,  9929, 10449,  9433,  3494 
  2770,   286,   412,   287,  1039,  9432, 11883,  2436,  3492,  9433,  3493 
  2771,   287,   412,   413,  1039, 11883,  2566, 11880,  3493,  9433, 11552 
  2772,  2179,   809,    81,   886, 10958, 10781,  8458,  8455,  8030,  8311 
  2773,  1874,   698,  1873,   640, 10352, 11620,  7251,  7249,  6763,  7247 
  2774,  1382,  1106,   514,   515, 10298, 11164,  5152,  5153, 11070,  2676 
  2775,   360,   218,   219,  1798,  9291,  2366, 10748,  8891,  6883,  6882 
  2776,   360,  1894,  1895,  1795,  7326,  7314,  7325,  8892,  9297,  8890 
  2777,  1785,  1826,  1873,   698,  6990, 11057, 11884,  6855,  6991, 11620 
  2778,  1789,  1882,  1881,  1800, 10813,  7275, 11086,  7091,  9786, 11159 
  2779,  1882,  1800,   371,  1881,  9786,  9787,  7347,  7275, 11159,  7348 
  2780,  1042,  1041,  1405,  1272,  3502, 10155, 11383,  4351,  4350,  9975 
  2781,  1218,  1626,  1403,  1622,  9865,  5728,  9460, 11879,  5731,  5717 
  2782,   422,  1048,  1049,   296, 11256,  3855, 11885, 11025,  3519,  3521 
  2783,   510,  1104,   369,   901, 11886, 11888,  4927, 11887,  3873,  9945 
  2784,  1790,  1884,   708,  1883, 11768, 11767,  6865, 11531,  7281, 10784 
  2785,   903,   104,   513,   105,  3155,  6690, 11889,  3154,  2230,  6692 
  2786,   439,   313,  2127,  2056, 11751,  8349,  9704,  9706,  8200,  8477 
  2787,  1201,  1395,  1695,  1564, 10531,  5987,  9925, 10422,  5624,  5989 
  2788,  1899,  1810,   406,  1897, 10837, 11307,  7421,  7422, 10825,  7420 
  2789,   667,  1769,   668,  1843,  6823,  6822,  2875, 10573, 10465, 10761 
  2790,  1403,  1219,  1218,  1622,  9462,  4190,  9460,  5717, 11890, 11879 
  2791,   613,   671,   672,  1847,  6716,  2879,  6719,  7168, 11789, 11790 
  2792,  1105,   513,   903,   104, 11843, 11889,  3923,  3688,  6690,  3155 
  2793,  2175,  2031,   877,  2106, 10655, 11380,  8448,  8525, 11660,  8301 
  2794,   499,  1462,   114,   500,  5127,  9916,  6663,  2659,  5128,  6662 
  2795,  1383,  1648,  1244,  1650,  6000, 11072, 11073,  5963,  5992, 11891 
  2796,  1383,  1165,  1244,  1001, 10101,  4509, 11073, 11230,  4705,  4344 
  2797,   510,   101,  1104,   901,  6687,  3687, 11886, 11887,  3150,  3873 
  2798,   510,   509,   100,   901,  2671,  6685,  6684, 11887,  9944,  3151 
  2799,   708,  1884,   650,  1883, 11767,  7279,  6802, 10784,  7281,  7277 
  2800,   382,  1869,   381,  1824,  7366,  7365,  2534,  9671,  9677, 11343 
  2801,  1081,  1587,  1155,   456,  9804, 11329,  3919, 10736,  5481,  9590 
  2802,  1400,  1091,  1097,  1230,  9920,  3666, 11837, 11277,  4227,  4229 
  2803,   375,   233,  1002,   234, 10292,  3367,  8884, 10555,  2381,  3368 
  2804,   898,  1162,   899,  1435,  4706,  3975,  3681,  9654,  8825, 10256 
  2805,   369,   368,   227,  1832,  2521,  9387, 10578, 11892,  9386,  7105 
  2806,  1381,   368,   367,   999,  4922,  2520,  4923,  9482, 11893, 10444 
  2807,   998,  1162,  1189,  1549,  4342,  4365,  4095,  9650,  8824,  9550 
  2808,  1796,   720,   663,   721,  6877,  6796, 10546,  6876,  2928,  6709 
  2809,   227,   368,   226,  1791,  9387, 11894,  2374,  6895,  9388,  6893 
  2810,    96,  1435,   470,  1434, 11392,  5047,  6592, 11146,  5495,  5046 
  2811,  1148,   366,   224,   225, 10669, 10829,  3831,  3832, 11233,  2372 
  2812,   477,  1443,  1101,   478,  5069, 10113, 11313,  2633,  5070, 11895 
  2813,  1896,   720,  1895,   662,  9487, 11896,  7317,  7315,  6797,  7313 
  2814,  1969,   819,  2146,  2077,  8922,  8390,  9046,  9037,  8243,  8496 
  2815,   899,   506,    37,  1469, 11523,  2667, 10535, 10536,  5146,  5145 
  2816,  1568,  1666,  1294,  1696,  5879,  9759, 10054,  6002,  6005,  9443 
  2817,  1884,   651,  1885,   709,  7280,  7282,  7284, 11769,  6776, 11681 
  2818,  1812,  1808,  1845,  1844,  7130, 10583,  9710,  9712, 11897,  7164 
  2819,   402,   401,  1015,   258,  2554, 11394,  9170, 11868,  9527,  3421 
  2820,   800,  2106,  2031,  2030, 10769, 11660,  7834,  7832, 10770,  7836 
  2821,   226,   368,   367,  1791, 11894,  2520, 11497,  6893,  9388, 10552 
  2822,  1462,  1461,   499,  1109,  5129,  5125,  5127,  9917, 11482, 11510 
  2823,  1241,  1291,  1621,  1157,  4732, 11899, 11898,  4507,  4756, 10233 
  2824,  1241,  1157,  1621,  1398,  4507, 10233, 11898, 10414, 10232,  5727 
  2825,   458,   332,   459,  2066, 10480,  9964,  2612, 11664,  8221,  9965 
  2826,  1241,  1398,  1621,  1565, 10414,  5727, 11898, 11900,  5983,  5714 
  2827,   331,   457,  2065,  2136, 11901, 10057,  8218,  8367, 10039,  8486 
  2828,   573,   572,   187,  1520,  2744,  6425,  6420,  5284,  5283, 11448 
  2829,  1855,  1817,  1775,   394, 11125,  6966, 10717,  7388, 11902, 11118 
  2830,   187,   186,   965,  1520,  2326,  3282,  3281, 11448,  9252,  9253 
  2831,  1291,  1565,  1240,  1241, 10497, 11903,  4707,  4732, 11900,  4261 
  2832,  1818,   622,   623,   681, 10884,  2828, 10883,  6970,  6735,  6734 
  2833,   635,  1868,  1782,  1869,  7232, 11622,  9629,  7234,  7236,  9630 
  2834,  1829,  1880,   373,  1788, 10596,  7415,  9095,  7097, 10492,  9685 
  2835,   837,  2086,  1988,   757,  8261, 10979, 10967,  8095,  9872,  7705 
  2836,  1274,  1584,  1450,  1449,  9631,  5755, 11865, 10426,  6028,  5090 
  2837,  1457,   916,   120,   496, 11286,  3181,  9642,  5116, 10431,  6646 
  2838,  1936,  1990,  1991,  2156,  7933,  7716,  8001, 10120,  9860,  9863 
  2839,   646,  1880,   704,   647,  7267, 10597,  6771,  2852,  7268,  6770 
  2840,  1877,  1787,  1878,  1828, 11904,  9840,  7263, 10518,  7096, 10599 
  2841,   425,   424,  1410,  1051,  2578,  4998,  4997, 11317, 11905, 11326 
  2842,  1596,  1488,   535,  1132,  5821,  5200,  5530, 10141, 11166, 11212 
  2843,  1794,  1836,  1893,   362,  7065,  9459,  9458,  9699, 10832,  7329 
  2844,  1647,  1276,   910,  1176, 10294,  4373, 11780, 11493,  4537,  4278 
  2845,  1467,   907,  1326,  1648,  9055,  4661, 11906,  5808, 11908, 11907 
  2846,   701,   702,  1877,  1787,  2909, 10641, 10640,  6996,  6859, 11904 
  2847,   950,  1494,  1256,   951, 10909, 10910,  4301,  3770,  9215,  4300 
  2848,   224,   225,   366,  1799,  2372, 11233, 10829,  6892,  6891,  9286 
  2849,  1290,  1636,  1715,   896, 11002,  6297, 10312,  4453, 10311, 10280 
  2850,   844,   765,  1995,  2090,  8104,  7727, 11909,  8270, 10918, 10917 
  2851,  1398,  1396,  1565,  1241,  6180,  5625,  5983, 10414, 10416, 11900 
  2852,  1115,   920,   488,   127,  3884,  9846,  8873,  3719,  3188,  6638 
  2853,  1834,   365,   364,  1889, 10246,  2517, 11018, 11016,  7335,  7334 
  2854,  1151,   383,   241,   384, 11555, 10096,  3840, 10801,  2536, 10723 
  2855,  1833,  1792,   712,   654,  7078,  6869,  7007,  9069,  9877,  6780 
  2856,  1565,  1396,  1240,  1241,  5625,  9810, 11903, 11900, 10416,  4261 
  2857,   364,   223,   997,   365,  9802,  3351, 11006,  2517, 11910, 11638 
  2858,   947,   549,  1500,  1598, 10525,  5232, 10619,  9450,  5542,  5652 
  2859,   366,   365,   224,  1799,  2518, 10258, 10829,  9286, 10247,  6892 
  2860,   788,   787,   865,  2018,  2999,  8121,  8122,  7796,  7795, 11185 
  2861,   391,  1135,   568,   963,  9150,  9148,  5876, 11447,  3949, 11211 
  2862,   690,   689,  1823,  1865,  2897,  6844,  6845, 10650,  8758,  8757 
  2863,  1241,  1565,  1621,  1291, 11900,  5714, 11898,  4732, 10497, 11899 
  2864,   407,  1396,  1092,   406,  4964,  8792,  8790,  2559,  4965,  9811 
  2865,  1093,  1397,  1398,  1396, 10188,  5418, 10413, 10415,  4968,  6180 
  2866,  1572,  1698,  1625,  1222,  5881,  5883,  5723, 11613, 10363, 11442 
  2867,   290,  1043,   417,   291,  3503, 10729, 10402,  2440,  3504, 11695 
  2868,  1892,   659,   716,   658,  7304,  6788,  9570,  7303,  2864,  6789 
  2869,   545,   544,   158,  1597,  2712,  6567,  6566,  5537,  5536, 11202 
  2870,   363,   222,  1793,  1835, 10080,  6890, 10457,  9489,  7104,  7025 
  2871,   227,   999,   226,   368,  3357,  3356,  2374,  9387, 11893, 11894 
  2872,  1680,  1681,   970,  1516,  5923,  9293, 11647,  5920,  5921,  9982 
  2873,  2097,   780,  2010,  2011, 11842,  7772, 10929,  9889,  7774,  7776 
  2874,  2109,  1902,  2112,  2178, 10161, 11911,  8595,  8528,  9717,  8707 
  2875,  2175,  2114,  1907,  2044,  8601, 11912, 10653,  8600,  8531, 11725 
  2876,   807,  2037,  2178,  2038,  7853, 10162, 11839,  7855,  7857, 11172 
  2877,   458,  1083,   459,   332, 11710, 11472,  2612, 10480,  3623,  9964 
  2878,   781,  2166,  2012,  2011, 11913,  9884,  7777,  7775,  9890,  7779 
  2879,  2036,  1903,  2109,  1902,  7872, 11616, 11699,  7871,  7453, 10161 
  2880,   850,  2093,  2002,  2161,  8276,  9876, 10116,  8419,  8571, 11848 
  2881,   781,  2166,   859,   860, 11913,  8430,  8118,  8119,  8429,  3072 
  2882,  1064,  1499,  1126,  1063,  9292,  9017,  4033,  3567, 11914,  4216 
  2883,  2091,  1998,  2160,   847,  9600,  9577,  8510,  8271, 10109,  8418 
  2884,  2090,  1996,  1932,  2159, 10919,  7925, 11840,  8509, 10912, 10911 
  2885,  1903,   410,  2042,  1902,  7451, 10350, 10756,  7453,  7449, 11915 
  2886,  2042,   410,  2112,  1902, 10350, 10609,  8462, 11915,  7449, 11911 
  2887,  1126,  1499,  1416,  1063,  9017,  5602,  9014,  4216, 11914, 10849 
  2888,  1954,  1955,  2068,   462,  7607,  9953,  9075,  7603,  7605,  9767 
  2889,  1954,   462,  2068,  2138,  7603,  9767,  9075,  9076,  9766,  8551 
  2890,  2109,  2042,  2112,  1902,  8594,  8462,  8595, 10161, 11915, 11911 
  2891,  1103,   999,  1381,   900,  4380,  9482, 11916,  3872,  4368,  9483 
  2892,  1595,  1107,   107,   108,  9094,  3693, 11783, 11917,  3692,  2233 
  2893,  1903,  2042,  2109,  1902, 10756,  8594, 11616,  7453, 11915, 10161 
  2894,  2171,  2103,  2023,  1912,  8581, 11459, 11210, 11266, 11460,  7879 
  2895,   818,  1967,   736,  2145, 10091,  7642,  8144,  8387,  9117,  9887 
  2896,   817,   735,  1966,   736,  8142,  7639, 10168,  8143,  2947,  7640 
  2897,  1476,   520,   928,  1475,  5167, 10572, 11918,  5169,  5166,  8803 
  2898,   870,  2103,   793,  2023,  8296, 11399,  8063, 11760, 11459,  7811 
  2899,  2080,  1949,  1948,  1975, 10012,  7589, 10927, 10010,  7955,  7954 
  2900,  2046,  1912,  2103,  2117, 11581, 11460,  8704,  8467, 11527,  8701 
  2901,  1338,  1680,  1681,  1263, 10214,  5923, 10215,  4718, 11648, 11866 
  2902,   970,  1681,  1680,  1263,  9293,  5923, 11647,  4317, 11866, 11648 
  2903,   455,   456,  2135,   329,  2609,  9986,  9792,  9040,  9591,  8365 
  2904,  2171,  2103,   870,  2023,  8581,  8296,  8439, 11210, 11459, 11760 
  2905,   557,   149,   150,   938,  6579,  2283,  6582,  9073,  3228,  3227 
  2906,  2130,  1938,  2060,   446, 10964, 11770,  8543, 11919,  7555, 11771 
  2907,   836,  1986,   835,  2154, 11802, 10329,  3048,  8405,  9692,  8406 
  2908,  1937,  1989,  2087,  1938,  7935, 11857,  9990,  7556,  7936, 11920 
  2909,  1939,  2154,  1940,  1986,  9681, 11251,  7562,  7939,  9692,  8003 
  2910,   836,  1986,   756,   835, 11802,  7700,  8093,  3048, 10329,  8092 
  2911,  2131,  1939,  1940,   447,  9687,  7562, 11250, 11753,  7558,  7560 
  2912,   870,   792,  2171,  2023,  8026, 10809,  8439, 11760,  7810, 11210 
  2913,   417,  1572,  1044,  1406,  5434, 11614, 11696,  4989,  5596, 11612 
  2914,   767,  1998,  2091,   847,  7735,  9600, 11260,  8109, 10109,  8271 
  2915,  1416,  1499,   437,  1063,  5602,  5459,  5009, 10849, 11914,  8960 
  2916,   965,  1136,   187,  1520,  3904,  3792,  3281,  9253,  9268, 11448 
  2917,   437,  1499,  1064,  1063,  5459,  9292, 11697,  8960, 11914,  3567 
  2918,  1923,  2052,  2164,  2096,  9756,  8626, 10400, 11921,  8714,  8574 
  2919,  1577,  1414,   432,  1058,  5646,  5006,  5451,  9765, 11570, 10017 
  2920,  1137,   192,  1544,   600,  3801, 10968, 10473,  9523,  6492,  5348 
  2921,  2159,  1997,  1932,  1931, 10913,  7924, 10911, 11922,  7923,  7538 
  2922,  2127,  2159,  2090,  1932,  8640,  8509,  8643,  9703, 10911, 11840 
  2923,  1012,  1562,  1013,  1197,  9395, 11516,  3417,  4123,  9423,  4124 
  2924,  2123,   431,   305,  2052, 11923, 11290,  8341,  8473, 11410,  8192 
  2925,  1185,  1699,  1684,   981,  8912,  6162, 11668,  4083, 11924, 11669 
  2926,  2158,  1994,  1934,  1933,  8818,  7928,  9627,  9628,  7927,  7544 
  2927,  1618,  1338,  1313,  1298,  9582,  4719, 10708, 10044,  4774,  4833 
  2928,  1690,  1681,  1543,  1138,  5947,  5922,  5944, 11336,  9295, 11337 
  2929,   305,   431,   304,  2052, 11290, 11291,  2454,  8192, 11410,  8193 
  2930,  1920,  2121,  2050,   427, 10668,  8471,  8969,  7500,  9457,  9204 
  2931,  1288,  1682,  1684,  1413,  9878,  6111, 11825, 11826,  6106,  6112 
  2932,  1660,  1736,  1304,  1615,  6265,  9995,  9993,  6170,  6301,  9848 
  2933,  2016,   786,  2017,   864,  7790,  7792,  7794, 10062,  8137, 11925 
  2934,  1263,  1338,  1661,  1262,  4718, 11405, 11758,  4319,  4534, 11253 
  2935,  2010,  2165,  1922,  2009,  9715, 11207,  7995,  7773, 10924,  7906 
  2936,  1050,   423,   424,  1535, 10025,  2577, 11199, 10699,  5441,  5440 
  2937,  1680,  1661,   969,  1263,  6185,  9894, 11646, 11648, 11758,  4318 
  2938,   360,  1895,   359,  1798,  7325,  7324,  2512,  8891,  8889, 11926 
  2939,   969,  1661,  1262,  1263,  9894, 11253,  4315,  4318, 11758,  4319 
  2940,  1837,  1798,   359,  1898,  7024, 11926, 11927,  9621, 11928,  7322 
  2941,   226,   999,   367,   368,  3356, 10444, 11497, 11894, 11893,  2520 
  2942,  2058,  1935,  1936,   443,  9160,  7550,  9159,  9154,  7546,  7548 
  2943,  1794,   362,  1893,  1892,  9699,  7329,  9458,  9571,  7330,  7308 
  2944,   921,  1424,  1079,  1452, 10129, 10579,  3992, 10128,  5102, 11330 
  2945,   452,  2063,   326,   453,  9532,  8215, 10178,  2606,  9534, 10970 
  2946,   672,  1847,  1814,   614, 11790, 11014,  6961,  6718,  7169, 10455 
  2947,  1339,  1627,  1272,  1624,  9911,  9976,  4786,  9912,  5734, 10763 
  2948,   452,   326,  1079,   453, 10178,  3610, 10893,  2606, 10970, 11492 
  2949,  1079,   326,   327,   453,  3610,  2476,  3611, 11492, 10970, 10971 
  2950,  2036,   805,   806,   882,  7849,  3017,  7850, 11929,  8069,  8068 
  2951,  1980,  2151,  1944,  1945, 11056, 11393,  7949,  7948, 10086,  7577 
  2952,   422,  2048,  1915,  1914, 10026, 10027,  7485,  7483, 10691,  7487 
  2953,  1873,  1872,  1826,   379,  7248, 11058, 11057,  7360,  7361,  8898 
  2954,   338,  1088,   337,   464,  3639,  3638,  2487, 10839, 10944, 11374 
  2955,  2098,  2166,  2012,   860,  8576,  9884, 10652,  8286,  8429,  9056 
  2956,  1907,  2031,  2175,  2106,  7978, 10655, 10653, 11724, 11660,  8525 
  2957,  1089,  1088,   338,   464,  3643,  3639,  3641, 10501, 10944, 10839 
  2958,   433,   306,   432,  1059, 11598, 10018,  2586, 11071,  3550, 10016 
  2959,  2013,   860,   782,   861, 10041,  8141,  7780, 10042,  3073,  8154 
  2960,  2124,  2163,  1925,  2053,  8697,  8786, 11271,  8474,  8698,  9566 
  2961,  1592,  1239,  1430,  1703,  8826,  9493,  5614,  6035, 10108,  6036 
  2962,  1632,  1590,  1235,  1631,  5764, 11140, 11930,  5767,  5759, 11012 
  2963,  1084,  1428,  1085,  1234,  9742,  8921,  3631,  4238,  8934,  4239 
  2964,   391,   390,   248,  1777,  2543,  9320,  9561, 11833,  9658,  6925 
  2965,  2072,  1900,   727,  2071, 11418,  7442, 11715,  8377, 11042, 11931 
  2966,   854,  2095,  2006,  2163,  8280,  8789, 11932,  8423,  8573,  8788 
  2967,  1631,  1590,  1236,  1429,  5759, 11141, 10664,  5758,  5634, 11479 
  2968,  2082,  2150,  1946,  1978,  8560, 11102,  9495, 11234, 10780,  8005 
  2969,  1859,   390,   391,  1777,  7381,  2543,  7382,  9657,  9658, 11833 
  2970,  2149,  1947,  1948,  2064,  9790,  7586,  9789,  8673, 11867,  9881 
  2971,   334,  1084,   333,   460,  3627,  3626,  2483, 10891,  9817, 11933 
  2972,  1280,   926,  1249,  1707,  4396,  4283,  4421, 11192, 11176, 11805 
  2973,  2135,  2149,  1948,  2064,  8672,  9789,  9880,  8485,  8673,  9881 
  2974,  1967,  2077,   818,  1968,  9110,  8244, 10091,  7647,  9038, 10843 
  2975,  2142,  1960,  2071,  2040, 11609, 11608,  8727, 10945,  7975, 10946 
  2976,  1189,   897,  1243,  1668,  4269,  4266,  4508,  9551, 10326, 10240 
  2977,  2069,   465,   338,   464, 10764, 10838,  8227, 10887,  2618, 10839 
  2978,  1079,  1078,   452,  1424,  3612, 10894, 10893, 10579, 10580,  5026 
  2979,  1243,  1694,  1189,  1668, 10239,  9549,  4508, 10240,  5994,  9551 
  2980,  1792,   654,  1888,   655,  9877,  7291,  9647, 11874,  2860,  7292 
  2981,  1791,   368,   367,  1886,  9388,  2520, 10552, 10513,  7340,  7341 
  2982,  1238,  1634,  1430,  1703, 10131,  5770, 11308, 10107,  6049,  6036 
  2983,   490,  1116,   129,   130, 10489,  3721,  6634,  6636,  3720,  2259 
  2984,  1962,  2143,   813,   732, 10745,  8384, 11659,  7628,  9622,  8032 
  2985,   487,  1586,  1423,  1114,  5502,  5501,  5097, 11471, 11934,  9005 
  2986,  1860,   685,  1778,  1820, 11591,  6841, 11935,  9545,  6976,  7085 
  2987,   231,  1000,   373,  1150,  3364, 11028, 10595,  3835,  3838, 11027 
  2988,  1078,  1586,   920,  1114,  8984,  8986,  4002,  4005, 11934,  3931 
  2989,   448,  1422,  1075,  1074,  5022, 10321, 10866, 10880, 10323,  3600 
  2990,   446,  1072,   319,   445, 10852,  3589, 10850,  2599,  9369, 10804 
  2991,   920,  1586,   487,  1114,  8986,  5502,  9847,  3931, 11934, 11471 
  2992,  2087,  2130,  1937,  1938,  8652, 10724,  9990, 11920, 10964,  7556 
  2993,  1324,  1718,  1261,  1285,  9332, 11562,  4646,  4644, 11563,  4441 
  2994,  1988,  1938,  1987,  2086,  8002,  7937,  7707, 10979, 10963,  9693 
  2995,  1177,  1718,  1324,  1285, 11369,  9332,  4645,  4437, 11563,  4644 
  2996,  1119,  1476,   136,   928,  8882,  8944,  3731,  3733, 11918,  3206 
  2997,  2086,  2060,  2130,  1938,  8654,  8543,  8655, 10963, 11770, 10964 
  2998,   301,   302,   428,  2121,  2451, 10896,  9456,  8337,  8336,  9449 
  2999,   954,   171,   536,   172,  3260,  6533, 11293,  3259,  2309,  6536 
  3000,  1988,  2155,   758,  1989, 10980, 11936,  7706,  7710, 11937,  7708 
  3001,  1452,  1116,   921,   490, 10776,  3885, 10128,  5101, 10489, 11938 
  3002,  1813,   401,  1771,  1846,  9525, 11939,  7072,  8870,  7402,  8868 
  3003,  2012,  2166,  2098,  1920,  9884,  8576, 10652,  7903,  9885,  8971 
  3004,   759,   838,  2087,  1989,  8046,  8264, 11940,  7709,  9842, 11857 
  3005,   546,  1127,   160,  1417, 10002,  3760,  6558,  5229,  9144, 10842 
  3006,  2001,   849,   850,  2161,  8797,  3062, 10003, 11849,  8420,  8419 
  3007,   547,  1580,   161,   548,  5539, 10622,  6560,  2715,  5540,  6561 
  3008,  1067,  1129,   947,  1418,  4034,  3895,  4035, 10899,  9937,  9938 
  3009,   946,  1417,   160,  1127,  9090, 10842,  3244,  3940,  9144,  3760 
  3010,   881,  2034,   880,  2108, 10774,  9904,  3093,  8305,  9891,  8306 
  3011,  2032,  1906,  2175,  2107,  7878, 10654, 11151, 11379, 11301,  8585 
  3012,  2113,  2177,  1903,  2042,  8596,  9731, 10755,  8463,  8597, 10756 
  3013,  2054,  2125,  1928,  2093,  8475, 10015, 10953,  8633,  8632, 10013 
  3014,  1513,  1285,  1678,  1718, 11564, 10584,  5912,  6124, 11563,  6125 
  3015,  1513,  1285,   967,  1678, 11564,  4422,  9234,  5912, 10584,  9233 
  3016,  1409,   422,  1049,   423,  4996, 11885, 11364,  4995,  2576, 11365 
  3017,  1409,  1049,   976,  1535, 11364,  4068, 11941,  5568, 10698, 10697 
  3018,  2119,   424,   298,   423,  9086,  9085,  8331,  9065,  2577, 10024 
  3019,  1436,  1296,   890,  1700, 11834,  4515,  8955,  6019, 11942, 10265 
  3020,  1771,   401,   400,  1846, 11939,  2553, 11440,  8868,  7402,  7401 
  3021,  1308,  1637,  1742,  1743, 11136,  6237, 11943, 11137,  6251,  6253 
  3022,  2012,  2166,  1921,  2011,  9884,  9883,  7902,  7779,  9890,  7904 
  3023,  1669,  1303,  1233,  1232, 10019,  4565,  9044,  9045,  4564,  4237 
  3024,   587,   586,   198,  1140,  2762,  6472,  6471, 10703, 10687,  3809 
  3025,  1229,  1583,  1420,  1071, 11804,  5606, 11414,  4222,  9366, 11215 
  3026,   612,   670,  1845,   611,  6714, 11452,  7163,  2817,  6715,  7162 
  3027,  1583,  1072,   446,   445,  9367, 10852,  5467,  5468,  9369,  2599 
  3028,   756,  1986,   755,   835,  7700,  7699,  2967,  8092, 10329,  8091 
  3029,  1229,  1583,  1071,  1072, 11804,  9366,  4222,  4223,  9367,  3591 
  3030,  1937,  2059,   444,   445,  9992, 11944,  7551,  7552, 11263,  2598 
  3031,   976,  1049,  1409,  1139,  4068, 11364, 11941,  3958,  4069, 11352 
  3032,  1056,  1576,   430,  1413,  9734,  5449, 11288, 11289,  5647,  5004 
  3033,   784,   861,  2014,   783,  8155, 11766,  7784,  2995,  8166,  7783 
  3034,  2086,  1938,  1987,  1939, 10963,  7937,  9693,  9680,  7559,  7938 
  3035,  1684,  1682,  1288,   982,  6111,  9878, 11825, 11670, 11566,  4524 
  3036,  1540,  1286,   972,  1689, 11717,  4427,  9062,  5941,  9124,  9122 
  3037,  1625,  1223,  1342,  1311, 11443,  4755,  9908,  9907,  4642,  4768 
  3038,  1345,  1223,  1625,  1311,  4641, 11443, 10250,  4643,  4642,  9907 
  3039,  1360,  1758,  1760,  1356, 10661,  6359,  8858,  4830, 10074, 10072 
  3040,   371,   230,  1800,   229, 10795,  6898,  9787, 11824,  2377,  6899 
  3041,   363,   222,   221,   995, 10080,  2369,  9698,  9797,  3346,  3345 
  3042,   422,   421,  1574,  1048,  2575,  5438,  5437, 11256, 11255, 11945 
  3043,  2072,  1960,  2141,   728, 11420, 11629,  8491, 11419,  7860, 11490 
  3044,  1911,  2103,  2046,  1912,  9106,  8704,  9107,  7479, 11460, 11581 
  3045,  1158,  1296,  1337,  1700,  4518,  4714,  4713,  9071, 11942,  9558 
  3046,  1519,   571,   572,   186,  5280,  2743,  5281,  9251,  6436,  6435 
  3047,  1337,  1296,  1704,  1700,  4714, 10203, 10378,  9558, 11942,  6039 
  3048,   890,  1296,  1158,  1700,  4515,  4518,  3966, 10265, 11942,  9071 
  3049,  1009,   389,   246,   961,  9175,  9173,  3395,  4113,  9471,  3397 
  3050,  1014,   401,   257,   258, 11396, 11946,  3418,  3419,  9527,  2405 
  3051,  2152,  1942,  1943,  2132, 10876,  7571, 11049,  8663, 10877, 10997 
  3052,   921,  1116,   129,   490,  3885,  3721,  3190, 11938, 10489,  6634 
  3053,   464,  2139,  1957,  1956, 10889, 10888,  7611,  7609, 11402,  7613 
  3054,  1757,  1725,  1726,  1318,  6324,  6151,  6325, 11852, 11872,  9595 
