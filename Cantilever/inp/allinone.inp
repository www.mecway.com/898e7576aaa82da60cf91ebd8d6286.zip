    7041,-2.415499675526e+000,-9.567212657991e+001,3.329684596858e+001
    7042,-2.453972978165e+000,-9.529317390121e+001,3.613899105882e+001
    7043,-2.755884584806e+000,-9.405645523006e+001,4.541438109244e+001
    7044,-2.430961993132e+000,-9.409504814215e+001,4.512493425179e+001
    7045,-2.177141232238e+000,-9.396451340143e+001,4.610394480718e+001
    7046,-3.119342365077e+000,-9.404266376672e+001,4.551781706749e+001
    7047,-3.107064599616e+000,-9.475794315032e+001,4.015322169047e+001
    7048,-3.133237944656e+000,-9.427282985300e+001,4.379157142039e+001
    7049,-3.254947441824e+000,-9.444342079854e+001,4.251213932882e+001
    7050,-3.021817206736e+000,-9.465549612104e+001,4.092157441012e+001
    7051,-3.109620240176e+000,-9.486205402312e+001,3.937239014446e+001
    7052,-3.033213327447e+000,-9.506700198719e+001,3.783528041398e+001
    7053,-2.994979990419e+000,-9.526817675434e+001,3.632646966037e+001
    7054,-3.141565247743e+000,-9.548107235011e+001,3.472975269206e+001
    7055,-3.006727423750e+000,-9.609711062598e+001,3.010946562302e+001
    7056,-3.224611394099e+000,-9.628868151091e+001,2.867268398610e+001
    7057,-3.009013470800e+000,-9.648704966283e+001,2.718492284667e+001
    7058,-3.310590244508e+000,-9.642464383881e+001,2.765296652682e+001
    7059,-3.056451670317e+000,-9.702714369383e+001,2.313421761415e+001
    7060,-3.065392560163e+000,-9.743464674689e+001,2.007794471618e+001
    7061,-3.338553940857e+000,-9.765399111220e+001,1.843286197638e+001
    7062,-3.038568823515e+000,-9.762501869400e+001,1.865015511286e+001
    7063,-3.213486364487e+000,-9.781259921174e+001,1.724330122984e+001
    7064,-3.024761701692e+000,-9.805447440003e+001,1.542923731769e+001
    7065,-3.025903265611e+000,-9.930619246721e+001,6.041351813786e+000
    7066,-2.502063823911e+000,-9.397078334953e+001,4.605692019638e+001
    7067,-3.034658391517e+000,-9.496564612497e+001,3.859544938064e+001
    7068,-3.094765477893e+000,-9.516683305250e+001,3.708654742413e+001
    7069,-2.899132030039e+000,-9.639124027389e+001,2.790349326375e+001
    7070,-3.288123592524e+000,-9.658767299432e+001,2.643024786048e+001
    7071,-3.237140652873e+000,-9.815895140994e+001,1.464565974332e+001
    7072,-2.999208653217e+000,-9.454613618879e+001,4.174177390198e+001
    7073,-3.370427931993e+000,-9.435586341831e+001,4.316881968060e+001
    7074,-3.342800059599e+000,-9.556658459906e+001,3.408841082493e+001
    7075,-3.250479520602e+000,-9.619674745010e+001,2.936218944216e+001
    7076,-3.231489577655e+000,-9.712995373824e+001,2.236314228110e+001
    7077,-3.227807695545e+000,-9.753346685453e+001,1.933679390892e+001
    7078,-3.320897682551e+000,-9.875950670401e+001,1.014149503785e+001
    7079,-3.291513534367e+000,-9.860125547705e+001,1.132837924005e+001
    7080,-2.896065149310e+000,-9.857966276088e+001,1.149032461130e+001
    7081,-3.059836480470e+000,-9.941426958704e+001,5.230773415122e+000
    7082,-3.033391489878e+000,-9.920199764596e+001,6.822812973187e+000
    7083,-3.009709150290e+000,-9.624083186001e+001,2.903155636785e+001
    7084,-2.896551564346e+000,-9.619543562682e+001,2.937202811676e+001
    7085,-2.990323930757e+000,-9.598600673220e+001,3.094274482638e+001
    7086,-2.870683437843e+000,-9.628736968763e+001,2.868252266070e+001
    7087,-2.957859399106e+000,-9.717309724770e+001,2.203956596017e+001
    7088,-2.860199138332e+000,-9.712050752363e+001,2.243398889065e+001
    7089,-2.937245167521e+000,-9.662639418617e+001,2.613983892159e+001
    7090,-2.954470138172e+000,-9.656555930827e+001,2.659610050590e+001
    7091,-2.973736253268e+000,-9.820262506288e+001,1.431810734632e+001
    7092,-2.881171986049e+000,-9.815510030383e+001,1.467454303914e+001
    7093,-2.933411263269e+000,-9.757107427471e+001,1.905473825755e+001
    7094,-2.852687082907e+000,-9.752224455593e+001,1.942096114841e+001
    7095,-3.138684821688e+000,-9.722862836209e+001,2.162308260222e+001
    7096,-3.046449929286e+000,-9.770951379991e+001,1.801644181859e+001
    7097,-3.003812829628e+000,-9.793571689376e+001,1.631991861470e+001
    7098,-3.125340773860e+000,-9.825786100796e+001,1.390383775816e+001
    7099,-2.986393962160e+000,-9.867013682101e+001,1.081176916035e+001
    7100,-3.135574098150e+000,-9.886573145919e+001,9.344809373939e+000
    7101,-2.537411490454e+000,-9.616303626349e+001,2.961502334175e+001
    7102,-3.593030868213e+000,-9.974095183141e+001,2.780656582303e+000
    7103,-2.942528733721e+000,-9.975089178414e+001,2.706106936811e+000
    7104,-2.552993342788e+000,-9.914535234007e+001,7.247652767383e+000
    7105,-2.527553193363e+000,-9.851889675475e+001,1.194606965727e+001
    7106,-2.541038715952e+000,-9.811809347535e+001,1.495209425279e+001
    7107,-2.663448210878e+000,-9.761379639541e+001,1.873432235235e+001
    7108,-2.542292280716e+000,-9.747570440969e+001,1.977001224524e+001
    7109,-2.535665181566e+000,-9.708065297874e+001,2.273289797732e+001
    7110,-2.603516773360e+000,-9.666766365273e+001,2.583031792242e+001
    7111,-2.658135045797e+000,-9.652577085468e+001,2.689451390778e+001
    7112,-2.937170227712e+000,-9.668977733879e+001,2.566446527700e+001
    7113,-2.971376439801e+000,-9.674564985897e+001,2.524542137561e+001
    7114,-3.302861174330e+000,-9.972567678844e+001,2.895219404585e+000
    7115,-2.779663534715e+000,-9.550440790766e+001,3.455473601048e+001
    7116,-2.950804009869e+000,-9.399612559489e+001,4.586685335619e+001
    7117,-2.553758465638e+000,-9.512304048041e+001,3.741499171481e+001
    7118,-2.552647889147e+000,-9.472615887523e+001,4.039160375365e+001
    7119,-2.798187689010e+000,-9.430716791977e+001,4.353403591959e+001
    7120,-2.840083627293e+000,-9.390336903540e+001,4.656252755237e+001
    7121,-2.658915086044e+000,-9.393331327908e+001,4.633794572478e+001
    7122,-3.107655272002e+000,-9.395865552444e+001,4.614787888458e+001
    7123,-3.157414798652e+000,-9.390336903540e+001,4.656252755237e+001
    7124,-3.138615840253e+000,-9.681054533752e+001,2.475870528649e+001
    7125,-2.545505118521e+000,-9.938114488455e+001,5.479208683732e+000
    7126,-2.511543363951e+000,-9.631478747122e+001,2.847688928375e+001
    7127,-2.555203529708e+000,-9.489606860965e+001,3.911728074552e+001
    7128,-2.903007859529e+000,-9.443528707393e+001,4.257314226341e+001
    7129,-3.035377676347e+000,-9.439020148508e+001,4.291128417980e+001
    7130,-3.018488349698e+000,-9.434772969369e+001,4.322982261520e+001
    7131,-2.980898346571e+000,-9.558992015661e+001,3.391339414335e+001
    7132,-2.991660194125e+000,-9.554702943823e+001,3.423507453119e+001
    7133,-3.112768258424e+000,-9.565868074476e+001,3.339768973222e+001
    7134,-2.971459866697e+000,-9.879405696612e+001,9.882368071985e+000
    7135,-2.948825150321e+000,-9.873972013707e+001,1.028989428988e+001
    7136,-2.849065626493e+000,-9.782846127983e+001,1.712433571915e+001
    7137,-2.959873349454e+000,-9.776714885321e+001,1.758417891884e+001
    7138,-2.967830282215e+000,-9.970457960305e+001,3.053448295038e+000
    7139,-2.744197491730e+000,-9.397244698778e+001,4.604444290954e+001
    7140,-2.520089843888e+000,-9.786773824585e+001,1.682975847405e+001
    7141,-2.521007997461e+000,-9.591734378913e+001,3.145771689945e+001
    7142,-2.530039335628e+000,-9.448520121975e+001,4.219878616976e+001
    7143,-3.672724983270e+000,-9.944826901359e+001,2.138386318083e+000
    7144,-3.366835432633e+000,-9.943626400360e+001,2.228423892969e+000
    7145,-3.069102271857e+000,-9.943626400360e+001,2.228423892969e+000
    7146,-2.748910192273e+000,-9.944461451193e+001,2.165795080494e+000
    7147,-2.421920015699e+000,-9.944461451193e+001,2.165795080494e+000
    7148,-2.421920015699e+000,-9.940577631967e+001,2.457081522508e+000
    7149,-2.976530929731e+000,-9.940572152269e+001,2.457492499852e+000
    7150,-3.634002462360e+000,-9.353590112902e+001,4.648114545237e+001
    7151,-3.540389043655e+000,-9.357646574946e+001,4.617691079904e+001
    7152,-3.540389043655e+000,-9.362426660148e+001,4.581840440887e+001
    7153,-3.462917260171e+000,-9.368107666991e+001,4.539232889566e+001
    7154,-3.462917260171e+000,-9.374082773494e+001,4.494419590794e+001
    7155,-3.094804193237e+000,-9.363798979932e+001,4.571548042513e+001
    7156,-3.502299940928e+000,-9.380274499369e+001,4.447981646729e+001
    7157,-3.502299940928e+000,-9.385054584572e+001,4.412131007712e+001
    7158,-3.056715090509e+000,-9.375671712650e+001,4.482502547126e+001
    7159,-3.521008509951e+000,-9.390606720841e+001,4.370489985695e+001
    7160,-3.521008509951e+000,-9.395685561368e+001,4.332398681739e+001
    7161,-3.114806340289e+000,-9.387415574794e+001,4.394423581044e+001
    7162,-3.576871942657e+000,-9.400903716684e+001,4.293262516873e+001
    7163,-3.576871942657e+000,-9.406580067861e+001,4.250689883041e+001
    7164,-3.189378342018e+000,-9.398185866379e+001,4.313646394161e+001
    7165,-3.490130874117e+000,-9.411746515058e+001,4.211941529068e+001
    7166,-3.490130874117e+000,-9.416526600260e+001,4.176090890051e+001
    7167,-3.158500706184e+000,-9.408570468890e+001,4.235761875322e+001
    7168,-3.583311755411e+000,-9.421786398814e+001,4.136642400896e+001
    7169,-3.583311755411e+000,-9.426865239341e+001,4.098551096940e+001
    7170,-3.164940518939e+000,-9.418996714641e+001,4.157565032195e+001
    7171,-3.510218286177e+000,-9.431665217148e+001,4.062551263387e+001
    7172,-3.510218286177e+000,-9.436445302351e+001,4.026700624370e+001
    7173,-3.185027930998e+000,-9.429056491002e+001,4.082116709487e+001
    7174,-3.506584881804e+000,-9.442155848055e+001,3.983871531589e+001
    7175,-3.506584881804e+000,-9.447832199233e+001,3.941298897756e+001
    7176,-3.108301057391e+000,-9.439567014513e+001,4.003287783152e+001
    7177,-3.521184877002e+000,-9.453165493236e+001,3.901299192733e+001
    7178,-3.521184877002e+000,-9.458244333763e+001,3.863207888777e+001
    7179,-3.119267648217e+000,-9.450610854220e+001,3.920458985348e+001
    7180,-3.590969460320e+000,-9.462914557373e+001,3.828181211703e+001
    7181,-3.590969460320e+000,-9.467694642575e+001,3.792330572686e+001
    7182,-3.203652226733e+000,-9.460614371833e+001,3.845432603251e+001
    7183,-3.505266402260e+000,-9.472262012879e+001,3.758075295408e+001
    7184,-3.505266402260e+000,-9.477340853406e+001,3.719983991452e+001
    7185,-3.187733751990e+000,-9.469851965747e+001,3.776150648899e+001
    7186,-3.499788968742e+000,-9.482393363844e+001,3.682090163167e+001
    7187,-3.499788968742e+000,-9.487472204372e+001,3.643998859212e+001
    7188,-3.096553260413e+000,-9.479471846489e+001,3.704001543336e+001
    7189,-3.513029807218e+000,-9.492742566894e+001,3.604471140294e+001
    7190,-3.513029807218e+000,-9.497522652096e+001,3.568620501277e+001
    7191,-3.104316665371e+000,-9.489794719449e+001,3.626579996134e+001
    7192,-3.506036356629e+000,-9.502866997996e+001,3.528537907031e+001
    7193,-3.506036356629e+000,-9.507945838523e+001,3.490446603076e+001
    7194,-3.110564053258e+000,-9.500409427871e+001,3.546969682970e+001
    7195,-3.508630567704e+000,-9.513286600411e+001,3.450390888915e+001
    7196,-3.508630567704e+000,-9.518664196264e+001,3.410058920021e+001
    7197,-3.106164813743e+000,-9.511094535658e+001,3.466831374564e+001
    7198,-3.584724012407e+000,-9.523550684835e+001,3.373410255738e+001
    7199,-3.584724012407e+000,-9.528629525362e+001,3.335318951782e+001
    7200,-3.184852469521e+000,-9.521321786117e+001,3.390126996121e+001
    7201,-3.518639759436e+000,-9.533240576328e+001,3.300736069540e+001
    7202,-3.518639759436e+000,-9.538319416855e+001,3.262644765584e+001
    7203,-3.194861661253e+000,-9.530819325654e+001,3.318895449595e+001
    7204,-3.502000096383e+000,-9.543541156603e+001,3.223481717477e+001
    7205,-3.502000096383e+000,-9.548321241805e+001,3.187631078460e+001
    7206,-3.112137745229e+000,-9.540652116367e+001,3.245149519245e+001
    7207,-3.490339725567e+000,-9.553983294088e+001,3.145165686343e+001
    7208,-3.490339725567e+000,-9.560257155916e+001,3.098111722633e+001
    7209,-3.083837711360e+000,-9.551535908397e+001,3.163521079022e+001
    7210,-3.486808353890e+000,-9.565837761470e+001,3.056257180974e+001
    7211,-3.486808353890e+000,-9.570617846672e+001,3.020406541957e+001
    7212,-3.068645968867e+000,-9.562778566234e+001,3.079201145246e+001
    7213,-3.476640498078e+000,-9.575808799790e+001,2.981474393577e+001
    7214,-3.476640498078e+000,-9.580588884992e+001,2.945623754560e+001
    7215,-3.054946741378e+000,-9.573550124906e+001,2.998414455207e+001
    7216,-3.490495456603e+000,-9.585709759469e+001,2.907217195982e+001
    7217,-3.490495456603e+000,-9.590788599997e+001,2.869125892026e+001
    7218,-3.058633844091e+000,-9.583861952500e+001,2.921075748248e+001
    7219,-3.513517328548e+000,-9.596442193563e+001,2.826723940280e+001
    7220,-3.513517328548e+000,-9.602417300065e+001,2.781910641509e+001
    7221,-3.095510674561e+000,-9.594636420543e+001,2.840267237925e+001
    7222,-3.589126506333e+000,-9.607030092267e+001,2.747314699994e+001
    7223,-3.589126506333e+000,-9.611810177470e+001,2.711464060977e+001
    7224,-3.194141724291e+000,-9.604902806311e+001,2.763269344664e+001
    7225,-3.498629126759e+000,-9.616396738001e+001,2.677064856994e+001
    7226,-3.498629126759e+000,-9.621176823203e+001,2.641214217977e+001
    7227,-3.179253522502e+000,-9.614102159044e+001,2.694274199166e+001
    7228,-3.483977566357e+000,-9.626004989989e+001,2.605002967085e+001
    7229,-3.483977566357e+000,-9.631382585841e+001,2.564670998191e+001
    7230,-3.074104582526e+000,-9.623516886361e+001,2.623663744292e+001
    7231,-3.483744690230e+000,-9.637201073105e+001,2.521032343712e+001
    7232,-3.483744690230e+000,-9.642578668958e+001,2.480700374818e+001
    7233,-3.059220145997e+000,-9.634163540410e+001,2.543813838921e+001
    7234,-3.501276162403e+000,-9.647885480673e+001,2.440899286950e+001
    7235,-3.501276162403e+000,-9.652665565876e+001,2.405048647932e+001
    7236,-3.076518742043e+000,-9.645288839390e+001,2.460374096574e+001
    7237,-3.513433291125e+000,-9.657905253013e+001,2.365750994406e+001
    7238,-3.513433291125e+000,-9.662984093540e+001,2.327659690450e+001
    7239,-3.106207342938e+000,-9.655835338243e+001,2.381275355179e+001
    7240,-3.575968545173e+000,-9.667671996993e+001,2.292500414554e+001
    7241,-3.575968545173e+000,-9.673348348170e+001,2.249927780722e+001
    7242,-3.180899725709e+000,-9.665762928832e+001,2.306818425757e+001
    7243,-3.510340065328e+000,-9.678302651025e+001,2.212770509310e+001
    7244,-3.510340065328e+000,-9.683082736228e+001,2.176919870293e+001
    7245,-3.177806499911e+000,-9.675405135140e+001,2.234501878450e+001
    7246,-3.500149271886e+000,-9.688309927320e+001,2.137715937097e+001
    7247,-3.500149271886e+000,-9.693388767848e+001,2.099624633141e+001
    7248,-3.101987226624e+000,-9.685586629088e+001,2.158140673842e+001
    7249,-3.493372951467e+000,-9.698396025830e+001,2.062070198272e+001
    7250,-3.493372951467e+000,-9.703176111033e+001,2.026219559255e+001
    7251,-3.085020112763e+000,-9.695821078163e+001,2.081382305776e+001
    7252,-3.566734176603e+000,-9.708000832931e+001,1.990034145016e+001
    7253,-3.566734176603e+000,-9.713975939434e+001,1.945220846244e+001
    7254,-3.151605017480e+000,-9.705653058044e+001,2.007642456668e+001
    7255,-3.481537995881e+000,-9.719333742254e+001,1.905037325097e+001
    7256,-3.481537995881e+000,-9.724113827456e+001,1.869186686080e+001
    7257,-3.139770061894e+000,-9.715835582762e+001,1.931273521281e+001
    7258,-3.577691483504e+000,-9.729365224584e+001,1.829801207620e+001
    7259,-3.577691483504e+000,-9.734444065111e+001,1.791709903665e+001
    7260,-3.150727368795e+000,-9.726444782710e+001,1.851704521674e+001
    7261,-3.487639020124e+000,-9.739293875405e+001,1.755336326465e+001
    7262,-3.487639020124e+000,-9.744372715932e+001,1.717245022509e+001
    7263,-3.156828393038e+000,-9.736545990131e+001,1.775945466015e+001
    7264,-3.473465440994e+000,-9.749603393467e+001,1.678014940999e+001
    7265,-3.473465440994e+000,-9.754980989319e+001,1.637682972105e+001
    7266,-3.052602350528e+000,-9.746626477959e+001,1.700341807306e+001
    7267,-3.502915479759e+000,-9.760571327858e+001,1.595755433065e+001
    7268,-3.502915479759e+000,-9.765650168385e+001,1.557664129109e+001
    7269,-3.067878810163e+000,-9.757447494033e+001,1.619184186756e+001
    7270,-3.515087968112e+000,-9.771061342774e+001,1.517080321192e+001
    7271,-3.515087968112e+000,-9.775841427977e+001,1.481229682175e+001
    7272,-3.109501337281e+000,-9.768449006960e+001,1.536672839798e+001
    7273,-3.507796682348e+000,-9.781435974442e+001,1.439270583685e+001
    7274,-3.507796682348e+000,-9.787112325620e+001,1.396697949852e+001
    7275,-3.114382539870e+000,-9.779454727815e+001,1.454129933391e+001
    7276,-3.521823509535e+000,-9.792661139041e+001,1.355081849192e+001
    7277,-3.521823509535e+000,-9.798038734894e+001,1.314749880298e+001
    7278,-3.121118081293e+000,-9.790598087701e+001,1.370554734241e+001
    7279,-3.597241329301e+000,-9.802590353545e+001,1.280612740412e+001
    7280,-3.597241329301e+000,-9.807669194072e+001,1.242521436457e+001
    7281,-3.210562728246e+000,-9.800698519774e+001,1.294801493696e+001
    7282,-3.522758280874e+000,-9.812232218207e+001,1.208298755450e+001
    7283,-3.522758280874e+000,-9.817012303409e+001,1.172448116433e+001
    7284,-3.211497499585e+000,-9.809813162559e+001,1.226441672804e+001
    7285,-3.493225075909e+000,-9.822083232121e+001,1.134416151089e+001
    7286,-3.493225075909e+000,-9.828058338624e+001,1.089602852318e+001
    7287,-3.107481246193e+000,-9.819447115406e+001,1.154187026454e+001
    7288,-3.511941828222e+000,-9.833376384973e+001,1.049717504701e+001
    7289,-3.511941828222e+000,-9.838156470175e+001,1.013866865684e+001
    7290,-3.096664793541e+000,-9.829836090468e+001,1.076269713493e+001
    7291,-3.505584107080e+000,-9.843467106882e+001,9.740370903865e+000
    7292,-3.505584107080e+000,-9.848247192084e+001,9.381864513694e+000
    7293,-3.109023824712e+000,-9.840464773523e+001,9.965545905789e+000
    7294,-3.501311232907e+000,-9.853612762207e+001,8.979446754448e+000
    7295,-3.501311232907e+000,-9.858691602735e+001,8.598533714891e+000
    7296,-3.098393229396e+000,-9.851140980352e+001,9.164830393565e+000
    7297,-3.504222205175e+000,-9.864272068983e+001,8.179998746245e+000
    7298,-3.504222205175e+000,-9.869948420161e+001,7.754272407917e+000
    7299,-3.097031327492e+000,-9.862087016724e+001,8.343877665673e+000
    7300,-3.593865221853e+000,-9.874687030145e+001,7.398876659092e+000
    7301,-3.593865221853e+000,-9.879467115348e+001,7.040370268921e+000
    7302,-3.189585316439e+000,-9.872406092957e+001,7.569946948203e+000
    7303,-3.523234131861e+000,-9.884188199294e+001,6.686288972984e+000
    7304,-3.523234131861e+000,-9.889267039821e+001,6.305375933427e+000
    7305,-3.208597243124e+000,-9.881865786887e+001,6.860469903441e+000
    7306,-3.500965968111e+000,-9.894473983866e+001,5.914855130034e+000
    7307,-3.500965968111e+000,-9.899552824394e+001,5.533942090477e+000
    7308,-3.115697989382e+000,-9.891793814879e+001,6.115867804110e+000
    7309,-3.509348954061e+000,-9.905588392753e+001,5.081274463504e+000
    7310,-3.509348954061e+000,-9.910965988606e+001,4.677954774561e+000
    7311,-3.101812811583e+000,-9.903036327283e+001,5.272679373743e+000
    7312,-3.486280417754e+000,-9.916994036863e+001,4.225851155307e+000
    7313,-3.486280417754e+000,-9.922072877390e+001,3.844938115750e+000
    7314,-3.087127261226e+000,-9.915099943900e+001,4.367908127517e+000
    7315,-3.645678873313e+000,-9.926330250337e+001,3.525635144705e+000
    7316,-3.645678873313e+000,-9.931409090865e+001,3.144722105149e+000
    7317,-3.223457180477e+000,-9.925385365104e+001,3.596501537217e+000
    7318,-2.317436751415e+000,-9.351797580951e+001,4.661558534869e+001
    7319,-2.498891201057e+000,-9.352466551069e+001,4.656541258986e+001
    7320,-2.687340802820e+000,-9.352466551069e+001,4.656541258986e+001
    7321,-2.470040596281e+000,-9.936651675014e+001,2.751528293958e+000
    7322,-2.470040596281e+000,-9.931572834486e+001,3.132441333514e+000
    7323,-2.704459430730e+000,-9.937481246149e+001,2.689310458826e+000
    7324,-2.625779953084e+000,-9.925359185967e+001,3.598464972508e+000
    7325,-2.625779953084e+000,-9.918487813488e+001,4.113817908379e+000
    7326,-2.648848489391e+000,-9.912459765232e+001,4.565921527633e+000
    7327,-2.648848489391e+000,-9.906484658729e+001,5.014054515347e+000
    7328,-2.640465503441e+000,-9.900449090369e+001,5.466722142320e+000
    7329,-2.640465503441e+000,-9.893278962566e+001,6.004481727576e+000
    7330,-2.662733667191e+000,-9.888072018520e+001,6.395002530970e+000
    7331,-2.662733667191e+000,-9.882395667343e+001,6.820728869298e+000
    7332,-2.643721740505e+000,-9.872935973413e+001,7.530205914060e+000
    7333,-2.643721740505e+000,-9.865765845609e+001,8.067965499316e+000
    7334,-2.640810768237e+000,-9.860185379360e+001,8.486500467963e+000
    7335,-2.640810768237e+000,-9.854210272858e+001,8.934633455676e+000
    7336,-2.645083642410e+000,-9.848844702734e+001,9.337051214923e+000
    7337,-2.645083642410e+000,-9.842272085581e+001,9.829997501408e+000
    7338,-2.651441363552e+000,-9.836961448875e+001,1.022829525439e+001
    7339,-2.651441363552e+000,-9.831583853022e+001,1.063161494333e+001
    7340,-2.632724611239e+000,-9.821186966146e+001,1.141138145905e+001
    7341,-2.632724611239e+000,-9.826265806673e+001,1.103046841949e+001
    7342,-2.662257816204e+000,-9.816116037433e+001,1.179170111249e+001
    7343,-2.662257816204e+000,-9.810140930931e+001,1.223983410020e+001
    7344,-2.661323044865e+000,-9.801026288145e+001,1.292343230912e+001
    7345,-2.661323044865e+000,-9.795051181642e+001,1.337156529684e+001
    7346,-2.647296217678e+000,-9.789502368221e+001,1.378772630344e+001
    7347,-2.647296217678e+000,-9.783228506393e+001,1.425826594054e+001
    7348,-2.654587503442e+000,-9.777633959928e+001,1.467785692543e+001
    7349,-2.654587503442e+000,-9.771658853425e+001,1.512598991315e+001
    7350,-2.612964976324e+000,-9.754084723344e+001,1.644404966921e+001
    7351,-2.612964976324e+000,-9.748408372166e+001,1.686977600754e+001
    7352,-2.627138555454e+000,-9.743177694632e+001,1.726207682263e+001
    7353,-2.627138555454e+000,-9.737202588129e+001,1.771020981035e+001
    7354,-2.621037531211e+000,-9.727101380707e+001,1.846780036694e+001
    7355,-2.621037531211e+000,-9.720827518879e+001,1.893834000404e+001
    7356,-2.621037531211e+000,-9.713956146401e+001,1.945369293991e+001
    7357,-2.632872486797e+000,-9.703773621683e+001,2.021738229378e+001
    7358,-2.632872486797e+000,-9.698396025830e+001,2.062070198272e+001
    7359,-2.639648807216e+000,-9.693388767848e+001,2.099624633141e+001
    7360,-2.639648807216e+000,-9.687114906020e+001,2.146678596851e+001
    7361,-2.649839600658e+000,-9.681887714927e+001,2.185882530048e+001
    7362,-2.649839600658e+000,-9.675912608424e+001,2.230695828819e+001
    7363,-2.652932826455e+000,-9.666270402117e+001,2.303012376126e+001
    7364,-2.652932826455e+000,-9.659697784963e+001,2.352307004774e+001
    7365,-2.640775697733e+000,-9.654458097827e+001,2.391604658301e+001
    7366,-2.640775697733e+000,-9.648482991324e+001,2.436417957072e+001
    7367,-2.623477101687e+000,-9.630486319866e+001,2.571392993007e+001
    7368,-2.623477101687e+000,-9.625108724013e+001,2.611724961901e+001
    7369,-2.638128662089e+000,-9.620280557228e+001,2.647936212793e+001
    7370,-2.638128662089e+000,-9.614604206050e+001,2.690508846626e+001
    7371,-2.653016863878e+000,-9.605404853317e+001,2.759503992123e+001
    7372,-2.653016863878e+000,-9.599429746814e+001,2.804317290895e+001
    7373,-2.629994991933e+000,-9.593776153248e+001,2.846719242641e+001
    7374,-2.629994991933e+000,-9.587203536095e+001,2.896013871289e+001
    7375,-2.616140033408e+000,-9.582082661618e+001,2.934420429867e+001
    7376,-2.616140033408e+000,-9.576705065765e+001,2.974752398761e+001
    7377,-2.626307889220e+000,-9.571514112648e+001,3.013684547142e+001
    7378,-2.626307889220e+000,-9.565837761470e+001,3.056257180974e+001
    7379,-2.629839260897e+000,-9.560257155916e+001,3.098111722633e+001
    7380,-2.629839260897e+000,-9.553983294088e+001,3.145165686343e+001
    7381,-2.641499631713e+000,-9.548321241805e+001,3.187631078460e+001
    7382,-2.641499631713e+000,-9.542047379977e+001,3.234685042170e+001
    7383,-2.658139294766e+000,-9.536825640230e+001,3.273848090277e+001
    7384,-2.658139294766e+000,-9.530850533727e+001,3.318661389048e+001
    7385,-2.648130103034e+000,-9.521352994190e+001,3.389892935574e+001
    7386,-2.648130103034e+000,-9.515079132362e+001,3.436946899284e+001
    7387,-2.645535891959e+000,-9.509738370474e+001,3.477002613444e+001
    7388,-2.645535891959e+000,-9.502866997996e+001,3.528537907031e+001
    7389,-2.652529342548e+000,-9.497522652096e+001,3.568620501277e+001
    7390,-2.652529342548e+000,-9.492145056244e+001,3.608952470171e+001
    7391,-2.639288504072e+000,-9.486874693721e+001,3.648480189089e+001
    7392,-2.639288504072e+000,-9.480899587219e+001,3.693293487860e+001
    7393,-2.644765937590e+000,-9.475847076781e+001,3.731187316145e+001
    7394,-2.644765937590e+000,-9.470170725603e+001,3.773759949978e+001
    7395,-2.660684412332e+000,-9.460933131689e+001,3.843041904330e+001
    7396,-2.660684412332e+000,-9.453763003886e+001,3.896817862856e+001
    7397,-2.646084417134e+000,-9.448429709883e+001,3.936817567879e+001
    7398,-2.646084417134e+000,-9.442454603380e+001,3.981630866650e+001
    7399,-2.649717821507e+000,-9.436744057676e+001,4.024459959431e+001
    7400,-2.649717821507e+000,-9.429872685198e+001,4.075995253018e+001
    7401,-2.629630409447e+000,-9.419812908837e+001,4.151443575726e+001
    7402,-2.629630409447e+000,-9.413539047008e+001,4.198497539436e+001
    7403,-2.629630409447e+000,-9.406966429855e+001,4.247792168085e+001
    7404,-2.660508045281e+000,-9.396581827344e+001,4.325676686924e+001
    7405,-2.660508045281e+000,-9.389710454865e+001,4.377211980511e+001
    7406,-2.641799476258e+000,-9.384158318596e+001,4.418853002528e+001
    7407,-2.641799476258e+000,-9.378183212093e+001,4.463666301299e+001
    7408,-2.602416795501e+000,-9.371991486218e+001,4.510104245364e+001
    7409,-2.602416795501e+000,-9.367211401016e+001,4.545954884381e+001
    7410,-3.602612559953e+000,-9.940937602434e+001,2.430083737441e+000
    7411,-3.602612559953e+000,-9.936456272557e+001,2.766183478226e+000
    7412,-3.265889395426e+000,-9.354061511044e+001,4.644579059167e+001
    7413,-2.368955630892e+000,-9.354259083019e+001,4.643097269354e+001
    7414,-2.642415015089e+000,-9.766247679036e+001,1.553182799232e+001
    7415,-2.642415015089e+000,-9.759675061883e+001,1.602477427881e+001
    7416,-2.623244225560e+000,-9.643176179608e+001,2.476219044941e+001
    7417,-2.623244225560e+000,-9.636304807130e+001,2.527754338528e+001
    7418,-2.816117662818e+000,-9.365283141550e+001,4.560416830374e+001
    7419,-2.893589446302e+000,-9.359602134707e+001,4.603024381696e+001
    7420,-2.368955630892e+000,-9.356649125621e+001,4.625171949846e+001
    7421,-2.401202048567e+000,-9.359728247215e+001,4.602078537889e+001
    7422,-2.582656498209e+000,-9.358007174731e+001,4.614986581514e+001
    7423,-3.339789322676e+000,-9.934689919743e+001,2.898659939250e+000
    7424,-2.998273750913e+000,-9.354061511044e+001,4.644579059167e+001
    7425,-2.733364757183e+000,-9.877674583397e+001,7.174810165236e+000
    7426,-2.736740864631e+000,-9.805577906796e+001,1.258206091027e+001
    7427,-2.717191018834e+000,-9.732352777835e+001,1.807394558235e+001
    7428,-2.706233711933e+000,-9.708598343582e+001,1.985552815139e+001
    7429,-2.715468080503e+000,-9.670958305569e+001,2.267853100230e+001
    7430,-2.728626041663e+000,-9.610017645519e+001,2.724908050608e+001
    7431,-2.724223547737e+000,-9.526239482761e+001,3.353244271291e+001
    7432,-2.730468995650e+000,-9.465603355299e+001,3.808015227256e+001
    7433,-2.722811290741e+000,-9.425072707390e+001,4.111995086572e+001
    7434,-2.716371477987e+000,-9.401799982659e+001,4.286540522058e+001
    7435,-2.401202048567e+000,-9.363014555791e+001,4.577431223564e+001
    7436,-2.861343028627e+000,-9.356523013113e+001,4.626117793653e+001
    7437,-2.908319368116e+000,-9.927341640676e+001,3.449780869269e+000
    7438,-3.067717823674e+000,-9.931599013624e+001,3.130477898224e+000
    7439,-3.024651510314e+000,-9.936646195316e+001,2.751939271301e+000
    7440,-2.062501113750e+000,-9.052057378477e+001,1.936726473612e+000
    7441,-2.513630857360e+000,-8.950004833000e+001,2.205606266240e+000
    7442,-2.894410913869e+000,-8.950004833000e+001,2.185864258712e+000
    7443,-3.203330580685e+000,-8.950004833000e+001,2.185864258712e+000
    7444,-3.683050988846e+000,-8.950004833000e+001,2.115979668697e+000
    7445,-2.514491357825e+000,-8.950004833000e+001,4.639151885483e+001
    7446,-2.466372031810e+000,-8.950004833000e+001,4.582538864755e+001
    7447,-2.466372031810e+000,-8.950004833000e+001,4.546688225738e+001
    7448,-2.518626926933e+000,-8.950004833000e+001,4.512440892409e+001
    7449,-2.518626926933e+000,-8.950004833000e+001,4.472108923514e+001
    7450,-2.797497777493e+000,-8.950004833000e+001,4.527529149715e+001
    7451,-2.483907433517e+000,-8.950004833000e+001,4.434792573072e+001
    7452,-2.483907433517e+000,-8.950004833000e+001,4.398941934055e+001
    7453,-2.815033179200e+000,-8.950004833000e+001,4.455965465943e+001
    7454,-2.519167060202e+000,-8.950004833000e+001,4.359355398573e+001
    7455,-2.519167060202e+000,-8.950004833000e+001,4.325745424495e+001
    7456,-2.815573312469e+000,-8.950004833000e+001,4.379062580019e+001
    7457,-2.478421812628e+000,-8.950004833000e+001,4.289980547619e+001
    7458,-2.478421812628e+000,-8.950004833000e+001,4.254129908602e+001
    7459,-2.810087691580e+000,-8.950004833000e+001,4.303711167662e+001
    7460,-2.470830897949e+000,-8.950004833000e+001,4.219785196209e+001
    7461,-2.470830897949e+000,-8.950004833000e+001,4.181693892253e+001
    7462,-2.761751529327e+000,-8.950004833000e+001,4.233601578393e+001
    7463,-2.472673487717e+000,-8.950004833000e+001,4.145858301433e+001
    7464,-2.472673487717e+000,-8.950004833000e+001,4.103285667600e+001
    7465,-2.520390727244e+000,-8.950004833000e+001,4.065928737476e+001
    7466,-2.520390727244e+000,-8.950004833000e+001,4.032318763397e+001
    7467,-2.805563033710e+000,-8.950004833000e+001,4.090228754236e+001
    7468,-2.487864419425e+000,-8.950004833000e+001,3.993013649038e+001
    7469,-2.487864419425e+000,-8.950004833000e+001,3.957163010020e+001
    7470,-2.820753965419e+000,-8.950004833000e+001,4.013566709751e+001
    7471,-2.516222949034e+000,-8.950004833000e+001,3.918615255813e+001
    7472,-2.516222949034e+000,-8.950004833000e+001,3.882764616796e+001
    7473,-2.816586187210e+000,-8.950004833000e+001,3.935713841185e+001
    7474,-2.486432828616e+000,-8.950004833000e+001,3.844163819878e+001
    7475,-2.486432828616e+000,-8.950004833000e+001,3.799350521107e+001
    7476,-2.815154596400e+000,-8.950004833000e+001,3.858565290059e+001
    7477,-2.480440759913e+000,-8.950004833000e+001,3.762682033744e+001
    7478,-2.480440759913e+000,-8.950004833000e+001,3.729072059666e+001
    7479,-2.779372407279e+000,-8.950004833000e+001,3.783296005779e+001
    7480,-2.513935933182e+000,-8.950004833000e+001,3.691703141248e+001
    7481,-2.513935933182e+000,-8.950004833000e+001,3.653611837292e+001
    7482,-2.484012155854e+000,-8.950004833000e+001,3.614351514405e+001
    7483,-2.484012155854e+000,-8.950004833000e+001,3.574019545510e+001
    7484,-2.810446907786e+000,-8.950004833000e+001,3.632629358693e+001
    7485,-2.516531604175e+000,-8.950004833000e+001,3.534125194737e+001
    7486,-2.516531604175e+000,-8.950004833000e+001,3.496033890781e+001
    7487,-2.813042578778e+000,-8.950004833000e+001,3.553474685032e+001
    7488,-2.484642449420e+000,-8.950004833000e+001,3.456027017355e+001
    7489,-2.484642449420e+000,-8.950004833000e+001,3.415695048461e+001
    7490,-2.813672872345e+000,-8.950004833000e+001,3.473573460832e+001
    7491,-2.483211312652e+000,-8.950004833000e+001,3.382172126897e+001
    7492,-2.483211312652e+000,-8.950004833000e+001,3.348562152819e+001
    7493,-2.780352580822e+000,-8.950004833000e+001,3.400043665843e+001
    7494,-2.522103060399e+000,-8.950004833000e+001,3.310699967494e+001
    7495,-2.522103060399e+000,-8.950004833000e+001,3.274849328476e+001
    7496,-2.817813191801e+000,-8.950004833000e+001,3.328658558954e+001
    7497,-2.480521915965e+000,-8.950004833000e+001,3.237987587870e+001
    7498,-2.480521915965e+000,-8.950004833000e+001,3.202136948853e+001
    7499,-2.815123795114e+000,-8.950004833000e+001,3.253934633023e+001
    7500,-2.475500744454e+000,-8.950004833000e+001,3.167122468440e+001
    7501,-2.475500744454e+000,-8.950004833000e+001,3.131271829423e+001
    7502,-2.768521479169e+000,-8.950004833000e+001,3.182058412003e+001
    7503,-2.484175957963e+000,-8.950004833000e+001,3.098479218412e+001
    7504,-2.484175957963e+000,-8.950004833000e+001,3.058147249518e+001
    7505,-2.772175521167e+000,-8.950004833000e+001,3.114251320579e+001
    7506,-2.520274139221e+000,-8.950004833000e+001,3.018976833225e+001
    7507,-2.520274139221e+000,-8.950004833000e+001,2.983126194208e+001
    7508,-2.816948915934e+000,-8.950004833000e+001,3.042288293276e+001
    7509,-2.487108958103e+000,-8.950004833000e+001,2.944071915442e+001
    7510,-2.487108958103e+000,-8.950004833000e+001,2.905980611486e+001
    7511,-2.819881916074e+000,-8.950004833000e+001,2.964063598217e+001
    7512,-2.516472328901e+000,-8.950004833000e+001,2.867974012856e+001
    7513,-2.516472328901e+000,-8.950004833000e+001,2.832123373839e+001
    7514,-2.816080105754e+000,-8.950004833000e+001,2.887002720821e+001
    7515,-2.478716515199e+000,-8.950004833000e+001,2.795095736998e+001
    7516,-2.478716515199e+000,-8.950004833000e+001,2.759245097981e+001
    7517,-2.807687662850e+000,-8.950004833000e+001,2.811968485350e+001
    7518,-2.482400928716e+000,-8.950004833000e+001,2.723128753710e+001
    7519,-2.482400928716e+000,-8.950004833000e+001,2.682796784816e+001
    7520,-2.773616262665e+000,-8.950004833000e+001,2.738824504238e+001
    7521,-2.518626578422e+000,-8.950004833000e+001,2.645375742619e+001
    7522,-2.518626578422e+000,-8.950004833000e+001,2.607284438663e+001
    7523,-2.813526325888e+000,-8.950004833000e+001,2.665287117770e+001
    7524,-2.479098447674e+000,-8.950004833000e+001,2.568709805194e+001
    7525,-2.479098447674e+000,-8.950004833000e+001,2.532859166177e+001
    7526,-2.810223844845e+000,-8.950004833000e+001,2.589291442104e+001
    7527,-2.479472141776e+000,-8.950004833000e+001,2.499210118526e+001
    7528,-2.479472141776e+000,-8.950004833000e+001,2.463359479508e+001
    7529,-2.771069408200e+000,-8.950004833000e+001,2.517067760984e+001
    7530,-2.517694171193e+000,-8.950004833000e+001,2.425003731836e+001
    7531,-2.517694171193e+000,-8.950004833000e+001,2.386912427880e+001
    7532,-2.809665131719e+000,-8.950004833000e+001,2.445062965659e+001
    7533,-2.477988584654e+000,-8.950004833000e+001,2.347310249409e+001
    7534,-2.477988584654e+000,-8.950004833000e+001,2.309218945454e+001
    7535,-2.808181574597e+000,-8.950004833000e+001,2.367105039516e+001
    7536,-2.481162410208e+000,-8.950004833000e+001,2.275189962893e+001
    7537,-2.481162410208e+000,-8.950004833000e+001,2.241579988815e+001
    7538,-2.771649813613e+000,-8.950004833000e+001,2.293473878485e+001
    7539,-2.516415472828e+000,-8.950004833000e+001,2.205269114725e+001
    7540,-2.516415472828e+000,-8.950004833000e+001,2.169418475708e+001
    7541,-2.810076701786e+000,-8.950004833000e+001,2.223134021835e+001
    7542,-2.476800417944e+000,-8.950004833000e+001,2.131138003964e+001
    7543,-2.476800417944e+000,-8.950004833000e+001,2.093046700008e+001
    7544,-2.805714709521e+000,-8.950004833000e+001,2.148542676001e+001
    7545,-2.480126893452e+000,-8.950004833000e+001,2.057261977267e+001
    7546,-2.480126893452e+000,-8.950004833000e+001,2.016930008373e+001
    7547,-2.769426130146e+000,-8.950004833000e+001,2.074477481515e+001
    7548,-2.517033692324e+000,-8.950004833000e+001,1.977942290572e+001
    7549,-2.517033692324e+000,-8.950004833000e+001,1.942091651555e+001
    7550,-2.809659404526e+000,-8.950004833000e+001,1.999705040974e+001
    7551,-2.486031353266e+000,-8.950004833000e+001,1.904547400911e+001
    7552,-2.486031353266e+000,-8.950004833000e+001,1.870937426832e+001
    7553,-2.815563864340e+000,-8.950004833000e+001,1.923173072529e+001
    7554,-2.519665215050e+000,-8.950004833000e+001,1.832951592788e+001
    7555,-2.519665215050e+000,-8.950004833000e+001,1.797100953771e+001
    7556,-2.818195387066e+000,-8.950004833000e+001,1.847642987841e+001
    7557,-2.483400214395e+000,-8.950004833000e+001,1.759411766609e+001
    7558,-2.483400214395e+000,-8.950004833000e+001,1.721320462654e+001
    7559,-2.815564248195e+000,-8.950004833000e+001,1.771967966635e+001
    7560,-2.476744420184e+000,-8.950004833000e+001,1.685430604449e+001
    7561,-2.476744420184e+000,-8.950004833000e+001,1.645098635555e+001
    7562,-2.772643453330e+000,-8.950004833000e+001,1.698388921268e+001
    7563,-2.480858173170e+000,-8.950004833000e+001,1.610991557454e+001
    7564,-2.480858173170e+000,-8.950004833000e+001,1.577381583376e+001
    7565,-2.770101412104e+000,-8.950004833000e+001,1.628391984963e+001
    7566,-2.517130346724e+000,-8.950004833000e+001,1.540776766486e+001
    7567,-2.517130346724e+000,-8.950004833000e+001,1.504926127469e+001
    7568,-2.810487338644e+000,-8.950004833000e+001,1.557680089974e+001
    7569,-2.480317212328e+000,-8.950004833000e+001,1.469313338855e+001
    7570,-2.480317212328e+000,-8.950004833000e+001,1.433462699838e+001
    7571,-2.809946377801e+000,-8.950004833000e+001,1.485462484470e+001
    7572,-2.476495291415e+000,-8.950004833000e+001,1.397968336985e+001
    7573,-2.476495291415e+000,-8.950004833000e+001,1.362117697968e+001
    7574,-2.769311322493e+000,-8.950004833000e+001,1.414355333003e+001
    7575,-2.483543875300e+000,-8.950004833000e+001,1.326071714268e+001
    7576,-2.483543875300e+000,-8.950004833000e+001,1.285739745374e+001
    7577,-2.772537985465e+000,-8.950004833000e+001,1.342814986450e+001
    7578,-2.518263584340e+000,-8.950004833000e+001,1.249108284399e+001
    7579,-2.518263584340e+000,-8.950004833000e+001,1.213257645382e+001
    7580,-2.814306278390e+000,-8.950004833000e+001,1.270137541776e+001
    7581,-2.481143248468e+000,-8.950004833000e+001,1.176082485584e+001
    7582,-2.481143248468e+000,-8.950004833000e+001,1.142472511505e+001
    7583,-2.811905651558e+000,-8.950004833000e+001,1.196330921002e+001
    7584,-2.477258588141e+000,-8.950004833000e+001,1.107715250132e+001
    7585,-2.477258588141e+000,-8.950004833000e+001,1.069623946176e+001
    7586,-2.770900655359e+000,-8.950004833000e+001,1.124398499831e+001
    7587,-2.518892139834e+000,-8.950004833000e+001,1.030270424463e+001
    7588,-2.518892139834e+000,-8.950004833000e+001,9.899384555691e+000
    7589,-2.808649546725e+000,-8.950004833000e+001,1.050287716744e+001
    7590,-2.481034118018e+000,-8.950004833000e+001,9.503479334938e+000
    7591,-2.481034118018e+000,-8.950004833000e+001,9.122566295381e+000
    7592,-2.812425076602e+000,-8.950004833000e+001,9.713436729567e+000
    7593,-2.517621732068e+000,-8.950004833000e+001,8.741021321096e+000
    7594,-2.517621732068e+000,-8.950004833000e+001,8.404921580311e+000
    7595,-2.811154668836e+000,-8.950004833000e+001,8.935986534529e+000
    7596,-2.483078677164e+000,-8.950004833000e+001,8.030382664093e+000
    7597,-2.483078677164e+000,-8.950004833000e+001,7.671876273922e+000
    7598,-2.813199227982e+000,-8.950004833000e+001,8.179902644027e+000
    7599,-2.515932924998e+000,-8.950004833000e+001,7.285202338406e+000
    7600,-2.515932924998e+000,-8.950004833000e+001,6.926695948235e+000
    7601,-2.811510420912e+000,-8.950004833000e+001,7.418689792294e+000
    7602,-2.481184619811e+000,-8.950004833000e+001,6.557392995365e+000
    7603,-2.481184619811e+000,-8.950004833000e+001,6.154073306422e+000
    7604,-2.809616363559e+000,-8.950004833000e+001,6.662712903907e+000
    7605,-2.474871554043e+000,-8.950004833000e+001,5.817068925561e+000
    7606,-2.474871554043e+000,-8.950004833000e+001,5.480969184776e+000
    7607,-2.768554992604e+000,-8.950004833000e+001,5.956405570176e+000
    7608,-2.471545959043e+000,-8.950004833000e+001,5.151156985427e+000
    7609,-2.471545959043e+000,-8.950004833000e+001,4.792650595256e+000
    7610,-2.758916331836e+000,-8.950004833000e+001,5.289588989966e+000
    7611,-2.473646008241e+000,-8.950004833000e+001,4.456643540832e+000
    7612,-2.473646008241e+000,-8.950004833000e+001,4.098137150661e+000
    7613,-2.757690786033e+000,-8.950004833000e+001,4.623769736193e+000
    7614,-2.486826773706e+000,-8.950004833000e+001,3.736177131543e+000
    7615,-2.486826773706e+000,-8.950004833000e+001,3.377670741372e+000
    7616,-2.772971600697e+000,-8.950004833000e+001,3.925802662651e+000
    7617,-3.683050988846e+000,-8.950004833000e+001,4.657077204991e+001
    7618,-3.347882604856e+000,-8.950004833000e+001,4.646813709613e+001
    7619,-3.039823438504e+000,-8.950004833000e+001,4.646813709613e+001
    7620,-3.573333726600e+000,-8.950004833000e+001,4.628888390105e+001
    7621,-2.712833261930e+000,-8.950004833000e+001,4.610963070596e+001
    7622,-3.687642892602e+000,-8.950004833000e+001,2.413143856042e+000
    7623,-3.687642892602e+000,-8.950004833000e+001,2.637210349899e+000
    7624,-3.736366958759e+000,-8.950004833000e+001,2.883229076489e+000
    7625,-3.736366958759e+000,-8.950004833000e+001,3.174515518503e+000
    7626,-3.515507740771e+000,-8.950004833000e+001,2.777073574891e+000
    7627,-3.670970681413e+000,-8.950004833000e+001,3.405639657424e+000
    7628,-3.670970681413e+000,-8.950004833000e+001,3.674519450052e+000
    7629,-3.498835529582e+000,-8.950004833000e+001,3.254216440402e+000
    7630,-3.634351997102e+000,-8.950004833000e+001,3.963418217092e+000
    7631,-3.634351997102e+000,-8.950004833000e+001,4.232298009720e+000
    7632,-3.396820567925e+000,-8.950004833000e+001,3.774239346362e+000
    7633,-3.631040313220e+000,-8.950004833000e+001,4.527182840794e+000
    7634,-3.631040313220e+000,-8.950004833000e+001,4.796062633423e+000
    7635,-3.356890199732e+000,-8.950004833000e+001,4.358022944476e+000
    7636,-3.631829535548e+000,-8.950004833000e+001,5.092493742157e+000
    7637,-3.631829535548e+000,-8.950004833000e+001,5.361373534785e+000
    7638,-3.354367738179e+000,-8.950004833000e+001,4.949338884285e+000
    7639,-3.635276515002e+000,-8.950004833000e+001,5.659012291846e+000
    7640,-3.635276515002e+000,-8.950004833000e+001,5.950298733860e+000
    7641,-3.358603939960e+000,-8.950004833000e+001,5.543408750080e+000
    7642,-3.642502080308e+000,-8.950004833000e+001,6.239371560658e+000
    7643,-3.642502080308e+000,-8.950004833000e+001,6.508251353286e+000
    7644,-3.369276484720e+000,-8.950004833000e+001,6.130120333938e+000
    7645,-3.690932052470e+000,-8.950004833000e+001,6.760207934578e+000
    7646,-3.690932052470e+000,-8.950004833000e+001,7.029087727206e+000
    7647,-3.424932022188e+000,-8.950004833000e+001,6.671149742028e+000
    7648,-3.643559380013e+000,-8.950004833000e+001,7.290077991344e+000
    7649,-3.643559380013e+000,-8.950004833000e+001,7.558957783972e+000
    7650,-3.425989321893e+000,-8.950004833000e+001,7.184096587458e+000
    7651,-3.642995993709e+000,-8.950004833000e+001,7.841608737242e+000
    7652,-3.642995993709e+000,-8.950004833000e+001,8.110488529870e+000
    7653,-3.378053263132e+000,-8.950004833000e+001,7.727737804865e+000
    7654,-3.693102255648e+000,-8.950004833000e+001,8.366594491856e+000
    7655,-3.693102255648e+000,-8.950004833000e+001,8.657880933870e+000
    7656,-3.427596138767e+000,-8.950004833000e+001,8.266494720120e+000
    7657,-3.642779590389e+000,-8.950004833000e+001,8.918023515050e+000
    7658,-3.642779590389e+000,-8.950004833000e+001,9.186903307679e+000
    7659,-3.427379735447e+000,-8.950004833000e+001,8.782743263287e+000
    7660,-3.643094161748e+000,-8.950004833000e+001,9.471474281804e+000
    7661,-3.643094161748e+000,-8.950004833000e+001,9.740354074432e+000
    7662,-3.377371641547e+000,-8.950004833000e+001,9.327456818592e+000
    7663,-3.690513128307e+000,-8.950004833000e+001,1.000044068293e+001
    7664,-3.690513128307e+000,-8.950004833000e+001,1.026932047556e+001
    7665,-3.425105179465e+000,-8.950004833000e+001,9.872114401219e+000
    7666,-3.642952672215e+000,-8.950004833000e+001,1.053003009080e+001
    7667,-3.642952672215e+000,-8.950004833000e+001,1.079890988342e+001
    7668,-3.424963689932e+000,-8.950004833000e+001,1.039291062495e+001
    7669,-3.636524669242e+000,-8.950004833000e+001,1.109325062841e+001
    7670,-3.636524669242e+000,-8.950004833000e+001,1.138453707043e+001
    7671,-3.370975230866e+000,-8.950004833000e+001,1.094796098518e+001
    7672,-3.643123347557e+000,-8.950004833000e+001,1.167942386196e+001
    7673,-3.643123347557e+000,-8.950004833000e+001,1.194830365459e+001
    7674,-3.371145906208e+000,-8.950004833000e+001,1.153718852170e+001
    7675,-3.694648415325e+000,-8.950004833000e+001,1.221386084658e+001
    7676,-3.694648415325e+000,-8.950004833000e+001,1.252755393798e+001
    7677,-3.429269652292e+000,-8.950004833000e+001,1.209763250522e+001
    7678,-3.643672081555e+000,-8.950004833000e+001,1.279063107287e+001
    7679,-3.643672081555e+000,-8.950004833000e+001,1.305951086550e+001
    7680,-3.429818386290e+000,-8.950004833000e+001,1.262626683210e+001
    7681,-3.639838663470e+000,-8.950004833000e+001,1.335383769490e+001
    7682,-3.639838663470e+000,-8.950004833000e+001,1.362271748753e+001
    7683,-3.375008634435e+000,-8.950004833000e+001,1.318367079640e+001
    7684,-3.639956679719e+000,-8.950004833000e+001,1.392087450178e+001
    7685,-3.639956679719e+000,-8.950004833000e+001,1.418975429441e+001
    7686,-3.371293232599e+000,-8.950004833000e+001,1.377615464005e+001
    7687,-3.645005813282e+000,-8.950004833000e+001,1.448296748702e+001
    7688,-3.645005813282e+000,-8.950004833000e+001,1.477425392903e+001
    7689,-3.376460382411e+000,-8.950004833000e+001,1.436752484691e+001
    7690,-3.690665086055e+000,-8.950004833000e+001,1.503254574989e+001
    7691,-3.690665086055e+000,-8.950004833000e+001,1.530142554252e+001
    7692,-3.427168788747e+000,-8.950004833000e+001,1.491902986039e+001
    7693,-3.644823471294e+000,-8.950004833000e+001,1.556412356771e+001
    7694,-3.644823471294e+000,-8.950004833000e+001,1.585541000973e+001
    7695,-3.426986446759e+000,-8.950004833000e+001,1.544001970643e+001
    7696,-3.634949930157e+000,-8.950004833000e+001,1.614977756841e+001
    7697,-3.634949930157e+000,-8.950004833000e+001,1.641865736104e+001
    7698,-3.371271290862e+000,-8.950004833000e+001,1.599708529031e+001
    7699,-3.639011661113e+000,-8.950004833000e+001,1.671907159478e+001
    7700,-3.639011661113e+000,-8.950004833000e+001,1.701035803679e+001
    7701,-3.365459480681e+000,-8.950004833000e+001,1.659186708273e+001
    7702,-3.645611271497e+000,-8.950004833000e+001,1.730600121163e+001
    7703,-3.645611271497e+000,-8.950004833000e+001,1.757488100426e+001
    7704,-3.376120822021e+000,-8.950004833000e+001,1.718792449132e+001
    7705,-3.693939053380e+000,-8.950004833000e+001,1.783423118328e+001
    7706,-3.693939053380e+000,-8.950004833000e+001,1.812551762529e+001
    7707,-3.431048214287e+000,-8.950004833000e+001,1.774291784517e+001
    7708,-3.645471507091e+000,-8.950004833000e+001,1.839039035989e+001
    7709,-3.645471507091e+000,-8.950004833000e+001,1.865927015252e+001
    7710,-3.430908449881e+000,-8.950004833000e+001,1.826714075879e+001
    7711,-3.646077654611e+000,-8.950004833000e+001,1.894716601277e+001
    7712,-3.646077654611e+000,-8.950004833000e+001,1.923845245479e+001
    7713,-3.383047051112e+000,-8.950004833000e+001,1.881990935364e+001
    7714,-3.690421847676e+000,-8.950004833000e+001,1.950065625178e+001
    7715,-3.690421847676e+000,-8.950004833000e+001,1.976953604441e+001
    7716,-3.427997391697e+000,-8.950004833000e+001,1.937000901089e+001
    7717,-3.645458234986e+000,-8.950004833000e+001,2.003330103278e+001
    7718,-3.645458234986e+000,-8.950004833000e+001,2.032458747479e+001
    7719,-3.427377972072e+000,-8.950004833000e+001,1.989597779625e+001
    7720,-3.635720274903e+000,-8.950004833000e+001,2.061904715066e+001
    7721,-3.635720274903e+000,-8.950004833000e+001,2.088792694329e+001
    7722,-3.372676399299e+000,-8.950004833000e+001,2.045420246049e+001
    7723,-3.643309882592e+000,-8.950004833000e+001,2.117835390228e+001
    7724,-3.643309882592e+000,-8.950004833000e+001,2.144723369491e+001
    7725,-3.370528046906e+000,-8.950004833000e+001,2.103908909535e+001
    7726,-3.690292956618e+000,-8.950004833000e+001,2.170606480753e+001
    7727,-3.690292956618e+000,-8.950004833000e+001,2.197494460016e+001
    7728,-3.425100728620e+000,-8.950004833000e+001,2.158834716696e+001
    7729,-3.644932949781e+000,-8.950004833000e+001,2.223647960934e+001
    7730,-3.644932949781e+000,-8.950004833000e+001,2.252776605136e+001
    7731,-3.426723795809e+000,-8.950004833000e+001,2.210871328877e+001
    7732,-3.636354293836e+000,-8.950004833000e+001,2.281934871146e+001
    7733,-3.636354293836e+000,-8.950004833000e+001,2.308822850409e+001
    7734,-3.372785133027e+000,-8.950004833000e+001,2.266183095805e+001
    7735,-3.649342007832e+000,-8.950004833000e+001,2.338119813208e+001
    7736,-3.649342007832e+000,-8.950004833000e+001,2.367248457409e+001
    7737,-3.377194191078e+000,-8.950004833000e+001,2.324638324615e+001
    7738,-3.691177044699e+000,-8.950004833000e+001,2.393730124633e+001
    7739,-3.691177044699e+000,-8.950004833000e+001,2.420618103896e+001
    7740,-3.432016941941e+000,-8.950004833000e+001,2.380416954638e+001
    7741,-3.646928552000e+000,-8.950004833000e+001,2.446726611642e+001
    7742,-3.646928552000e+000,-8.950004833000e+001,2.473614590905e+001
    7743,-3.429603486109e+000,-8.950004833000e+001,2.433007129608e+001
    7744,-3.638048871972e+000,-8.950004833000e+001,2.502686346766e+001
    7745,-3.638048871972e+000,-8.950004833000e+001,2.531814990967e+001
    7746,-3.376475313382e+000,-8.950004833000e+001,2.488187393215e+001
    7747,-3.644427396539e+000,-8.950004833000e+001,2.560874891850e+001
    7748,-3.644427396539e+000,-8.950004833000e+001,2.587762871113e+001
    7749,-3.373974157921e+000,-8.950004833000e+001,2.546319049958e+001
    7750,-3.690877062622e+000,-8.950004833000e+001,2.613667334779e+001
    7751,-3.690877062622e+000,-8.950004833000e+001,2.640555314042e+001
    7752,-3.426802348571e+000,-8.950004833000e+001,2.601283414507e+001
    7753,-3.642399998002e+000,-8.950004833000e+001,2.666357293038e+001
    7754,-3.642399998002e+000,-8.950004833000e+001,2.693245272301e+001
    7755,-3.424774950034e+000,-8.950004833000e+001,2.652989857170e+001
    7756,-3.635518066498e+000,-8.950004833000e+001,2.722164055482e+001
    7757,-3.635518066498e+000,-8.950004833000e+001,2.749052034745e+001
    7758,-3.369415953910e+000,-8.950004833000e+001,2.707710619347e+001
    7759,-3.641266176423e+000,-8.950004833000e+001,2.778015822701e+001
    7760,-3.641266176423e+000,-8.950004833000e+001,2.804903801964e+001
    7761,-3.368282132331e+000,-8.950004833000e+001,2.765593190484e+001
    7762,-3.692408179305e+000,-8.950004833000e+001,2.830741307571e+001
    7763,-3.692408179305e+000,-8.950004833000e+001,2.859869951772e+001
    7764,-3.425172245138e+000,-8.950004833000e+001,2.820394484047e+001
    7765,-3.644727354312e+000,-8.950004833000e+001,2.885937378453e+001
    7766,-3.644727354312e+000,-8.950004833000e+001,2.912825357716e+001
    7767,-3.428633423027e+000,-8.950004833000e+001,2.872299416335e+001
    7768,-3.649979005008e+000,-8.950004833000e+001,2.941631192605e+001
    7769,-3.649979005008e+000,-8.950004833000e+001,2.970759836806e+001
    7770,-3.386204248730e+000,-8.950004833000e+001,2.927172677905e+001
    7771,-3.692468971481e+000,-8.950004833000e+001,2.997261496569e+001
    7772,-3.692468971481e+000,-8.950004833000e+001,3.024149475832e+001
    7773,-3.433945865899e+000,-8.950004833000e+001,2.982480172557e+001
    7774,-3.648432661247e+000,-8.950004833000e+001,3.050074635348e+001
    7775,-3.648432661247e+000,-8.950004833000e+001,3.076962614611e+001
    7776,-3.432399522138e+000,-8.950004833000e+001,3.034906991835e+001
    7777,-3.636659253380e+000,-8.950004833000e+001,3.105717924306e+001
    7778,-3.636659253380e+000,-8.950004833000e+001,3.132605903569e+001
    7779,-3.376589804038e+000,-8.950004833000e+001,3.089587461047e+001
    7780,-3.640325488530e+000,-8.950004833000e+001,3.161906447528e+001
    7781,-3.640325488530e+000,-8.950004833000e+001,3.188794426791e+001
    7782,-3.368482631320e+000,-8.950004833000e+001,3.147643314701e+001
    7783,-3.649030112344e+000,-8.950004833000e+001,3.217654663314e+001
    7784,-3.649030112344e+000,-8.950004833000e+001,3.244542642577e+001
    7785,-3.380853490284e+000,-8.950004833000e+001,3.205804095183e+001
    7786,-3.695026946059e+000,-8.950004833000e+001,3.270535768572e+001
    7787,-3.695026946059e+000,-8.950004833000e+001,3.299664412774e+001
    7788,-3.435554947814e+000,-8.950004833000e+001,3.260657457702e+001
    7789,-3.651851123347e+000,-8.950004833000e+001,3.326382309706e+001
    7790,-3.651851123347e+000,-8.950004833000e+001,3.355510953908e+001
    7791,-3.438375958816e+000,-8.950004833000e+001,3.313368480630e+001
    7792,-3.638757804325e+000,-8.950004833000e+001,3.384714718715e+001
    7793,-3.638757804325e+000,-8.950004833000e+001,3.411602697978e+001
    7794,-3.382106817082e+000,-8.950004833000e+001,3.369290142370e+001
    7795,-3.647611211359e+000,-8.950004833000e+001,3.440534108362e+001
    7796,-3.647611211359e+000,-8.950004833000e+001,3.467422087625e+001
    7797,-3.377866905094e+000,-8.950004833000e+001,3.427425317562e+001
    7798,-3.690754974843e+000,-8.950004833000e+001,3.493467311002e+001
    7799,-3.690754974843e+000,-8.950004833000e+001,3.520355290265e+001
    7800,-3.429864075611e+000,-8.950004833000e+001,3.482401951323e+001
    7801,-3.647562684417e+000,-8.950004833000e+001,3.546942158962e+001
    7802,-3.647562684417e+000,-8.950004833000e+001,3.576070803163e+001
    7803,-3.429815548669e+000,-8.950004833000e+001,3.535034043397e+001
    7804,-3.643450665819e+000,-8.950004833000e+001,3.605001654329e+001
    7805,-3.643450665819e+000,-8.950004833000e+001,3.631889633592e+001
    7806,-3.382511239646e+000,-8.950004833000e+001,3.590551763259e+001
    7807,-3.689512962410e+000,-8.950004833000e+001,3.657815374415e+001
    7808,-3.689512962410e+000,-8.950004833000e+001,3.684703353678e+001
    7809,-3.424461517639e+000,-8.950004833000e+001,3.645408355248e+001
    7810,-3.641375821940e+000,-8.950004833000e+001,3.710543435834e+001
    7811,-3.641375821940e+000,-8.950004833000e+001,3.737431415097e+001
    7812,-3.422386673760e+000,-8.950004833000e+001,3.697174178228e+001
    7813,-3.636222504292e+000,-8.950004833000e+001,3.766561055312e+001
    7814,-3.636222504292e+000,-8.950004833000e+001,3.793449034575e+001
    7815,-3.369096215642e+000,-8.950004833000e+001,3.752143900599e+001
    7816,-3.643357480044e+000,-8.950004833000e+001,3.823067282910e+001
    7817,-3.643357480044e+000,-8.950004833000e+001,3.852195927112e+001
    7818,-3.371077873746e+000,-8.950004833000e+001,3.810891789150e+001
    7819,-3.689657962092e+000,-8.950004833000e+001,3.878437379547e+001
    7820,-3.689657962092e+000,-8.950004833000e+001,3.905325358810e+001
    7821,-3.424513331547e+000,-8.950004833000e+001,3.866751489921e+001
    7822,-3.645977756835e+000,-8.950004833000e+001,3.931774283157e+001
    7823,-3.645977756835e+000,-8.950004833000e+001,3.960902927358e+001
    7824,-3.427133608337e+000,-8.950004833000e+001,3.919441866703e+001
    7825,-3.644026647073e+000,-8.950004833000e+001,3.989954134159e+001
    7826,-3.644026647073e+000,-8.950004833000e+001,4.016842113422e+001
    7827,-3.381502293318e+000,-8.950004833000e+001,3.974941997851e+001
    7828,-3.692768382281e+000,-8.950004833000e+001,4.043257197238e+001
    7829,-3.692768382281e+000,-8.950004833000e+001,4.072385841440e+001
    7830,-3.428292918764e+000,-8.950004833000e+001,4.030408288468e+001
    7831,-3.639351920318e+000,-8.950004833000e+001,4.098368129260e+001
    7832,-3.639351920318e+000,-8.950004833000e+001,4.125256108523e+001
    7833,-3.423618192009e+000,-8.950004833000e+001,4.082805660105e+001
    7834,-3.631365691857e+000,-8.950004833000e+001,4.154474696357e+001
    7835,-3.631365691857e+000,-8.950004833000e+001,4.181362675620e+001
    7836,-3.362215501585e+000,-8.950004833000e+001,4.138006535759e+001
    7837,-3.631966722979e+000,-8.950004833000e+001,4.211069218791e+001
    7838,-3.631966722979e+000,-8.950004833000e+001,4.237957198054e+001
    7839,-3.354830304246e+000,-8.950004833000e+001,4.196931666764e+001
    7840,-3.643826334833e+000,-8.950004833000e+001,4.267083219887e+001
    7841,-3.643826334833e+000,-8.950004833000e+001,4.296211864089e+001
    7842,-3.367290947223e+000,-8.950004833000e+001,4.255764231769e+001
    7843,-3.691410408694e+000,-8.950004833000e+001,4.322040734226e+001
    7844,-3.691410408694e+000,-8.950004833000e+001,4.348928713489e+001
    7845,-3.426734632937e+000,-8.950004833000e+001,4.310719123740e+001
    7846,-3.650238867145e+000,-8.950004833000e+001,4.375326426833e+001
    7847,-3.650238867145e+000,-8.950004833000e+001,4.404455071034e+001
    7848,-3.433147165249e+000,-8.950004833000e+001,4.362945707221e+001
    7849,-3.644693449496e+000,-8.950004833000e+001,4.433144708719e+001
    7850,-3.644693449496e+000,-8.950004833000e+001,4.460032687982e+001
    7851,-3.386430206051e+000,-8.950004833000e+001,4.418033058250e+001
    7852,-3.689030295131e+000,-8.950004833000e+001,4.486148999171e+001
    7853,-3.689030295131e+000,-8.950004833000e+001,4.513036978434e+001
    7854,-3.425221634036e+000,-8.950004833000e+001,4.472839007124e+001
    7855,-3.632829975735e+000,-8.950004833000e+001,4.539354568672e+001
    7856,-3.632829975735e+000,-8.950004833000e+001,4.568483212873e+001
    7857,-3.413358160276e+000,-8.950004833000e+001,4.525272908551e+001
    7858,-3.573333726600e+000,-8.950004833000e+001,4.602000410842e+001
    7859,-2.568281237759e+000,-8.950004833000e+001,2.454744051340e+000
    7860,-3.462191770858e+000,-8.950004833000e+001,2.233890660956e+000
    7861,-2.991704112490e+000,-8.950004833000e+001,4.590200688885e+001
    7862,-2.756003204415e+000,-8.950004833000e+001,4.163421275180e+001
    7863,-2.806875511845e+000,-8.950004833000e+001,3.709258599998e+001
    7864,-2.405165787218e+000,-8.950004833000e+001,3.047513008709e+000
    7865,-2.405165787218e+000,-8.950004833000e+001,2.689006618538e+000
    7866,-3.207922484441e+000,-8.950004833000e+001,2.483028446057e+000
    7867,-3.297661591745e+000,-8.950004833000e+001,4.585107696758e+001
    7868,-2.704491379674e+000,-8.950004833000e+001,3.233684910871e+000
    7869,-3.051200361626e+000,-8.950004833000e+001,4.556683490917e+001
    7870,-3.103455256748e+000,-8.950004833000e+001,4.522436157587e+001
    7871,-3.115318730509e+000,-8.950004833000e+001,4.470002256160e+001
    7872,-3.080599237093e+000,-8.950004833000e+001,4.432685905718e+001
    7873,-3.086144654742e+000,-8.950004833000e+001,4.403996268033e+001
    7874,-3.121404281427e+000,-8.950004833000e+001,4.364409732552e+001
    7875,-3.114991749116e+000,-8.950004833000e+001,4.312183149070e+001
    7876,-3.074246501541e+000,-8.950004833000e+001,4.276418272195e+001
    7877,-3.062386889688e+000,-8.950004833000e+001,4.247292250361e+001
    7878,-3.054795975008e+000,-8.950004833000e+001,4.212947537968e+001
    7879,-3.073814935933e+000,-8.950004833000e+001,3.734820889400e+001
    7880,-3.107310109202e+000,-8.950004833000e+001,3.697451970982e+001
    7881,-3.116415728397e+000,-8.950004833000e+001,4.028432514382e+001
    7882,-3.083889420578e+000,-8.950004833000e+001,3.989127400022e+001
    7883,-3.085840530340e+000,-8.950004833000e+001,3.960076193221e+001
    7884,-3.114199059949e+000,-8.950004833000e+001,3.921528439014e+001
    7885,-3.111578783158e+000,-8.950004833000e+001,3.868838062232e+001
    7886,-3.081788662741e+000,-8.950004833000e+001,3.830237265313e+001
    7887,-3.074653686988e+000,-8.950004833000e+001,3.800619016978e+001
    7888,-3.068661618285e+000,-8.950004833000e+001,3.763950529615e+001
    7889,-2.785945843727e+000,-8.950004833000e+001,2.669264611010e+000
    7890,-3.083573194350e+000,-8.950004833000e+001,3.577494973950e+001
    7891,-3.116092642672e+000,-8.950004833000e+001,3.537600623176e+001
    7892,-3.116141169613e+000,-8.950004833000e+001,3.484968531102e+001
    7893,-3.084252014858e+000,-8.950004833000e+001,3.444961657677e+001
    7894,-3.075398607825e+000,-8.950004833000e+001,3.416030247292e+001
    7895,-3.073967471058e+000,-8.950004833000e+001,3.382507325729e+001
    7896,-3.087060790079e+000,-8.950004833000e+001,3.353303560921e+001
    7897,-3.125952537826e+000,-8.950004833000e+001,3.315441375596e+001
    7898,-3.123131526823e+000,-8.950004833000e+001,3.262730352668e+001
    7899,-3.081550382389e+000,-8.950004833000e+001,3.225868612062e+001
    7900,-3.072845758575e+000,-8.950004833000e+001,3.197008375538e+001
    7901,-3.067824587064e+000,-8.950004833000e+001,3.161993895125e+001
    7902,-3.072833565423e+000,-8.950004833000e+001,3.099900740155e+001
    7903,-3.064158351914e+000,-8.950004833000e+001,3.132693351166e+001
    7904,-3.084606973291e+000,-8.950004833000e+001,3.071145430460e+001
    7905,-3.120705154548e+000,-8.950004833000e+001,3.031975014167e+001
    7906,-3.122251498309e+000,-8.950004833000e+001,2.979548194889e+001
    7907,-3.089086317191e+000,-8.950004833000e+001,2.940493916122e+001
    7908,-3.083834666495e+000,-8.950004833000e+001,2.911688081233e+001
    7909,-3.113198037293e+000,-8.950004833000e+001,2.873681482603e+001
    7910,-3.109736859404e+000,-8.950004833000e+001,2.821776550316e+001
    7911,-3.071981045702e+000,-8.950004833000e+001,2.784748913474e+001
    7912,-3.066232935777e+000,-8.950004833000e+001,2.755785125518e+001
    7913,-3.076799280798e+000,-8.950004833000e+001,2.690749998067e+001
    7914,-3.113024930504e+000,-8.950004833000e+001,2.653328955870e+001
    7915,-3.115052329041e+000,-8.950004833000e+001,2.601622513207e+001
    7916,-3.075524198293e+000,-8.950004833000e+001,2.563047879738e+001
    7917,-3.069145673726e+000,-8.950004833000e+001,2.533987978855e+001
    7918,-3.069519367828e+000,-8.950004833000e+001,2.500338931204e+001
    7919,-3.078399047856e+000,-8.950004833000e+001,2.471267175343e+001
    7920,-3.116621077273e+000,-8.950004833000e+001,2.432911427670e+001
    7921,-3.119034533105e+000,-8.950004833000e+001,2.380321252700e+001
    7922,-3.079328946566e+000,-8.950004833000e+001,2.340719074230e+001
    7923,-3.066341232571e+000,-8.950004833000e+001,2.311422111431e+001
    7924,-3.069515058125e+000,-8.950004833000e+001,2.277393128870e+001
    7925,-3.078093714069e+000,-8.950004833000e+001,2.248234862859e+001
    7926,-3.113346776689e+000,-8.950004833000e+001,2.211923988770e+001
    7927,-3.111723709500e+000,-8.950004833000e+001,2.159887376590e+001
    7928,-3.072108654616e+000,-8.950004833000e+001,2.121606904845e+001
    7929,-3.067845522435e+000,-8.950004833000e+001,2.056779486205e+001
    7930,-3.064519046927e+000,-8.950004833000e+001,2.092564208946e+001
    7931,-3.077583482518e+000,-8.950004833000e+001,2.027333518618e+001
    7932,-3.114490281389e+000,-8.950004833000e+001,1.988345800818e+001
    7933,-3.115109701015e+000,-8.950004833000e+001,1.935748922281e+001
    7934,-3.084107361957e+000,-8.950004833000e+001,1.898204671637e+001
    7935,-3.083501214437e+000,-8.950004833000e+001,1.869415085612e+001
    7936,-3.117135076221e+000,-8.950004833000e+001,1.831429251568e+001
    7937,-3.117274840627e+000,-8.950004833000e+001,1.779006960206e+001
    7938,-3.081009839973e+000,-8.950004833000e+001,1.741317773044e+001
    7939,-3.074410229589e+000,-8.950004833000e+001,1.711753455560e+001
    7940,-3.063692704422e+000,-8.950004833000e+001,1.645822173981e+001
    7941,-3.067806457408e+000,-8.950004833000e+001,1.611715095881e+001
    7942,-3.077679998545e+000,-8.950004833000e+001,1.582278340013e+001
    7943,-3.113952172098e+000,-8.950004833000e+001,1.545673523123e+001
    7944,-3.114134514086e+000,-8.950004833000e+001,1.493574538518e+001
    7945,-3.077321379690e+000,-8.950004833000e+001,1.457961749904e+001
    7946,-3.072272246127e+000,-8.950004833000e+001,1.428640430643e+001
    7947,-3.068450325214e+000,-8.950004833000e+001,1.393146067790e+001
    7948,-3.075380892850e+000,-8.950004833000e+001,1.327284382665e+001
    7949,-3.068332308965e+000,-8.950004833000e+001,1.363330366365e+001
    7950,-3.079214310935e+000,-8.950004833000e+001,1.297851699725e+001
    7951,-3.113934019975e+000,-8.950004833000e+001,1.261220238750e+001
    7952,-3.113385285977e+000,-8.950004833000e+001,1.208356806062e+001
    7953,-3.076264950105e+000,-8.950004833000e+001,1.171181646264e+001
    7954,-3.072209614436e+000,-8.950004833000e+001,1.077501631238e+001
    7955,-3.113843166129e+000,-8.950004833000e+001,1.038148109525e+001
    7956,-3.113984655662e+000,-8.950004833000e+001,9.860684871518e+000
    7957,-3.076126633846e+000,-8.950004833000e+001,9.464779650765e+000
    7958,-3.075812062487e+000,-8.950004833000e+001,9.180208676641e+000
    7959,-3.112399676537e+000,-8.950004833000e+001,8.798663702356e+000
    7960,-3.112616079857e+000,-8.950004833000e+001,8.282415159190e+000
    7961,-3.078073024953e+000,-8.950004833000e+001,7.907876242972e+000
    7962,-3.078636411257e+000,-8.950004833000e+001,7.625225289702e+000
    7963,-3.111490659091e+000,-8.950004833000e+001,7.238551354187e+000
    7964,-3.110433359386e+000,-8.950004833000e+001,6.725604508757e+000
    7965,-3.075685054199e+000,-8.950004833000e+001,6.356301555886e+000
    7966,-3.068459488893e+000,-8.950004833000e+001,6.067228729089e+000
    7967,-3.062146423125e+000,-8.950004833000e+001,5.730224348228e+000
    7968,-3.058699443672e+000,-8.950004833000e+001,5.432585591166e+000
    7969,-3.055373848671e+000,-8.950004833000e+001,5.102773391818e+000
    7970,-3.054584626343e+000,-8.950004833000e+001,4.806342283084e+000
    7971,-3.056684675541e+000,-8.950004833000e+001,4.470335228660e+000
    7972,-3.059996359423e+000,-8.950004833000e+001,4.175450397586e+000
    7973,-3.073177124888e+000,-8.950004833000e+001,3.813490378468e+000
    7974,-3.038005187242e+000,-8.950004833000e+001,2.713549766579e+000
    7975,-3.296866377415e+000,-8.950004833000e+001,2.761576168824e+000
    7976,-3.345590443572e+000,-8.950004833000e+001,3.007594895414e+000
    7977,-2.874889736701e+000,-8.950004833000e+001,2.947812333777e+000
    7978,-3.056037533653e+000,-8.950004833000e+001,4.147405403977e+001
    7979,-3.054194943886e+000,-8.950004833000e+001,4.183240994797e+001
    7980,-3.109795809200e+000,-8.950004833000e+001,3.524591611428e+000
    7981,-3.065781611462e+000,-8.950004833000e+001,1.106935705737e+001
    7982,-3.069666271789e+000,-8.950004833000e+001,1.141692967110e+001
    7983,-3.079461175753e+000,-8.950004833000e+001,3.606425825115e+001
    7984,-3.155447249672e+000,-8.950004833000e+001,3.671611888826e+001
    7985,-3.111741001642e+000,-8.950004833000e+001,4.080829886018e+001
    7986,-3.064023762115e+000,-8.950004833000e+001,4.118186816143e+001
    7987,-3.280194166227e+000,-8.950004833000e+001,3.238719034335e+000
    7988,-3.109384953081e+000,-8.950004833000e+001,3.645686148003e+001
    7989,-3.159284933098e+000,-8.950004833000e+001,3.511013754479e+001
    7990,-3.157879265207e+000,-8.950004833000e+001,3.895079514667e+001
    7991,-3.159655576144e+000,-8.950004833000e+001,4.496118567349e+001
    7992,-3.165157463605e+000,-8.950004833000e+001,4.054847598198e+001
    7993,-3.162575822976e+000,-8.950004833000e+001,4.338012019207e+001
    7994,-3.169128360539e+000,-8.950004833000e+001,3.288723478663e+001
    7995,-3.164741464782e+000,-8.950004833000e+001,3.006049854651e+001
    7996,-3.160878862287e+000,-8.950004833000e+001,2.847614055922e+001
    7997,-3.161501995124e+000,-8.950004833000e+001,2.627526976873e+001
    7998,-3.069917349294e+000,-8.950004833000e+001,2.719668781247e+001
    7999,-3.160869569972e+000,-8.950004833000e+001,2.406802919924e+001
    8000,-3.158706783526e+000,-8.950004833000e+001,2.185770487852e+001
    8001,-3.159453894080e+000,-8.950004833000e+001,1.961969301981e+001
    8002,-3.165602622510e+000,-8.950004833000e+001,1.804941978108e+001
    8003,-3.067754435378e+000,-8.950004833000e+001,1.675863597356e+001
    8004,-3.159793786858e+000,-8.950004833000e+001,1.519403720604e+001
    8005,-3.164910353746e+000,-8.950004833000e+001,1.234912525261e+001
    8006,-3.161403622221e+000,-8.950004833000e+001,1.012077148002e+001
    8007,-3.162722341796e+000,-8.950004833000e+001,8.538521121176e+000
    8008,-3.158863331548e+000,-8.950004833000e+001,6.977561090049e+000
    8009,-2.956550723190e+000,-8.950004833000e+001,3.277970066440e+000
    8010,-3.908502110590e+000,-8.937504826250e+001,2.093573019311e+000
    8011,-3.908502110590e+000,-8.937504826250e+001,2.272826214397e+000
    8012,-3.908502110590e+000,-8.937504826250e+001,2.429672760097e+000
    8013,-3.908502110590e+000,-8.937504826250e+001,2.653739253954e+000
    8014,-3.908502110590e+000,-8.937504826250e+001,2.900212397196e+000
    8015,-3.908502110590e+000,-8.937504826250e+001,9.711833810447e+000
    8016,-3.908502110590e+000,-8.937504826250e+001,1.000312025246e+001
    8017,-3.908502110590e+000,-8.937504826250e+001,1.975001273524e+001
    8018,-3.908502110590e+000,-8.937504826250e+001,2.004129917725e+001
    8019,-3.908502110590e+000,-8.937504826250e+001,2.033258561927e+001
    8020,-3.908502110590e+000,-8.937504826250e+001,2.062387206128e+001
    8021,-3.908502110590e+000,-8.937504826250e+001,2.860063924259e+001
    8022,-3.908502110590e+000,-8.937504826250e+001,2.889192568460e+001
    8023,-3.908502110590e+000,-8.937504826250e+001,3.628611998188e+001
    8024,-3.908502110590e+000,-8.937504826250e+001,3.657740642389e+001
    8025,-3.908502110590e+000,-8.937504826250e+001,3.684628621652e+001
    8026,-3.908502110590e+000,-8.937504826250e+001,3.713757265854e+001
    8027,-3.908502110590e+000,-8.937504826250e+001,4.571931937326e+001
    8028,-3.908502110590e+000,-8.937504826250e+001,4.598819916589e+001
    8029,-3.908502110590e+000,-8.937504826250e+001,4.625707895851e+001
    8030,-3.908502110590e+000,-8.937504826250e+001,4.643633215360e+001
    8031,-3.908502110590e+000,-8.937504826250e+001,4.661558534869e+001
    8032,-3.908502110590e+000,-8.937504826250e+001,3.774071723238e+000
    8033,-3.908502110590e+000,-8.937504826250e+001,3.505191930610e+000
    8034,-3.908502110590e+000,-8.937504826250e+001,8.008928457135e+000
    8035,-3.908502110590e+000,-8.937504826250e+001,7.740048664506e+000
    8036,-3.908502110590e+000,-8.937504826250e+001,9.151667575805e+000
    8037,-3.908502110590e+000,-8.937504826250e+001,8.882787783177e+000
    8038,-3.908502110590e+000,-8.937504826250e+001,9.442954017819e+000
    8039,-3.908502110590e+000,-8.937504826250e+001,1.027200004509e+001
    8040,-3.908502110590e+000,-8.937504826250e+001,1.085457292912e+001
    8041,-3.908502110590e+000,-8.937504826250e+001,1.058569313649e+001
    8042,-3.908502110590e+000,-8.937504826250e+001,1.199731204779e+001
    8043,-3.908502110590e+000,-8.937504826250e+001,1.172843225516e+001
    8044,-3.908502110590e+000,-8.937504826250e+001,1.316245781584e+001
    8045,-3.908502110590e+000,-8.937504826250e+001,1.289357802322e+001
    8046,-3.908502110590e+000,-8.937504826250e+001,1.860727361657e+001
    8047,-3.908502110590e+000,-8.937504826250e+001,1.833839382394e+001
    8048,-3.908502110590e+000,-8.937504826250e+001,1.948113294261e+001
    8049,-3.908502110590e+000,-8.937504826250e+001,2.089275185391e+001
    8050,-3.908502110590e+000,-8.937504826250e+001,2.147532473794e+001
    8051,-3.908502110590e+000,-8.937504826250e+001,2.120644494531e+001
    8052,-3.908502110590e+000,-8.937504826250e+001,2.743549347453e+001
    8053,-3.908502110590e+000,-8.937504826250e+001,2.716661368190e+001
    8054,-3.908502110590e+000,-8.937504826250e+001,2.799565970917e+001
    8055,-3.908502110590e+000,-8.937504826250e+001,2.772677991655e+001
    8056,-3.908502110590e+000,-8.937504826250e+001,2.830935280057e+001
    8057,-3.908502110590e+000,-8.937504826250e+001,2.916080547723e+001
    8058,-3.908502110590e+000,-8.937504826250e+001,3.030354459590e+001
    8059,-3.908502110590e+000,-8.937504826250e+001,3.003466480327e+001
    8060,-3.908502110590e+000,-8.937504826250e+001,3.512097421382e+001
    8061,-3.908502110590e+000,-8.937504826250e+001,3.485209442120e+001
    8062,-3.908502110590e+000,-8.937504826250e+001,3.601724018925e+001
    8063,-3.908502110590e+000,-8.937504826250e+001,3.740645245117e+001
    8064,-3.908502110590e+000,-8.937504826250e+001,3.796661868581e+001
    8065,-3.908502110590e+000,-8.937504826250e+001,3.769773889318e+001
    8066,-3.908502110590e+000,-8.937504826250e+001,4.341143448653e+001
    8067,-3.908502110590e+000,-8.937504826250e+001,4.314255469390e+001
    8068,-3.908502110590e+000,-8.937504826250e+001,4.455417360520e+001
    8069,-3.908502110590e+000,-8.937504826250e+001,4.428529381257e+001
    8070,-3.908502110590e+000,-8.937504826250e+001,4.511433983984e+001
    8071,-3.908502110590e+000,-8.937504826250e+001,4.484546004722e+001
    8072,-3.908502110590e+000,-8.937504826250e+001,2.945209191924e+001
    8073,-3.908502110590e+000,-8.937504826250e+001,4.542803293124e+001
    8074,-3.908502110590e+000,-8.937504826250e+001,3.191498839210e+000
    8075,-3.908502110590e+000,-8.937504826250e+001,1.889856005858e+001
    8076,-3.908502110590e+000,-8.937504826250e+001,3.572595374724e+001
    8077,-3.908502110590e+000,-8.937504826250e+001,4.065358165253e+000
    8078,-3.908502110590e+000,-8.937504826250e+001,4.334237957881e+000
    8079,-3.908502110590e+000,-8.937504826250e+001,4.625524399895e+000
    8080,-3.908502110590e+000,-8.937504826250e+001,4.894404192523e+000
    8081,-3.908502110590e+000,-8.937504826250e+001,5.185690634537e+000
    8082,-3.908502110590e+000,-8.937504826250e+001,7.448762222492e+000
    8083,-3.908502110590e+000,-8.937504826250e+001,8.300214899149e+000
    8084,-3.908502110590e+000,-8.937504826250e+001,8.591501341163e+000
    8085,-3.908502110590e+000,-8.937504826250e+001,1.114585937113e+001
    8086,-3.908502110590e+000,-8.937504826250e+001,1.143714581315e+001
    8087,-3.908502110590e+000,-8.937504826250e+001,1.228859848980e+001
    8088,-3.908502110590e+000,-8.937504826250e+001,1.260229158120e+001
    8089,-3.908502110590e+000,-8.937504826250e+001,1.345374425786e+001
    8090,-3.908502110590e+000,-8.937504826250e+001,1.629938872984e+001
    8091,-3.908502110590e+000,-8.937504826250e+001,1.659067517186e+001
    8092,-3.908502110590e+000,-8.937504826250e+001,1.688196161387e+001
    8093,-3.908502110590e+000,-8.937504826250e+001,1.717324805588e+001
    8094,-3.908502110590e+000,-8.937504826250e+001,1.744212784851e+001
    8095,-3.908502110590e+000,-8.937504826250e+001,1.775582093991e+001
    8096,-3.908502110590e+000,-8.937504826250e+001,1.804710738193e+001
    8097,-3.908502110590e+000,-8.937504826250e+001,3.543466730522e+001
    8098,-3.908502110590e+000,-8.937504826250e+001,1.918984650060e+001
    8099,-3.908502110590e+000,-8.937504826250e+001,2.974337836126e+001
    8100,-3.908502110590e+000,-8.937504826250e+001,5.454570427166e+000
    8101,-3.908502110590e+000,-8.937504826250e+001,7.179882429864e+000
    8102,-3.908502110590e+000,-8.937504826250e+001,1.603050893721e+001
    8103,-3.908502110590e+000,-8.937504826250e+001,2.176661117995e+001
    8104,-3.908502110590e+000,-8.937504826250e+001,2.203549097258e+001
    8105,-3.908502110590e+000,-8.937504826250e+001,2.232677741459e+001
    8106,-3.908502110590e+000,-8.937504826250e+001,2.261806385661e+001
    8107,-3.908502110590e+000,-8.937504826250e+001,2.290935029862e+001
    8108,-3.908502110590e+000,-8.937504826250e+001,2.317823009125e+001
    8109,-3.908502110590e+000,-8.937504826250e+001,2.346951653326e+001
    8110,-3.908502110590e+000,-8.937504826250e+001,2.376080297528e+001
    8111,-3.908502110590e+000,-8.937504826250e+001,2.405208941729e+001
    8112,-3.908502110590e+000,-8.937504826250e+001,2.575499477060e+001
    8113,-3.908502110590e+000,-8.937504826250e+001,2.604628121262e+001
    8114,-3.908502110590e+000,-8.937504826250e+001,2.631516100525e+001
    8115,-3.908502110590e+000,-8.937504826250e+001,2.660644744726e+001
    8116,-3.908502110590e+000,-8.937504826250e+001,2.687532723989e+001
    8117,-3.908502110590e+000,-8.937504826250e+001,3.059483103791e+001
    8118,-3.908502110590e+000,-8.937504826250e+001,3.086371083054e+001
    8119,-3.908502110590e+000,-8.937504826250e+001,3.115499727256e+001
    8120,-3.908502110590e+000,-8.937504826250e+001,3.400064174454e+001
    8121,-3.908502110590e+000,-8.937504826250e+001,3.429192818655e+001
    8122,-3.908502110590e+000,-8.937504826250e+001,3.456080797918e+001
    8123,-3.908502110590e+000,-8.937504826250e+001,3.825790512782e+001
    8124,-3.908502110590e+000,-8.937504826250e+001,3.854919156984e+001
    8125,-3.908502110590e+000,-8.937504826250e+001,3.886288466124e+001
    8126,-3.908502110590e+000,-8.937504826250e+001,3.913176445386e+001
    8127,-3.908502110590e+000,-8.937504826250e+001,3.942305089588e+001
    8128,-3.908502110590e+000,-8.937504826250e+001,3.971433733789e+001
    8129,-3.908502110590e+000,-8.937504826250e+001,4.000562377991e+001
    8130,-3.908502110590e+000,-8.937504826250e+001,4.224628871848e+001
    8131,-3.908502110590e+000,-8.937504826250e+001,4.255998180988e+001
    8132,-3.908502110590e+000,-8.937504826250e+001,4.285126825189e+001
    8133,-3.908502110590e+000,-8.937504826250e+001,4.370272092855e+001
    8134,-3.908502110590e+000,-8.937504826250e+001,4.399400737056e+001
    8135,-3.908502110590e+000,-8.937504826250e+001,2.432096920992e+001
    8136,-3.908502110590e+000,-8.937504826250e+001,4.027450357253e+001
    8137,-3.908502110590e+000,-8.937504826250e+001,3.373176195191e+001
    8138,-3.908502110590e+000,-8.937504826250e+001,1.372262405049e+001
    8139,-3.908502110590e+000,-8.937504826250e+001,4.197740892585e+001
    8140,-3.908502110590e+000,-8.937504826250e+001,2.548611497798e+001
    8141,-3.908502110590e+000,-8.937504826250e+001,3.142387706519e+001
    8142,-3.908502110590e+000,-8.937504826250e+001,5.745856869180e+000
    8143,-3.908502110590e+000,-8.937504826250e+001,6.037143311194e+000
    8144,-3.908502110590e+000,-8.937504826250e+001,6.328429753208e+000
    8145,-3.908502110590e+000,-8.937504826250e+001,6.866189338464e+000
    8146,-3.908502110590e+000,-8.937504826250e+001,1.403631714189e+001
    8147,-3.908502110590e+000,-8.937504826250e+001,1.430519693451e+001
    8148,-3.908502110590e+000,-8.937504826250e+001,1.459648337653e+001
    8149,-3.908502110590e+000,-8.937504826250e+001,1.515664961117e+001
    8150,-3.908502110590e+000,-8.937504826250e+001,1.544793605319e+001
    8151,-3.908502110590e+000,-8.937504826250e+001,1.573922249520e+001
    8152,-3.908502110590e+000,-8.937504826250e+001,2.463466230132e+001
    8153,-3.908502110590e+000,-8.937504826250e+001,2.519482853596e+001
    8154,-3.908502110590e+000,-8.937504826250e+001,3.173757015658e+001
    8155,-3.908502110590e+000,-8.937504826250e+001,3.227532974184e+001
    8156,-3.908502110590e+000,-8.937504826250e+001,3.256661618386e+001
    8157,-3.908502110590e+000,-8.937504826250e+001,3.285790262587e+001
    8158,-3.908502110590e+000,-8.937504826250e+001,3.314918906788e+001
    8159,-3.908502110590e+000,-8.937504826250e+001,3.344047550990e+001
    8160,-3.908502110590e+000,-8.937504826250e+001,4.056579001455e+001
    8161,-3.908502110590e+000,-8.937504826250e+001,4.085707645656e+001
    8162,-3.908502110590e+000,-8.937504826250e+001,4.114836289858e+001
    8163,-3.908502110590e+000,-8.937504826250e+001,4.168612248383e+001
    8164,-3.908502110590e+000,-8.937504826250e+001,6.597309545836e+000
    8165,-3.908502110590e+000,-8.937504826250e+001,1.488776981854e+001
    8166,-3.908502110590e+000,-8.937504826250e+001,3.200644994921e+001
    8167,-3.908502110590e+000,-8.937504826250e+001,4.141724269120e+001
    8168,-3.908502110590e+000,-8.937504826250e+001,2.490354209395e+001
    8169,-2.252861216544e+000,-8.925004819500e+001,4.639151885483e+001
    8170,-2.287178244317e+000,-8.925004819500e+001,4.546402758621e+001
    8171,-2.287178244317e+000,-8.925004819500e+001,4.582253397638e+001
    8172,-2.255054472750e+000,-8.925004819500e+001,4.401792475024e+001
    8173,-2.255054472750e+000,-8.925004819500e+001,4.437643114041e+001
    8174,-2.317275309136e+000,-8.925004819500e+001,4.260805472331e+001
    8175,-2.317275309136e+000,-8.925004819500e+001,4.296656111348e+001
    8176,-2.318526512433e+000,-8.925004819500e+001,4.097852138493e+001
    8177,-2.318526512433e+000,-8.925004819500e+001,4.140424772326e+001
    8178,-2.257837000370e+000,-8.925004819500e+001,3.955749989630e+001
    8179,-2.257837000370e+000,-8.925004819500e+001,3.991600628647e+001
    8180,-2.323603581062e+000,-8.925004819500e+001,3.799671892219e+001
    8181,-2.323603581062e+000,-8.925004819500e+001,3.844485190990e+001
    8182,-2.259030446622e+000,-8.925004819500e+001,3.653893044593e+001
    8183,-2.259030446622e+000,-8.925004819500e+001,3.689743683610e+001
    8184,-2.273677572684e+000,-8.925004819500e+001,3.503272026780e+001
    8185,-2.273677572684e+000,-8.925004819500e+001,3.541363330736e+001
    8186,-2.273141019737e+000,-8.925004819500e+001,3.348026547201e+001
    8187,-2.273141019737e+000,-8.925004819500e+001,3.383877186219e+001
    8188,-2.258493049625e+000,-8.925004819500e+001,3.202037856531e+001
    8189,-2.258493049625e+000,-8.925004819500e+001,3.237888495548e+001
    8190,-2.264261501155e+000,-8.925004819500e+001,3.054074593786e+001
    8191,-2.264261501155e+000,-8.925004819500e+001,3.096647227619e+001
    8192,-2.321755999480e+000,-8.925004819500e+001,2.904033026302e+001
    8193,-2.321755999480e+000,-8.925004819500e+001,2.942124330258e+001
    8194,-2.269130368485e+000,-8.925004819500e+001,2.761853472783e+001
    8195,-2.269130368485e+000,-8.925004819500e+001,2.797704111800e+001
    8196,-2.271580469948e+000,-8.925004819500e+001,2.604945112974e+001
    8197,-2.271580469948e+000,-8.925004819500e+001,2.643036416930e+001
    8198,-2.261762420103e+000,-8.925004819500e+001,2.462245148642e+001
    8199,-2.261762420103e+000,-8.925004819500e+001,2.498095787659e+001
    8200,-2.261944508197e+000,-8.925004819500e+001,2.307427630061e+001
    8201,-2.261944508197e+000,-8.925004819500e+001,2.345518934017e+001
    8202,-2.262560135181e+000,-8.925004819500e+001,2.166508249497e+001
    8203,-2.262560135181e+000,-8.925004819500e+001,2.202358888514e+001
    8204,-2.272245853824e+000,-8.925004819500e+001,2.013211040764e+001
    8205,-2.272245853824e+000,-8.925004819500e+001,2.053543009658e+001
    8206,-2.265496051525e+000,-8.925004819500e+001,1.870801357984e+001
    8207,-2.265496051525e+000,-8.925004819500e+001,1.906651997001e+001
    8208,-2.268115101486e+000,-8.925004819500e+001,1.721443170062e+001
    8209,-2.268115101486e+000,-8.925004819500e+001,1.761775138956e+001
    8210,-2.265911947338e+000,-8.925004819500e+001,1.575251143421e+001
    8211,-2.265911947338e+000,-8.925004819500e+001,1.611101782438e+001
    8212,-2.264179380596e+000,-8.925004819500e+001,1.431750753664e+001
    8213,-2.264179380596e+000,-8.925004819500e+001,1.465360727743e+001
    8214,-2.265010028942e+000,-8.925004819500e+001,1.282593692094e+001
    8215,-2.265010028942e+000,-8.925004819500e+001,1.320684996050e+001
    8216,-2.267192866417e+000,-8.925004819500e+001,1.135846157621e+001
    8217,-2.267192866417e+000,-8.925004819500e+001,1.171696796639e+001
    8218,-2.324753567290e+000,-8.925004819500e+001,9.804864894652e+000
    8219,-2.324753567290e+000,-8.925004819500e+001,1.023059123298e+001
    8220,-2.256217720723e+000,-8.925004819500e+001,8.358541076444e+000
    8221,-2.256217720723e+000,-8.925004819500e+001,8.717047466616e+000
    8222,-2.267093951245e+000,-8.925004819500e+001,6.977738122078e+000
    8223,-2.267093951245e+000,-8.925004819500e+001,7.313837862863e+000
    8224,-2.264901737429e+000,-8.925004819500e+001,5.454287757387e+000
    8225,-2.264901737429e+000,-8.925004819500e+001,5.812794147558e+000
    8226,-2.254715528995e+000,-8.925004819500e+001,4.051158848559e+000
    8227,-2.254715528995e+000,-8.925004819500e+001,4.409665238730e+000
    8228,-2.295457820177e+000,-8.925004819500e+001,2.646963315321e+000
    8229,-2.295457820177e+000,-8.925004819500e+001,3.005469705492e+000
    8230,-2.238078708562e+000,-8.925004819500e+001,2.205606266240e+000
    8231,-3.097043774385e+000,-8.925004819500e+001,2.171914965850e+000
    8232,-2.799422613669e+000,-8.925004819500e+001,2.171914965850e+000
    8233,-3.481652357562e+000,-8.925004819500e+001,2.055770095067e+000
    8234,-3.255972735695e+000,-8.925004819500e+001,2.055770095067e+000
    8235,-3.738066265737e+000,-8.925004819500e+001,2.501489333789e+000
    8236,-3.738066265737e+000,-8.925004819500e+001,2.344642788089e+000
    8237,-3.611137515425e+000,-8.925004819500e+001,3.506961581401e+000
    8238,-3.611137515425e+000,-8.925004819500e+001,3.193268490002e+000
    8239,-3.591228667165e+000,-8.925004819500e+001,4.708926359956e+000
    8240,-3.591228667165e+000,-8.925004819500e+001,4.417639917942e+000
    8241,-3.607361757337e+000,-8.925004819500e+001,5.902678363686e+000
    8242,-3.607361757337e+000,-8.925004819500e+001,5.611391921672e+000
    8243,-3.610810006220e+000,-8.925004819500e+001,7.055910546153e+000
    8244,-3.610810006220e+000,-8.925004819500e+001,6.742217454753e+000
    8245,-3.591878542703e+000,-8.925004819500e+001,8.257951205181e+000
    8246,-3.591878542703e+000,-8.925004819500e+001,7.966664763167e+000
    8247,-3.607793922361e+000,-8.925004819500e+001,9.453593492533e+000
    8248,-3.607793922361e+000,-8.925004819500e+001,9.162307050519e+000
    8249,-3.614878139607e+000,-8.925004819500e+001,1.061316359394e+001
    8250,-3.614878139607e+000,-8.925004819500e+001,1.029947050254e+001
    8251,-3.608564426016e+000,-8.925004819500e+001,1.181138610640e+001
    8252,-3.608564426016e+000,-8.925004819500e+001,1.152009966438e+001
    8253,-3.608915951260e+000,-8.925004819500e+001,1.293776625017e+001
    8254,-3.608915951260e+000,-8.925004819500e+001,1.264647980815e+001
    8255,-3.603173954222e+000,-8.925004819500e+001,1.416681081946e+001
    8256,-3.603173954222e+000,-8.925004819500e+001,1.385311772806e+001
    8257,-3.665281197522e+000,-8.925004819500e+001,1.532749758601e+001
    8258,-3.665281197522e+000,-8.925004819500e+001,1.503621114399e+001
    8259,-3.596376841301e+000,-8.925004819500e+001,1.648560604759e+001
    8260,-3.596376841301e+000,-8.925004819500e+001,1.619431960558e+001
    8261,-3.613969717166e+000,-8.925004819500e+001,1.771414071978e+001
    8262,-3.613969717166e+000,-8.925004819500e+001,1.740044762838e+001
    8263,-3.608571366036e+000,-8.925004819500e+001,1.884586056102e+001
    8264,-3.608571366036e+000,-8.925004819500e+001,1.855457411901e+001
    8265,-3.595918091987e+000,-8.925004819500e+001,2.004250290941e+001
    8266,-3.595918091987e+000,-8.925004819500e+001,1.975121646740e+001
    8267,-3.667476088801e+000,-8.925004819500e+001,2.123152744207e+001
    8268,-3.667476088801e+000,-8.925004819500e+001,2.091783435067e+001
    8269,-3.594859275614e+000,-8.925004819500e+001,2.239565158369e+001
    8270,-3.594859275614e+000,-8.925004819500e+001,2.210436514168e+001
    8271,-3.612387454838e+000,-8.925004819500e+001,2.359255518222e+001
    8272,-3.612387454838e+000,-8.925004819500e+001,2.330126874020e+001
    8273,-3.614973877691e+000,-8.925004819500e+001,2.475273442686e+001
    8274,-3.614973877691e+000,-8.925004819500e+001,2.443904133546e+001
    8275,-3.599262628268e+000,-8.925004819500e+001,2.595488769586e+001
    8276,-3.599262628268e+000,-8.925004819500e+001,2.566360125384e+001
    8277,-3.667167835867e+000,-8.925004819500e+001,2.711610178192e+001
    8278,-3.667167835867e+000,-8.925004819500e+001,2.682481533991e+001
    8279,-3.602580076441e+000,-8.925004819500e+001,2.830752981385e+001
    8280,-3.602580076441e+000,-8.925004819500e+001,2.799383672245e+001
    8281,-3.667386422918e+000,-8.925004819500e+001,2.947237289154e+001
    8282,-3.667386422918e+000,-8.925004819500e+001,2.918108644953e+001
    8283,-3.603322103174e+000,-8.925004819500e+001,3.063419503430e+001
    8284,-3.603322103174e+000,-8.925004819500e+001,3.034290859229e+001
    8285,-3.602264119764e+000,-8.925004819500e+001,3.186983105616e+001
    8286,-3.602264119764e+000,-8.925004819500e+001,3.155613796476e+001
    8287,-3.666444557383e+000,-8.925004819500e+001,3.303119032566e+001
    8288,-3.666444557383e+000,-8.925004819500e+001,3.273990388365e+001
    8289,-3.614614481396e+000,-8.925004819500e+001,3.418616482242e+001
    8290,-3.614614481396e+000,-8.925004819500e+001,3.389487838040e+001
    8291,-3.610972744796e+000,-8.925004819500e+001,3.534255724375e+001
    8292,-3.610972744796e+000,-8.925004819500e+001,3.502886415235e+001
    8293,-3.595047869811e+000,-8.925004819500e+001,3.655341394124e+001
    8294,-3.595047869811e+000,-8.925004819500e+001,3.626212749923e+001
    8295,-3.607411854383e+000,-8.925004819500e+001,3.775658645815e+001
    8296,-3.607411854383e+000,-8.925004819500e+001,3.746530001614e+001
    8297,-3.609568464131e+000,-8.925004819500e+001,3.891655039645e+001
    8298,-3.609568464131e+000,-8.925004819500e+001,3.860285730505e+001
    8299,-3.594851467961e+000,-8.925004819500e+001,4.012309574452e+001
    8300,-3.594851467961e+000,-8.925004819500e+001,3.983180930251e+001
    8301,-3.665360008958e+000,-8.925004819500e+001,4.128173320766e+001
    8302,-3.665360008958e+000,-8.925004819500e+001,4.099044676565e+001
    8303,-3.615507326744e+000,-8.925004819500e+001,4.247315104601e+001
    8304,-3.615507326744e+000,-8.925004819500e+001,4.215945795461e+001
    8305,-3.608631130064e+000,-8.925004819500e+001,4.360204287620e+001
    8306,-3.608631130064e+000,-8.925004819500e+001,4.331075643418e+001
    8307,-3.596917804423e+000,-8.925004819500e+001,4.479623553226e+001
    8308,-3.596917804423e+000,-8.925004819500e+001,4.450494909024e+001
    8309,-3.635208522857e+000,-8.925004819500e+001,4.601749277389e+001
    8310,-3.635208522857e+000,-8.925004819500e+001,4.574861298126e+001
    8311,-3.749836524911e+000,-8.925004819500e+001,4.661558534869e+001
    8312,-3.215588946052e+000,-8.925004819500e+001,4.657479314724e+001
    8313,-3.436341065258e+000,-8.925004819500e+001,4.657479314724e+001
    8314,-2.374740476248e+000,-8.925004819500e+001,4.614952191929e+001
    8315,-2.724417674315e+000,-8.925004819500e+001,4.593904343101e+001
    8316,-2.268606096889e+000,-8.925004819500e+001,4.471318999312e+001
    8317,-2.268606096889e+000,-8.925004819500e+001,4.511650968206e+001
    8318,-2.263888099454e+000,-8.925004819500e+001,4.332960938901e+001
    8319,-2.263888099454e+000,-8.925004819500e+001,4.366570912979e+001
    8320,-2.280915220803e+000,-8.925004819500e+001,4.183838299623e+001
    8321,-2.280915220803e+000,-8.925004819500e+001,4.221929603579e+001
    8322,-2.266560230934e+000,-8.925004819500e+001,4.026484123590e+001
    8323,-2.266560230934e+000,-8.925004819500e+001,4.060094097669e+001
    8324,-2.652310811817e+000,-8.925004819500e+001,3.860550257952e+001
    8325,-2.266208277005e+000,-8.925004819500e+001,3.884428213576e+001
    8326,-2.266208277005e+000,-8.925004819500e+001,3.920278852593e+001
    8327,-2.265963813316e+000,-8.925004819500e+001,3.724712793322e+001
    8328,-2.265963813316e+000,-8.925004819500e+001,3.760563432339e+001
    8329,-2.262636878111e+000,-8.925004819500e+001,3.577965887328e+001
    8330,-2.262636878111e+000,-8.925004819500e+001,3.618297856223e+001
    8331,-2.329679284911e+000,-8.925004819500e+001,3.423768796629e+001
    8332,-2.329679284911e+000,-8.925004819500e+001,3.464100765523e+001
    8333,-2.312209876443e+000,-8.925004819500e+001,3.275307750459e+001
    8334,-2.312209876443e+000,-8.925004819500e+001,3.308917724538e+001
    8335,-2.581045281000e+000,-8.925004819500e+001,3.111899723200e+001
    8336,-2.254284826096e+000,-8.925004819500e+001,3.130752222837e+001
    8337,-2.254284826096e+000,-8.925004819500e+001,3.166602861854e+001
    8338,-2.269655658860e+000,-8.925004819500e+001,2.980105418092e+001
    8339,-2.269655658860e+000,-8.925004819500e+001,3.015956057109e+001
    8340,-2.270291283607e+000,-8.925004819500e+001,2.832735968760e+001
    8341,-2.270291283607e+000,-8.925004819500e+001,2.866345942838e+001
    8342,-2.322998580828e+000,-8.925004819500e+001,2.680543096290e+001
    8343,-2.322998580828e+000,-8.925004819500e+001,2.720875065184e+001
    8344,-2.258958784369e+000,-8.925004819500e+001,2.532557876497e+001
    8345,-2.258958784369e+000,-8.925004819500e+001,2.568408515514e+001
    8346,-2.312030109569e+000,-8.925004819500e+001,2.385768431782e+001
    8347,-2.312030109569e+000,-8.925004819500e+001,2.423859735738e+001
    8348,-2.256485486136e+000,-8.925004819500e+001,2.237048346607e+001
    8349,-2.256485486136e+000,-8.925004819500e+001,2.272898985624e+001
    8350,-2.316182145375e+000,-8.925004819500e+001,2.092493749254e+001
    8351,-2.316182145375e+000,-8.925004819500e+001,2.128344388271e+001
    8352,-2.261169216409e+000,-8.925004819500e+001,1.941394875742e+001
    8353,-2.261169216409e+000,-8.925004819500e+001,1.977245514759e+001
    8354,-2.314735169357e+000,-8.925004819500e+001,1.799973937430e+001
    8355,-2.314735169357e+000,-8.925004819500e+001,1.833583911508e+001
    8356,-2.263061972645e+000,-8.925004819500e+001,1.646166305041e+001
    8357,-2.263061972645e+000,-8.925004819500e+001,1.684257608996e+001
    8358,-2.314769923513e+000,-8.925004819500e+001,1.501981283417e+001
    8359,-2.314769923513e+000,-8.925004819500e+001,1.537831922434e+001
    8360,-2.255101157780e+000,-8.925004819500e+001,1.358204340796e+001
    8361,-2.255101157780e+000,-8.925004819500e+001,1.396295644752e+001
    8362,-2.314590962033e+000,-8.925004819500e+001,1.209192602917e+001
    8363,-2.314590962033e+000,-8.925004819500e+001,1.245043241935e+001
    8364,-2.268615320762e+000,-8.925004819500e+001,1.064266310747e+001
    8365,-2.268615320762e+000,-8.925004819500e+001,1.100116949765e+001
    8366,-2.270071264709e+000,-8.925004819500e+001,9.060036032568e+000
    8367,-2.270071264709e+000,-8.925004819500e+001,9.418542422739e+000
    8368,-2.255818494480e+000,-8.925004819500e+001,7.659739197479e+000
    8369,-2.255818494480e+000,-8.925004819500e+001,8.018245587651e+000
    8370,-2.319980587569e+000,-8.925004819500e+001,6.190499877187e+000
    8371,-2.319980587569e+000,-8.925004819500e+001,6.593819566130e+000
    8372,-2.254899797946e+000,-8.925004819500e+001,4.749041377524e+000
    8373,-2.254899797946e+000,-8.925004819500e+001,5.107547767695e+000
    8374,-2.263367487565e+000,-8.925004819500e+001,3.373848799622e+000
    8375,-2.263367487565e+000,-8.925004819500e+001,3.709948540407e+000
    8376,-2.596035482489e+000,-8.925004819500e+001,2.378083522693e+000
    8377,-3.219117817776e+000,-8.925004819500e+001,2.290958587306e+000
    8378,-3.795914995586e+000,-8.925004819500e+001,2.042962710179e+000
    8379,-3.634292908310e+000,-8.925004819500e+001,2.042962710179e+000
    8380,-3.795914995586e+000,-8.925004819500e+001,2.199809255879e+000
    8381,-3.663613248287e+000,-8.925004819500e+001,2.941034953418e+000
    8382,-3.663613248287e+000,-8.925004819500e+001,2.694561810175e+000
    8383,-3.593966478436e+000,-8.925004819500e+001,4.109665613633e+000
    8384,-3.593966478436e+000,-8.925004819500e+001,3.818379171619e+000
    8385,-3.593587372992e+000,-8.925004819500e+001,5.308911381436e+000
    8386,-3.593587372992e+000,-8.925004819500e+001,5.017624939422e+000
    8387,-3.665663231384e+000,-8.925004819500e+001,6.464334785251e+000
    8388,-3.665663231384e+000,-8.925004819500e+001,6.173048343237e+000
    8389,-3.594963593924e+000,-8.925004819500e+001,7.655652713415e+000
    8390,-3.594963593924e+000,-8.925004819500e+001,7.364366271401e+000
    8391,-3.594832469946e+000,-8.925004819500e+001,8.858877459388e+000
    8392,-3.594832469946e+000,-8.925004819500e+001,8.567591017374e+000
    8393,-3.666709388367e+000,-8.925004819500e+001,1.001560437258e+001
    8394,-3.666709388367e+000,-8.925004819500e+001,9.724317930564e+000
    8395,-3.599169362379e+000,-8.925004819500e+001,1.121613737735e+001
    8396,-3.599169362379e+000,-8.925004819500e+001,1.092485093533e+001
    8397,-3.664980041084e+000,-8.925004819500e+001,1.237312493860e+001
    8398,-3.664980041084e+000,-8.925004819500e+001,1.208183849659e+001
    8399,-3.600288669148e+000,-8.925004819500e+001,1.353712942117e+001
    8400,-3.600288669148e+000,-8.925004819500e+001,1.324584297915e+001
    8401,-3.609384458712e+000,-8.925004819500e+001,1.476550718688e+001
    8402,-3.609384458712e+000,-8.925004819500e+001,1.447422074486e+001
    8403,-3.608567621793e+000,-8.925004819500e+001,1.589035908737e+001
    8404,-3.608567621793e+000,-8.925004819500e+001,1.559907264536e+001
    8405,-3.599409861346e+000,-8.925004819500e+001,1.709012549589e+001
    8406,-3.599409861346e+000,-8.925004819500e+001,1.679883905388e+001
    8407,-3.665300854989e+000,-8.925004819500e+001,1.828194207040e+001
    8408,-3.665300854989e+000,-8.925004819500e+001,1.799065562838e+001
    8409,-3.595702677457e+000,-8.925004819500e+001,1.944043018268e+001
    8410,-3.595702677457e+000,-8.925004819500e+001,1.914914374066e+001
    8411,-3.610382987853e+000,-8.925004819500e+001,2.064126814169e+001
    8412,-3.610382987853e+000,-8.925004819500e+001,2.034998169968e+001
    8413,-3.611249249979e+000,-8.925004819500e+001,2.179971906533e+001
    8414,-3.611249249979e+000,-8.925004819500e+001,2.150843262331e+001
    8415,-3.595036492359e+000,-8.925004819500e+001,2.299635370795e+001
    8416,-3.595036492359e+000,-8.925004819500e+001,2.270506726594e+001
    8417,-3.664942333371e+000,-8.925004819500e+001,2.415982236051e+001
    8418,-3.664942333371e+000,-8.925004819500e+001,2.386853591849e+001
    8419,-3.596504589732e+000,-8.925004819500e+001,2.535171812059e+001
    8420,-3.596504589732e+000,-8.925004819500e+001,2.506043167858e+001
    8421,-3.610668060842e+000,-8.925004819500e+001,2.655221814406e+001
    8422,-3.610668060842e+000,-8.925004819500e+001,2.626093170205e+001
    8423,-3.614472173184e+000,-8.925004819500e+001,2.768484918878e+001
    8424,-3.614472173184e+000,-8.925004819500e+001,2.739356274676e+001
    8425,-3.611854154718e+000,-8.925004819500e+001,2.890573101125e+001
    8426,-3.611854154718e+000,-8.925004819500e+001,2.861444456923e+001
    8427,-3.613298263853e+000,-8.925004819500e+001,3.003502713091e+001
    8428,-3.613298263853e+000,-8.925004819500e+001,2.974374068889e+001
    8429,-3.595240708196e+000,-8.925004819500e+001,3.124105951663e+001
    8430,-3.595240708196e+000,-8.925004819500e+001,3.094977307462e+001
    8431,-3.613401782274e+000,-8.925004819500e+001,3.246771977691e+001
    8432,-3.613401782274e+000,-8.925004819500e+001,3.217643333490e+001
    8433,-3.617362954573e+000,-8.925004819500e+001,3.359600160048e+001
    8434,-3.617362954573e+000,-8.925004819500e+001,3.330471515847e+001
    8435,-3.668634228311e+000,-8.925004819500e+001,3.475511093066e+001
    8436,-3.668634228311e+000,-8.925004819500e+001,3.446382448865e+001
    8437,-3.599749394426e+000,-8.925004819500e+001,3.594620020083e+001
    8438,-3.599749394426e+000,-8.925004819500e+001,3.565491375881e+001
    8439,-3.594907188501e+000,-8.925004819500e+001,3.715887145091e+001
    8440,-3.594907188501e+000,-8.925004819500e+001,3.686758500889e+001
    8441,-3.665574011471e+000,-8.925004819500e+001,3.832250849647e+001
    8442,-3.665574011471e+000,-8.925004819500e+001,3.803122205445e+001
    8443,-3.594743294112e+000,-8.925004819500e+001,3.951980669787e+001
    8444,-3.594743294112e+000,-8.925004819500e+001,3.922852025586e+001
    8445,-3.607898869755e+000,-8.925004819500e+001,4.071857646771e+001
    8446,-3.607898869755e+000,-8.925004819500e+001,4.042729002570e+001
    8447,-3.611782928992e+000,-8.925004819500e+001,4.185213262290e+001
    8448,-3.611782928992e+000,-8.925004819500e+001,4.156084618089e+001
