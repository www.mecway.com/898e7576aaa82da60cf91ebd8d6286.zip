    5633,-2.187501181250e+000,-9.017059794536e+001,1.485710002049e+001
    5634,-2.187501181250e+000,-9.017694322297e+001,6.086039609606e+000
    5635,-2.187501181250e+000,-9.010586721625e+001,4.592181031684e+000
    5636,-2.187501181250e+000,-9.005524890206e+001,3.101867170862e+000
    5637,-2.187501181250e+000,-9.801454460789e+001,9.065613890129e+000
    5638,-2.187501181250e+000,-9.770357568779e+001,8.717317546082e+000
    5639,-2.187501181250e+000,-9.652968649230e+001,1.866932542045e+001
    5640,-2.187501181250e+000,-9.345750647293e+001,4.071002958281e+001
    5641,-2.187501181250e+000,-9.182976114401e+001,4.619398720261e+001
    5642,-2.187501181250e+000,-9.039298528511e+001,3.857902272036e+001
    5643,-2.187501181250e+000,-9.021287024021e+001,4.241139930630e+001
    5644,-2.187501181250e+000,-9.017116284757e+001,4.007419299168e+001
    5645,-2.187501181250e+000,-9.066219842444e+001,2.975560236331e+001
    5646,-2.187501181250e+000,-9.014934121880e+001,2.819339954546e+001
    5647,-2.187501181250e+000,-9.002590113043e+001,2.958918115214e+001
    5648,-2.187501181250e+000,-9.011741401215e+001,1.923369075736e+001
    5649,-2.187501181250e+000,-9.019135070086e+001,7.572305268857e+000
    5650,-2.187501181250e+000,-9.014144254731e+001,8.993685444629e+000
    5651,-2.187501181250e+000,-9.650616310222e+001,1.641091997062e+001
    5652,-2.187501181250e+000,-9.056277666170e+001,2.175562026891e+001
    5653,-2.187501181250e+000,-9.732885341176e+001,2.840493010805e+000
    5654,-2.187501181250e+000,-9.703601538201e+001,2.827363711854e+000
    5655,-2.187501181250e+000,-9.671925551356e+001,2.746251551919e+000
    5656,-2.187501181250e+000,-9.643205532601e+001,2.733122229220e+000
    5657,-2.187501181250e+000,-9.690747365387e+001,3.097821085677e+000
    5658,-2.187501181250e+000,-9.613549471272e+001,2.698293782133e+000
    5659,-2.187501181250e+000,-9.583031862637e+001,2.682634719402e+000
    5660,-2.187501181250e+000,-9.629415317213e+001,2.981880478655e+000
    5661,-2.187501181250e+000,-9.550433409547e+001,2.682653691540e+000
    5662,-2.187501181250e+000,-9.520650441198e+001,2.687492882081e+000
    5663,-2.187501181250e+000,-9.567160802795e+001,2.947071003705e+000
    5664,-2.187501181250e+000,-9.492430289908e+001,2.704728863756e+000
    5665,-2.187501181250e+000,-9.463569419563e+001,2.713317734602e+000
    5666,-2.187501181250e+000,-9.506342198414e+001,2.964325957518e+000
    5667,-2.187501181250e+000,-9.435344449810e+001,2.741540018523e+000
    5668,-2.187501181250e+000,-9.407257594153e+001,2.744580806033e+000
    5669,-2.187501181250e+000,-9.449897077371e+001,3.009784223114e+000
    5670,-2.187501181250e+000,-9.378827653505e+001,2.727735333480e+000
    5671,-2.187501181250e+000,-9.346658557355e+001,2.722836963313e+000
    5672,-2.187501181250e+000,-9.393242166971e+001,3.021161034482e+000
    5673,-2.187501181250e+000,-9.312303179482e+001,2.718482271338e+000
    5674,-2.187501181250e+000,-9.283340068336e+001,2.718417990238e+000
    5675,-2.187501181250e+000,-9.330456848450e+001,2.999960869955e+000
    5676,-2.187501181250e+000,-9.255197524107e+001,2.720258186513e+000
    5677,-2.187501181250e+000,-9.226929546839e+001,2.716102786743e+000
    5678,-2.187501181250e+000,-9.267958926348e+001,2.997446374255e+000
    5679,-2.187501181250e+000,-9.198681816354e+001,2.693619348500e+000
    5680,-2.187501181250e+000,-9.171189851089e+001,2.679257813966e+000
    5681,-2.187501181250e+000,-9.211568651634e+001,2.976803132287e+000
    5682,-2.187501181250e+000,-9.144779417726e+001,2.633277004296e+000
    5683,-2.187501181250e+000,-9.113334051470e+001,2.636814625386e+000
    5684,-2.187501181250e+000,-9.156910487786e+001,2.908338884374e+000
    5685,-2.187501181250e+000,-9.730876165529e+001,1.099613539085e+001
    5686,-2.187501181250e+000,-9.738931045344e+001,1.065968309829e+001
    5687,-2.187501181250e+000,-9.799114049715e+001,4.429473450460e+000
    5688,-2.187501181250e+000,-9.803958099690e+001,3.947971085478e+000
    5689,-2.187501181250e+000,-9.708138698967e+001,1.142329203782e+001
    5690,-2.187501181250e+000,-9.732247563716e+001,1.240705384554e+001
    5691,-2.187501181250e+000,-9.675311505945e+001,1.786674406153e+001
    5692,-2.187501181250e+000,-9.674103929226e+001,1.652851355261e+001
    5693,-2.187501181250e+000,-9.710770916753e+001,1.623445771740e+001
    5694,-2.187501181250e+000,-9.296260060611e+001,4.040710878921e+001
    5695,-2.187501181250e+000,-9.269278321437e+001,4.115050431842e+001
    5696,-2.187501181250e+000,-9.237018910503e+001,4.043722316129e+001
    5697,-2.187501181250e+000,-9.646900557493e+001,1.958217346829e+001
    5698,-2.187501181250e+000,-9.556864364469e+001,2.267635769709e+001
    5699,-2.187501181250e+000,-9.485415521205e+001,2.809136561901e+001
    5700,-2.187501181250e+000,-9.487067770292e+001,2.765309893696e+001
    5701,-2.187501181250e+000,-9.743473772126e+001,8.307227640031e+000
    5702,-2.187501181250e+000,-9.739535426585e+001,7.881292935807e+000
    5703,-2.187501181250e+000,-9.518416236681e+001,2.996484508127e+001
    5704,-2.187501181250e+000,-9.453052252291e+001,3.535845168649e+001
    5705,-2.187501181250e+000,-9.313491236359e+001,3.999674842568e+001
    5706,-2.187501181250e+000,-9.318671634531e+001,3.959273433092e+001
    5707,-2.187501181250e+000,-9.344125748169e+001,3.816052637792e+001
    5708,-2.187501181250e+000,-9.362111286304e+001,3.769482368324e+001
    5709,-2.187501181250e+000,-9.267026771870e+001,4.168556882316e+001
    5710,-2.187501181250e+000,-9.169709261632e+001,4.586705666314e+001
    5711,-2.187501181250e+000,-9.201684386518e+001,4.586071853719e+001
    5712,-2.187501181250e+000,-9.256785206626e+001,4.389938166360e+001
    5713,-2.187501181250e+000,-9.263686144628e+001,4.341556791913e+001
    5714,-2.187501181250e+000,-9.286867035166e+001,4.572708960295e+001
    5715,-2.187501181250e+000,-9.281592746488e+001,4.539310174674e+001
    5716,-2.187501181250e+000,-9.061392003321e+001,4.300892645149e+001
    5717,-2.187501181250e+000,-9.059698970087e+001,4.339499676667e+001
    5718,-2.187501181250e+000,-9.048360057175e+001,4.459171902366e+001
    5719,-2.187501181250e+000,-9.042815077699e+001,4.496628771211e+001
    5720,-2.187501181250e+000,-9.058954284770e+001,4.058585414518e+001
    5721,-2.187501181250e+000,-9.057855341435e+001,4.097238937038e+001
    5722,-2.187501181250e+000,-9.097643695207e+001,3.837272167081e+001
    5723,-2.187501181250e+000,-9.096099380204e+001,3.879589539275e+001
    5724,-2.187501181250e+000,-8.994132381569e+001,4.604136301830e+001
    5725,-2.187501181250e+000,-9.019089886317e+001,4.600623114438e+001
    5726,-2.187501181250e+000,-9.235768807239e+001,4.591898295589e+001
    5727,-2.187501181250e+000,-9.268488560415e+001,4.594343720908e+001
    5728,-2.187501181250e+000,-9.066951683327e+001,4.385781014141e+001
    5729,-2.187501181250e+000,-9.067013967277e+001,4.422654591307e+001
    5730,-2.187501181250e+000,-9.097311549364e+001,4.453331900424e+001
    5731,-2.187501181250e+000,-9.108712746226e+001,4.370533251890e+001
    5732,-2.187501181250e+000,-9.056369394668e+001,4.137467997840e+001
    5733,-2.187501181250e+000,-9.058195148186e+001,4.180241869599e+001
    5734,-2.187501181250e+000,-9.096626168753e+001,4.115508193019e+001
    5735,-2.187501181250e+000,-9.076672953332e+001,4.222363194483e+001
    5736,-2.187501181250e+000,-9.076709902966e+001,4.258756639735e+001
    5737,-2.187501181250e+000,-9.116777932632e+001,4.282115909002e+001
    5738,-2.187501181250e+000,-9.113618027132e+001,4.197858578704e+001
    5739,-2.187501181250e+000,-9.042428365474e+001,3.606326701376e+001
    5740,-2.187501181250e+000,-9.046682807099e+001,3.639119645559e+001
    5741,-2.187501181250e+000,-9.050330386275e+001,2.641298758477e+001
    5742,-2.187501181250e+000,-9.046862870394e+001,2.676537448813e+001
    5743,-2.187501181250e+000,-9.040799673604e+001,3.356862243791e+001
    5744,-2.187501181250e+000,-8.998697625488e+001,3.330537789978e+001
    5745,-2.187501181250e+000,-9.035913381752e+001,2.574444031738e+001
    5746,-2.187501181250e+000,-9.042918260879e+001,2.605331060227e+001
    5747,-2.187501181250e+000,-9.018769218066e+001,2.219548165671e+001
    5748,-2.187501181250e+000,-9.039427563322e+001,1.842458701432e+001
    5749,-2.187501181250e+000,-9.037878650839e+001,1.876090372469e+001
    5750,-2.187501181250e+000,-9.058246442597e+001,7.430105714365e+000
    5751,-2.187501181250e+000,-9.057111763058e+001,7.798580252539e+000
    5752,-2.187501181250e+000,-9.045214865879e+001,1.702427995293e+001
    5753,-2.187501181250e+000,-9.046419176386e+001,1.735718072779e+001
    5754,-2.187501181250e+000,-9.035080092646e+001,1.626521363620e+001
    5755,-2.187501181250e+000,-9.040845169580e+001,1.667679435167e+001
    5756,-2.187501181250e+000,-9.030045019056e+001,1.535559215364e+001
    5757,-2.187501181250e+000,-9.032035186846e+001,1.576463028801e+001
    5758,-2.187501181250e+000,-9.058889836145e+001,5.881973948908e+000
    5759,-2.187501181250e+000,-9.062379498984e+001,6.249877484377e+000
    5760,-2.187501181250e+000,-9.031089734722e+001,1.510138253123e+001
    5761,-2.187501181250e+000,-9.047593293357e+001,1.036861489523e+001
    5762,-2.187501181250e+000,-9.037565110261e+001,1.073690614173e+001
    5763,-2.187501181250e+000,-9.659490697136e+001,1.674750016889e+001
    5764,-2.187501181250e+000,-9.063946492858e+001,6.665699166942e+000
    5765,-2.187501181250e+000,-9.063489375103e+001,7.040642959745e+000
    5766,-2.187501181250e+000,-9.101466068075e+001,7.266917943428e+000
    5767,-2.187501181250e+000,-9.105142006706e+001,6.461633506243e+000
    5768,-2.187501181250e+000,-9.042683675831e+001,8.814458093202e+000
    5769,-2.187501181250e+000,-9.042302460316e+001,9.169250529498e+000
    5770,-2.187501181250e+000,-9.048431872392e+001,4.394864857494e+000
    5771,-2.187501181250e+000,-9.048058997446e+001,4.762623004925e+000
    5772,-2.187501181250e+000,-9.032885760535e+001,2.886128255188e+000
    5773,-2.187501181250e+000,-9.036444797580e+001,3.244505712370e+000
    5774,-2.187501181250e+000,-9.655108656576e+001,1.693237160770e+001
    5775,-2.187501181250e+000,-9.655513347402e+001,9.273523053645e+000
    5776,-2.187501181250e+000,-9.674719720118e+001,9.359716940534e+000
    5777,-2.187501181250e+000,-9.732219295533e+001,7.324625223196e+000
    5778,-2.187501181250e+000,-9.734493595602e+001,6.812598096132e+000
    5779,-2.187501181250e+000,-9.247666608954e+001,8.992830184850e+000
    5780,-2.187501181250e+000,-9.273700845331e+001,8.978720528050e+000
    5781,-2.187501181250e+000,-9.303089242576e+001,8.991112086409e+000
    5782,-2.187501181250e+000,-9.333756991421e+001,8.998302117439e+000
    5783,-2.187501181250e+000,-9.291005945349e+001,8.703188185767e+000
    5784,-2.187501181250e+000,-9.366477470644e+001,9.023802251757e+000
    5785,-2.187501181250e+000,-9.395010653711e+001,9.028851631487e+000
    5786,-2.187501181250e+000,-9.353114821817e+001,8.741079878445e+000
    5787,-2.187501181250e+000,-9.423298020892e+001,9.039110773833e+000
    5788,-2.187501181250e+000,-9.450207696005e+001,9.052837147965e+000
    5789,-2.187501181250e+000,-9.414122668221e+001,8.776839155109e+000
    5790,-2.187501181250e+000,-9.473297370517e+001,9.124235403193e+000
    5791,-2.187501181250e+000,-9.500149068681e+001,9.142483685472e+000
    5792,-2.187501181250e+000,-9.465499709914e+001,8.858496552682e+000
    5793,-2.187501181250e+000,-9.524386069295e+001,9.126204506838e+000
    5794,-2.187501181250e+000,-9.548395287397e+001,9.135685052540e+000
    5795,-2.187501181250e+000,-9.512826385040e+001,8.913615629275e+000
    5796,-2.187501181250e+000,-9.076637011520e+001,9.759851798834e+000
    5797,-2.187501181250e+000,-9.091640299967e+001,9.616130339927e+000
    5798,-2.187501181250e+000,-9.058785890991e+001,1.576640678720e+001
    5799,-2.187501181250e+000,-9.042327404373e+001,1.474417967427e+001
    5800,-2.187501181250e+000,-9.348082288672e+001,1.901641245053e+001
    5801,-2.187501181250e+000,-9.373175710703e+001,1.903979908871e+001
    5802,-2.187501181250e+000,-9.092228774315e+001,1.794963835027e+001
    5803,-2.187501181250e+000,-9.076595432105e+001,1.779493148052e+001
    5804,-2.187501181250e+000,-9.358452975135e+001,1.818866754878e+001
    5805,-2.187501181250e+000,-9.451974391931e+001,1.833041762048e+001
    5806,-2.187501181250e+000,-9.432196877685e+001,1.829972911982e+001
    5807,-2.187501181250e+000,-9.628290629892e+001,1.750794723202e+001
    5808,-2.187501181250e+000,-9.619512920408e+001,1.772559517961e+001
    5809,-2.187501181250e+000,-9.597264072615e+001,1.808064008559e+001
    5810,-2.187501181250e+000,-9.573776432931e+001,1.819740240161e+001
    5811,-2.187501181250e+000,-9.640366413883e+001,1.713719897055e+001
    5812,-2.187501181250e+000,-9.634503842359e+001,1.731728042370e+001
    5813,-2.187501181250e+000,-9.032482501707e+001,2.193074586816e+001
    5814,-2.187501181250e+000,-9.031122119131e+001,2.167321641139e+001
    5815,-2.187501181250e+000,-9.526093799409e+001,2.654403969385e+001
    5816,-2.187501181250e+000,-9.513272583580e+001,2.677970563702e+001
    5817,-2.187501181250e+000,-9.597848312468e+001,2.120185784659e+001
    5818,-2.187501181250e+000,-9.598798207658e+001,2.141770853530e+001
    5819,-2.187501181250e+000,-9.563045427312e+001,1.964170990348e+001
    5820,-2.187501181250e+000,-9.576565118398e+001,1.981115622966e+001
    5821,-2.187501181250e+000,-9.303868438691e+001,1.928735094941e+001
    5822,-2.187501181250e+000,-9.238907850018e+001,1.903545261569e+001
    5823,-2.187501181250e+000,-9.264317723947e+001,1.902074124759e+001
    5824,-2.187501181250e+000,-9.724111129686e+001,8.614283597174e+000
    5825,-2.187501181250e+000,-9.049767914977e+001,2.019942359472e+001
    5826,-2.187501181250e+000,-9.054264192292e+001,1.997883578122e+001
    5827,-2.187501181250e+000,-9.075448444784e+001,1.958472822053e+001
    5828,-2.187501181250e+000,-9.094271602402e+001,1.943650336710e+001
    5829,-2.187501181250e+000,-9.061811153772e+001,2.475254293880e+001
    5830,-2.187501181250e+000,-9.031074615990e+001,2.133776811853e+001
    5831,-2.187501181250e+000,-9.138444861309e+001,2.714891811799e+001
    5832,-2.187501181250e+000,-9.119503314237e+001,2.709042298119e+001
    5833,-2.187501181250e+000,-9.034302429939e+001,2.107317754687e+001
    5834,-2.187501181250e+000,-9.047877732194e+001,2.061192185074e+001
    5835,-2.187501181250e+000,-9.046771550568e+001,2.044998011135e+001
    5836,-2.187501181250e+000,-9.093274561536e+001,2.704201101027e+001
    5837,-2.187501181250e+000,-9.073673665672e+001,2.689735955145e+001
    5838,-2.187501181250e+000,-9.043225579957e+001,2.707187316505e+001
    5839,-2.187501181250e+000,-9.096265127937e+001,2.725227019929e+001
    5840,-2.187501181250e+000,-9.346729605478e+001,2.732642592060e+001
    5841,-2.187501181250e+000,-9.324063909901e+001,2.737449195410e+001
    5842,-2.187501181250e+000,-9.295410462573e+001,2.748487558364e+001
    5843,-2.187501181250e+000,-9.272877633925e+001,2.747258247583e+001
    5844,-2.187501181250e+000,-9.309213172274e+001,2.766796208425e+001
    5845,-2.187501181250e+000,-9.248165237573e+001,2.734241622376e+001
    5846,-2.187501181250e+000,-9.226686963394e+001,2.729564647117e+001
    5847,-2.187501181250e+000,-9.255847328593e+001,2.764817946172e+001
    5848,-2.187501181250e+000,-9.314506117840e+001,3.911730233269e+001
    5849,-2.187501181250e+000,-9.453916946928e+001,3.031900088338e+001
    5850,-2.187501181250e+000,-9.464566850459e+001,3.086328594427e+001
    5851,-2.187501181250e+000,-9.374316300531e+001,3.579229019935e+001
    5852,-2.187501181250e+000,-9.392760334795e+001,2.837715764782e+001
    5853,-2.187501181250e+000,-9.410133186719e+001,2.844660737447e+001
    5854,-2.187501181250e+000,-9.352958029889e+001,3.688978634757e+001
    5855,-2.187501181250e+000,-9.338809705412e+001,3.700327949413e+001
    5856,-2.187501181250e+000,-9.262004995396e+001,2.806785848620e+001
    5857,-2.187501181250e+000,-9.287916933089e+001,2.806506267866e+001
    5858,-2.187501181250e+000,-9.041978551043e+001,3.585004514925e+001
    5859,-2.187501181250e+000,-9.033554718052e+001,2.551898251321e+001
    5860,-2.187501181250e+000,-9.054407492198e+001,1.754387153846e+001
    5861,-2.187501181250e+000,-9.318703026869e+001,1.901824817023e+001
    5862,-2.187501181250e+000,-9.336593273920e+001,1.874278812981e+001
    5863,-2.187501181250e+000,-9.319828378093e+001,1.847631977666e+001
    5864,-2.187501181250e+000,-9.349207639896e+001,1.847448405695e+001
    5865,-2.187501181250e+000,-9.292379423938e+001,1.901372662869e+001
    5866,-2.187501181250e+000,-9.079366550749e+001,2.865210569175e+001
    5867,-2.187501181250e+000,-9.094051735150e+001,2.851513688102e+001
    5868,-2.187501181250e+000,-9.045175969391e+001,2.811592014876e+001
    5869,-2.187501181250e+000,-9.038480277478e+001,2.848569505572e+001
    5870,-2.187501181250e+000,-9.129829333978e+001,3.727218439433e+001
    5871,-2.187501181250e+000,-9.112261621662e+001,3.720807483350e+001
    5872,-2.187501181250e+000,-9.780078286233e+001,4.858755160115e+000
    5873,-2.187501181250e+000,-9.210915876945e+001,3.725738235425e+001
    5874,-2.187501181250e+000,-9.192931675702e+001,3.725540017799e+001
    5875,-2.187501181250e+000,-9.718602453071e+001,1.343043714389e+001
    5876,-2.187501181250e+000,-9.463071771638e+001,3.259523825133e+001
    5877,-2.187501181250e+000,-9.028993783537e+001,4.570618209307e+001
    5878,-2.187501181250e+000,-9.048079462081e+001,4.594733209482e+001
    5879,-2.187501181250e+000,-9.075680707288e+001,4.593246386995e+001
    5880,-2.187501181250e+000,-9.032477937719e+001,4.534068317645e+001
    5881,-2.187501181250e+000,-9.081148920346e+001,3.938470802588e+001
    5882,-2.187501181250e+000,-9.069489871339e+001,3.974834431232e+001
    5883,-2.187501181250e+000,-9.139494087042e+001,3.917840697633e+001
    5884,-2.187501181250e+000,-8.997500864512e+001,3.037360750249e+001
    5885,-2.187501181250e+000,-9.734890181347e+001,6.159315721113e+000
    5886,-2.187501181250e+000,-9.744495275842e+001,5.622221997649e+000
    5887,-2.187501181250e+000,-9.682991656675e+001,6.437575890881e+000
    5888,-2.187501181250e+000,-9.717621663081e+001,1.004216006978e+001
    5889,-2.187501181250e+000,-9.724690336520e+001,1.024282256810e+001
    5890,-2.187501181250e+000,-9.051289050051e+001,8.167496424604e+000
    5891,-2.187501181250e+000,-9.049551589900e+001,8.516553025255e+000
    5892,-2.187501181250e+000,-9.090400422561e+001,8.025296870113e+000
    5893,-2.187501181250e+000,-9.264895282170e+001,1.848263304747e+001
    5894,-2.187501181250e+000,-9.239698009775e+001,1.848334257763e+001
    5895,-2.187501181250e+000,-9.545775128691e+001,1.823101184276e+001
    5896,-2.187501181250e+000,-9.525715538085e+001,1.826719121488e+001
    5897,-2.187501181250e+000,-9.175658696338e+001,2.717427902523e+001
    5898,-2.187501181250e+000,-9.160027411365e+001,2.716115754170e+001
    5899,-2.187501181250e+000,-9.469210283097e+001,2.707528755249e+001
    5900,-2.187501181250e+000,-9.444241948541e+001,2.715437944675e+001
    5901,-2.187501181250e+000,-9.421881245641e+001,2.720339276377e+001
    5902,-2.187501181250e+000,-9.404342288657e+001,2.722733914890e+001
    5903,-2.187501181250e+000,-9.601422634631e+001,2.101518693335e+001
    5904,-2.187501181250e+000,-9.516863551574e+001,1.940301067651e+001
    5905,-2.187501181250e+000,-9.535973367641e+001,1.949182053291e+001
    5906,-2.187501181250e+000,-9.582904636021e+001,2.009207718040e+001
    5907,-2.187501181250e+000,-9.588811860566e+001,2.028682258044e+001
    5908,-2.187501181250e+000,-9.117504979084e+001,1.928924793094e+001
    5909,-2.187501181250e+000,-9.136591611926e+001,1.922373368258e+001
    5910,-2.187501181250e+000,-9.159584248981e+001,1.924528041231e+001
    5911,-2.187501181250e+000,-9.176667275992e+001,1.921270975593e+001
    5912,-2.187501181250e+000,-9.371584088979e+001,3.650479089704e+001
    5913,-2.187501181250e+000,-9.362732512280e+001,3.666133395584e+001
    5914,-2.187501181250e+000,-9.045929175254e+001,1.777240206891e+001
    5915,-2.187501181250e+000,-9.386320542132e+001,2.721768740915e+001
    5916,-2.187501181250e+000,-9.367810269852e+001,2.724052321875e+001
    5917,-2.187501181250e+000,-9.358947283977e+001,2.747167575285e+001
    5918,-2.187501181250e+000,-9.398049694876e+001,2.739542479075e+001
    5919,-2.187501181250e+000,-9.315362503107e+001,3.706163338323e+001
    5920,-2.187501181250e+000,-9.300093025691e+001,3.712026166126e+001
    5921,-2.187501181250e+000,-9.283405560602e+001,3.720133118725e+001
    5922,-2.187501181250e+000,-9.268385650022e+001,3.722368728595e+001
    5923,-2.187501181250e+000,-9.296915656835e+001,3.732302198664e+001
    5924,-2.187501181250e+000,-9.061733542556e+001,2.909936671412e+001
    5925,-2.187501181250e+000,-9.068382717512e+001,2.891837328347e+001
    5926,-2.187501181250e+000,-9.470402941689e+001,2.979970507696e+001
    5927,-2.187501181250e+000,-9.470687379928e+001,2.998218202588e+001
    5928,-2.187501181250e+000,-9.058622435206e+001,2.944997653688e+001
    5929,-2.187501181250e+000,-9.061502549811e+001,2.928939265667e+001
    5930,-2.187501181250e+000,-9.434740824465e+001,2.857328097191e+001
    5931,-2.187501181250e+000,-9.450800116124e+001,2.871904426014e+001
    5932,-2.187501181250e+000,-9.471095579465e+001,2.899610640595e+001
    5933,-2.187501181250e+000,-9.476728558532e+001,2.920506619637e+001
    5934,-2.187501181250e+000,-9.173027557574e+001,3.721487984738e+001
    5935,-2.187501181250e+000,-9.156386102575e+001,3.719466962036e+001
    5936,-2.187501181250e+000,-9.135211121208e+001,3.745198352384e+001
    5937,-2.187501181250e+000,-9.181672007933e+001,3.741498908048e+001
    5938,-2.187501181250e+000,-9.273724568162e+001,4.289882249557e+001
    5939,-2.187501181250e+000,-9.277894239075e+001,4.234915379495e+001
    5940,-2.187501181250e+000,-9.221733682204e+001,4.302453405763e+001
    5941,-2.187501181250e+000,-9.092690499131e+001,3.694649633764e+001
    5942,-2.187501181250e+000,-9.077279539912e+001,3.678461305677e+001
    5943,-2.187501181250e+000,-9.034456781951e+001,2.515786972362e+001
    5944,-2.187501181250e+000,-9.248936923565e+001,3.721396039588e+001
    5945,-2.187501181250e+000,-9.230793183330e+001,3.722194651495e+001
    5946,-2.187501181250e+000,-9.221453432446e+001,3.742007357179e+001
    5947,-2.187501181250e+000,-9.260779465289e+001,3.739436462256e+001
    5948,-2.187501181250e+000,-9.131862806108e+001,1.820045187470e+001
    5949,-2.187501181250e+000,-9.114844391117e+001,1.811590397100e+001
    5950,-2.187501181250e+000,-9.024101671506e+001,2.576108417727e+000
    5951,-2.187501181250e+000,-9.527346064095e+001,2.621150166848e+001
    5952,-2.187501181250e+000,-9.798612383369e+001,2.801879615406e+000
    5953,-2.187501181250e+000,-9.768094185823e+001,2.837577236075e+000
    5954,-2.187501181250e+000,-9.738590275869e+001,1.046215717373e+001
    5955,-2.187501181250e+000,-9.079986858212e+001,2.720018986382e+000
    5956,-2.187501181250e+000,-9.055021578880e+001,2.718746959235e+000
    5957,-2.187501181250e+000,-9.823101488853e+001,3.405842013157e+000
    5958,-2.187501181250e+000,-9.830412203368e+001,2.924172317094e+000
    5959,-2.187501181250e+000,-9.752011095027e+001,1.028921579567e+001
    5960,-2.187501181250e+000,-9.773697652364e+001,3.715230768472e+000
    5961,-2.187501181250e+000,-9.097152861167e+001,2.945562435700e+000
    5962,-2.187501181250e+000,-9.562382390666e+001,1.944238122286e+001
    5963,-2.187501181250e+000,-9.672764143483e+001,1.739780486587e+001
    5964,-2.187501181250e+000,-9.668236073448e+001,1.706992111373e+001
    5965,-2.187501181250e+000,-9.711215367295e+001,1.119254191322e+001
    5966,-2.187501181250e+000,-9.621959226507e+001,1.874609793910e+001
    5967,-2.187501181250e+000,-9.627579132956e+001,1.828939938656e+001
    5968,-2.187501181250e+000,-9.191985687586e+001,2.716536548713e+001
    5969,-2.187501181250e+000,-9.181985971998e+001,2.731624747952e+001
    5970,-2.187501181250e+000,-9.774519018171e+001,1.012586202387e+001
    5971,-2.187501181250e+000,-9.222501954471e+001,4.559205241642e+001
    5972,-2.187501181250e+000,-9.074748598062e+001,3.784267364812e+001
    5973,-2.187501181250e+000,-9.131549449755e+001,3.805954632050e+001
    5974,-2.187501181250e+000,-9.488030195715e+001,2.840587980383e+001
    5975,-2.187501181250e+000,-9.455449055788e+001,2.817532511614e+001
    5976,-2.187501181250e+000,-9.546666270047e+001,2.568848395016e+001
    5977,-2.187501181250e+000,-9.587269074569e+001,2.543974640583e+001
    5978,-2.187501181250e+000,-9.757632196879e+001,3.176017470881e+000
    5979,-2.187501181250e+000,-9.689911201982e+001,7.647525978511e+000
    5980,-2.187501181250e+000,-9.499464439149e+001,2.714445607556e+001
    5981,-2.187501181250e+000,-9.433456092553e+001,2.836316570353e+001
    5982,-2.187501181250e+000,-9.478359193639e+001,2.876690144677e+001
    5983,-2.187501181250e+000,-9.298769220389e+001,4.602020997691e+001
    5984,-2.187501181250e+000,-9.628273495337e+001,1.800386756694e+001
    5985,-2.187501181250e+000,-9.220904638534e+001,4.184420366229e+001
    5986,-2.187501181250e+000,-9.241276332267e+001,4.517047650622e+001
    5987,-2.187501181250e+000,-9.266282703564e+001,4.491326141784e+001
    5988,-2.187501181250e+000,-9.207191911546e+001,4.511221208752e+001
    5989,-2.187501181250e+000,-9.263920721963e+001,4.447406001166e+001
    5990,-2.187501181250e+000,-9.054990449994e+001,3.658515988770e+001
    5991,-2.187501181250e+000,-9.068320499281e+001,4.527288757917e+001
    5992,-2.187501181250e+000,-9.647280618288e+001,1.746541528492e+001
    5993,-2.187501181250e+000,-9.023923318680e+001,3.015506024455e+001
    5994,-2.187501181250e+000,-9.760619078822e+001,9.906527418245e+000
    5995,-2.187501181250e+000,-9.047223017631e+001,3.680688813703e+001
    5996,-2.187501181250e+000,-9.032168514419e+001,2.992165887961e+001
    5997,-2.187501181250e+000,-9.053242091763e+001,3.016545574537e+001
    5998,-2.187501181250e+000,-9.210275978897e+001,2.719030683705e+001
    5999,-2.187501181250e+000,-9.046146724532e+001,3.720235974019e+001
    6000,-2.187501181250e+000,-9.666550931016e+001,1.758847167420e+001
    6001,-2.187501181250e+000,-9.218830774006e+001,4.411595782925e+001
    6002,-2.187501181250e+000,-9.105697330156e+001,4.590222377352e+001
    6003,-2.187501181250e+000,-9.134508797276e+001,4.589356408960e+001
    6004,-2.187501181250e+000,-9.153217069393e+001,4.556029542418e+001
    6005,-2.187501181250e+000,-9.087999982169e+001,4.561704294708e+001
    6006,-2.187501181250e+000,-9.479966402256e+001,1.834931623790e+001
    6007,-2.187501181250e+000,-9.459715420578e+001,1.855956395465e+001
    6008,-2.187501181250e+000,-9.499285702660e+001,1.833972710716e+001
    6009,-2.187501181250e+000,-9.072170040602e+001,4.009306828883e+001
    6010,-2.187501181250e+000,-9.111327871352e+001,4.026000546582e+001
    6011,-2.187501181250e+000,-9.048837040775e+001,2.977360254296e+001
    6012,-2.187501181250e+000,-9.053569595716e+001,2.959715052584e+001
    6013,-2.187501181250e+000,-9.065717847062e+001,3.746393823604e+001
    6014,-2.187501181250e+000,-9.048400085618e+001,2.621005483793e+001
    6015,-2.187501181250e+000,-9.049427075025e+001,3.547911601561e+001
    6016,-2.187501181250e+000,-9.077709795485e+001,8.692118110124e+000
    6017,-2.187501181250e+000,-9.216332134221e+001,9.040172278353e+000
    6018,-2.187501181250e+000,-9.230283073372e+001,8.738138720911e+000
    6019,-2.187501181250e+000,-9.192514433635e+001,9.068483052975e+000
    6020,-2.187501181250e+000,-9.040060735553e+001,1.909393204432e+001
    6021,-2.187501181250e+000,-9.044025893682e+001,1.943441877619e+001
    6022,-2.187501181250e+000,-9.045833094514e+001,2.751374143344e+001
    6023,-2.187501181250e+000,-9.039495591607e+001,1.812201630785e+001
    6024,-2.187501181250e+000,-9.068049086876e+001,1.832603271744e+001
    6025,-2.187501181250e+000,-9.070163143306e+001,1.896163174353e+001
    6026,-2.187501181250e+000,-9.225707910603e+001,1.878085572123e+001
    6027,-2.187501181250e+000,-9.214315308245e+001,1.850554521155e+001
    6028,-2.187501181250e+000,-9.046174653400e+001,1.685801479236e+001
    6029,-2.187501181250e+000,-9.292956982162e+001,1.847561842857e+001
    6030,-2.187501181250e+000,-9.279152312125e+001,1.875163846841e+001
    6031,-2.187501181250e+000,-9.040441563629e+001,9.457050990784e+000
    6032,-2.187501181250e+000,-9.049361450598e+001,9.843785224847e+000
    6033,-2.187501181250e+000,-9.043495179290e+001,5.137250481082e+000
    6034,-2.187501181250e+000,-9.045490585679e+001,5.516348928593e+000
    6035,-2.187501181250e+000,-9.041997402468e+001,3.635873094002e+000
    6036,-2.187501181250e+000,-9.042935237129e+001,4.017962222108e+000
    6037,-2.187501181250e+000,-9.514137266328e+001,1.850592667979e+001
    6038,-2.187501181250e+000,-9.164194070992e+001,9.136536334825e+000
    6039,-2.187501181250e+000,-9.170628235997e+001,8.853534096264e+000
    6040,-2.187501181250e+000,-9.193313177317e+001,1.847627150164e+001
    6041,-2.187501181250e+000,-9.077721699254e+001,2.750286516627e+001
    6042,-2.187501181250e+000,-9.053518418532e+001,2.781274837133e+001
    6043,-2.187501181250e+000,-9.077064574131e+001,2.810504388159e+001
    6044,-2.187501181250e+000,-9.103950451955e+001,2.755127713718e+001
    6045,-2.187501181250e+000,-9.069358272798e+001,3.420134178329e+000
    6046,-2.187501181250e+000,-9.081340330057e+001,4.939934306892e+000
    6047,-2.187501181250e+000,-9.068980984729e+001,9.277823639357e+000
    6048,-2.187501181250e+000,-9.090175762366e+001,5.680186803364e+000
    6049,-2.187501181250e+000,-9.080407512950e+001,4.188404195348e+000
    6050,-2.187501181250e+000,-9.628593183363e+001,9.287296030322e+000
    6051,-2.187501181250e+000,-9.650945648996e+001,9.082721287262e+000
    6052,-2.187501181250e+000,-9.610540605494e+001,9.256821509736e+000
    6053,-2.187501181250e+000,-9.087970250963e+001,9.430297281218e+000
    6054,-2.187501181250e+000,-9.112490462887e+001,9.480803520503e+000
    6055,-2.187501181250e+000,-9.128916136784e+001,9.384526586750e+000
    6056,-2.187501181250e+000,-9.089831147650e+001,9.142496819932e+000
    6057,-2.187501181250e+000,-9.058878374075e+001,1.003801292304e+001
    6058,-2.187501181250e+000,-9.572388745202e+001,9.171323000555e+000
    6059,-2.187501181250e+000,-9.591053013647e+001,9.192880551103e+000
    6060,-2.187501181250e+000,-9.604537893111e+001,9.032553305305e+000
    6061,-2.187501181250e+000,-9.561056843459e+001,8.932974398656e+000
    6062,-2.187501181250e+000,-9.090732731963e+001,1.818972763171e+001
    6063,-2.187501181250e+000,-9.145659866519e+001,9.197835044910e+000
    6064,-2.187501181250e+000,-9.036635483383e+001,1.100893723834e+001
    6065,-2.187501181250e+000,-9.408093308226e+001,1.835499236549e+001
    6066,-2.187501181250e+000,-9.398847972987e+001,1.864080887366e+001
    6067,-2.187501181250e+000,-9.375217870962e+001,1.845513590193e+001
    6068,-2.187501181250e+000,-9.171149292840e+001,1.835166673439e+001
    6069,-2.187501181250e+000,-9.153187351785e+001,1.829937965881e+001
    6070,-2.187501181250e+000,-9.134672894442e+001,1.845492103655e+001
    6071,-2.187501181250e+000,-9.178161324596e+001,1.867845358790e+001
    6072,-2.187501181250e+000,-9.045262533203e+001,1.142701194378e+001
    6073,-2.187501181250e+000,-9.054292730869e+001,1.020919670814e+001
    6074,-2.187501181250e+000,-9.568568405994e+001,1.839978134636e+001
    6075,-2.187501181250e+000,-9.214723947743e+001,2.741267357553e+001
    6076,-2.187501181250e+000,-9.438432144301e+001,2.735606321349e+001
    6077,-2.187501181250e+000,-9.047129110445e+001,1.972448693356e+001
    6078,-2.187501181250e+000,-9.095813231026e+001,2.830273869890e+001
    6079,-2.187501181250e+000,-9.121142841186e+001,2.840965992090e+001
    6080,-2.187501181250e+000,-9.139138001844e+001,2.834159269135e+001
    6081,-2.187501181250e+000,-9.104155680167e+001,2.799956692147e+001
    6082,-2.187501181250e+000,-9.213525148487e+001,1.905765524961e+001
    6083,-2.187501181250e+000,-9.714430369686e+001,9.046660906905e+000
    6084,-2.187501181250e+000,-9.687546573034e+001,8.636571000854e+000
    6085,-2.187501181250e+000,-9.095578604702e+001,1.914740462700e+001
    6086,-2.187501181250e+000,-9.439662898105e+001,1.921651304336e+001
    6087,-2.187501181250e+000,-9.458332183998e+001,1.923398350192e+001
    6088,-2.187501181250e+000,-9.144076430694e+001,2.731292159391e+001
    6089,-2.187501181250e+000,-9.037843980564e+001,2.493537059961e+001
    6090,-2.187501181250e+000,-9.043295786429e+001,2.426293221310e+001
    6091,-2.187501181250e+000,-9.042678452854e+001,2.077644894330e+001
    6092,-2.187501181250e+000,-9.373228369258e+001,2.836058915172e+001
    6093,-2.187501181250e+000,-9.389316489270e+001,2.821992360998e+001
    6094,-2.187501181250e+000,-9.355236987379e+001,2.832453611212e+001
    6095,-2.187501181250e+000,-9.481739952743e+001,3.042315329178e+001
    6096,-2.187501181250e+000,-9.370272008924e+001,3.689679229073e+001
    6097,-2.187501181250e+000,-9.481814996051e+001,3.020143309134e+001
    6098,-2.187501181250e+000,-9.306746383816e+001,2.789202029413e+001
    6099,-2.187501181250e+000,-9.314103591960e+001,2.817873725901e+001
    6100,-2.187501181250e+000,-9.336811246856e+001,2.822570599242e+001
    6101,-2.187501181250e+000,-9.335399831145e+001,2.778163666459e+001
    6102,-2.187501181250e+000,-9.162226485281e+001,2.829497864689e+001
    6103,-2.187501181250e+000,-9.181469148688e+001,2.826364060887e+001
    6104,-2.187501181250e+000,-9.145992820500e+001,2.815064769432e+001
    6105,-2.187501181250e+000,-9.027496444241e+001,2.875196264744e+001
    6106,-2.187501181250e+000,-9.024542471633e+001,2.910392488397e+001
    6107,-2.187501181250e+000,-9.089083230080e+001,3.726791980195e+001
    6108,-2.187501181250e+000,-9.718971252811e+001,5.020826678327e+000
    6109,-2.187501181250e+000,-9.141804618438e+001,1.902169592057e+001
    6110,-2.187501181250e+000,-9.595793967960e+001,1.987319154417e+001
    6111,-2.187501181250e+000,-9.046523465771e+001,2.913077678501e+001
    6112,-2.187501181250e+000,-9.024311478888e+001,2.929395082652e+001
    6113,-2.187501181250e+000,-9.709465976662e+001,9.791732073951e+000
    6114,-2.187501181250e+000,-9.729955469260e+001,9.819453194212e+000
    6115,-2.187501181250e+000,-9.752463392404e+001,9.656099422418e+000
    6116,-2.187501181250e+000,-9.696686705021e+001,9.609755384435e+000
    6117,-2.187501181250e+000,-9.494472478001e+001,1.931960032803e+001
    6118,-2.187501181250e+000,-9.512919257423e+001,1.920908150380e+001
    6119,-2.187501181250e+000,-9.477103509123e+001,1.928295318126e+001
    6120,-2.187501181250e+000,-9.598097282379e+001,2.049715151384e+001
    6121,-2.187501181250e+000,-9.599851506454e+001,2.068558919710e+001
    6122,-2.187501181250e+000,-9.498510385743e+001,3.008633443428e+001
    6123,-2.187501181250e+000,-9.389185635907e+001,3.618346002059e+001
    6124,-2.187501181250e+000,-9.384961439787e+001,3.632729896737e+001
    6125,-2.187501181250e+000,-9.393423842123e+001,3.649084796932e+001
    6126,-2.187501181250e+000,-9.649827980750e+001,1.793435448057e+001
    6127,-2.187501181250e+000,-9.469534541243e+001,2.944680276054e+001
    6128,-2.187501181250e+000,-9.468844868081e+001,2.962988175301e+001
    6129,-2.187501181250e+000,-9.206491814217e+001,2.820174841376e+001
    6130,-2.187501181250e+000,-9.231288450421e+001,2.816881025912e+001
    6131,-2.187501181250e+000,-9.026980358626e+001,2.033343170116e+001
    6132,-2.187501181250e+000,-9.351358783210e+001,2.810452499418e+001
    6133,-2.187501181250e+000,-9.194103969466e+001,2.804214145475e+001
    6134,-2.187501181250e+000,-9.611418907398e+001,2.036444142831e+001
    6135,-2.187501181250e+000,-9.641901148649e+001,3.250911402408e+000
    6136,-2.187501181250e+000,-9.612245087321e+001,3.216082955321e+000
    6137,-2.187501181250e+000,-9.583909969311e+001,3.256248610803e+000
    6138,-2.187501181250e+000,-9.551311516221e+001,3.256267582942e+000
    6139,-2.187501181250e+000,-9.596395800747e+001,3.525279534557e+000
    6140,-2.187501181250e+000,-9.522537148625e+001,3.232180911855e+000
    6141,-2.187501181250e+000,-9.494316997334e+001,3.249416893530e+000
    6142,-2.187501181250e+000,-9.539286315141e+001,3.541358518954e+000
    6143,-2.187501181250e+000,-9.466942361843e+001,3.385806047167e+000
    6144,-2.187501181250e+000,-9.438717392090e+001,3.414028331088e+000
    6145,-2.187501181250e+000,-9.483137312053e+001,3.653661001504e+000
    6146,-2.187501181250e+000,-9.406796993212e+001,3.426696002505e+000
    6147,-2.187501181250e+000,-9.378367052564e+001,3.409850529952e+000
    6148,-2.187501181250e+000,-9.423842277684e+001,3.802717826557e+000
    6149,-2.187501181250e+000,-9.346814272276e+001,3.294891238040e+000
    6150,-2.187501181250e+000,-9.312458894404e+001,3.290536546065e+000
    6151,-2.187501181250e+000,-9.360369098518e+001,3.700426206062e+000
    6152,-2.187501181250e+000,-9.282167925230e+001,3.332562776969e+000
    6153,-2.187501181250e+000,-9.254025381001e+001,3.334402973243e+000
    6154,-2.187501181250e+000,-9.298525349056e+001,3.627493145054e+000
    6155,-2.187501181250e+000,-9.221438643167e+001,3.309906073509e+000
    6156,-2.187501181250e+000,-9.193190912682e+001,3.287422635266e+000
    6157,-2.187501181250e+000,-9.235647642049e+001,3.645022476223e+000
    6158,-2.187501181250e+000,-9.160310726684e+001,3.203137415083e+000
    6159,-2.187501181250e+000,-9.133900293322e+001,3.157156605414e+000
    6160,-2.187501181250e+000,-9.170180718218e+001,3.536240356306e+000
    6161,-2.187501181250e+000,-9.100553100064e+001,3.240360966410e+000
    6162,-2.187501181250e+000,-9.041239633537e+001,2.946797671653e+001
    6163,-2.187501181250e+000,-9.019258639399e+001,2.944112481549e+001
    6164,-2.187501181250e+000,-9.192267118067e+001,2.748560908604e+001
    6165,-2.187501181250e+000,-9.175940126819e+001,2.749452262414e+001
    6166,-2.187501181250e+000,-9.767060964152e+001,9.383773574838e+000
    6167,-2.187501181250e+000,-9.508325659057e+001,2.868294194963e+001
    6168,-2.187501181250e+000,-9.617953411271e+001,1.981529677851e+001
    6169,-2.187501181250e+000,-9.618401596559e+001,1.935914728321e+001
    6170,-2.187501181250e+000,-9.430841418042e+001,2.804865151871e+001
    6171,-2.187501181250e+000,-9.738488807717e+001,3.718146543201e+000
    6172,-2.187501181250e+000,-9.507288620559e+001,2.974559401581e+001
    6173,-2.187501181250e+000,-9.317869899191e+001,3.854348052459e+001
    6174,-2.187501181250e+000,-9.296984061357e+001,3.816322986920e+001
    6175,-2.187501181250e+000,-9.341868718434e+001,3.745276020249e+001
    6176,-2.187501181250e+000,-9.380740094402e+001,3.736730816321e+001
    6177,-2.187501181250e+000,-9.168376567156e+001,4.523375084598e+001
    6178,-2.187501181250e+000,-9.187150944953e+001,4.481217493578e+001
    6179,-2.187501181250e+000,-9.133176102800e+001,4.526025827244e+001
    6180,-2.187501181250e+000,-9.302968534117e+001,4.622564077161e+001
    6181,-2.187501181250e+000,-9.209222598288e+001,3.914171098764e+001
    6182,-2.187501181250e+000,-9.194272138431e+001,3.973052362077e+001
    6183,-2.187501181250e+000,-9.281216543910e+001,8.334638301133e+000
    6184,-2.187501181250e+000,-9.310604941154e+001,8.347029859492e+000
    6185,-2.187501181250e+000,-9.337050324228e+001,3.718359857156e+001
    6186,-2.187501181250e+000,-9.057738291753e+001,2.867448325074e+001
    6187,-2.187501181250e+000,-9.581913184807e+001,1.925359914080e+001
    6188,-2.187501181250e+000,-9.610860331029e+001,1.902047583058e+001
    6189,-2.187501181250e+000,-9.554841125137e+001,1.910370977023e+001
    6190,-2.187501181250e+000,-9.736397354590e+001,9.296699350805e+000
    6191,-2.187501181250e+000,-9.267364431028e+001,3.912000582397e+001
    6192,-2.187501181250e+000,-9.167290399257e+001,4.047391914998e+001
    6193,-2.187501181250e+000,-9.391495294307e+001,3.700555860821e+001
    6194,-2.187501181250e+000,-9.530253254293e+001,1.907084561132e+001
    6195,-2.187501181250e+000,-9.549784048434e+001,1.888206352926e+001
    6196,-2.187501181250e+000,-9.507862180720e+001,1.898743526283e+001
    6197,-2.187501181250e+000,-9.491047003253e+001,2.737621841953e+001
    6198,-2.187501181250e+000,-9.363012130232e+001,2.767859122864e+001
    6199,-2.187501181250e+000,-9.360545341774e+001,2.790264943852e+001
    6200,-2.187501181250e+000,-9.378971082298e+001,2.800147955822e+001
    6201,-2.187501181250e+000,-9.384092794607e+001,2.759268852678e+001
    6202,-2.187501181250e+000,-9.171895545474e+001,4.297053925854e+001
    6203,-2.187501181250e+000,-9.181933969008e+001,4.245379383498e+001
    6204,-2.187501181250e+000,-9.019518267691e+001,2.976320704214e+001
    6205,-2.187501181250e+000,-9.532881639672e+001,1.864129507893e+001
    6206,-2.187501181250e+000,-9.506451804247e+001,1.871383097121e+001
    6207,-2.187501181250e+000,-9.090664703678e+001,1.849229833817e+001
    6208,-2.187501181250e+000,-9.342384250318e+001,8.444133760369e+000
    6209,-2.187501181250e+000,-9.375104729541e+001,8.469633894687e+000
    6210,-2.187501181250e+000,-9.332594848878e+001,8.075583875735e+000
    6211,-2.187501181250e+000,-9.409542713948e+001,8.439691245312e+000
    6212,-2.187501181250e+000,-9.437830081129e+001,8.449950387657e+000
    6213,-2.187501181250e+000,-9.398812142449e+001,8.142745127236e+000
    6214,-2.187501181250e+000,-9.473643480831e+001,8.533479044709e+000
    6215,-2.187501181250e+000,-9.496733155343e+001,8.604877299937e+000
    6216,-2.187501181250e+000,-9.469063526559e+001,8.196331134913e+000
    6217,-2.187501181250e+000,-9.456813614239e+001,2.758393041390e+001
    6218,-2.187501181250e+000,-9.194431252783e+001,1.909261760836e+001
    6219,-2.187501181250e+000,-9.171066501803e+001,4.179020886319e+001
    6220,-2.187501181250e+000,-9.700962532535e+001,3.502303462923e+000
    6221,-2.187501181250e+000,-9.669286545689e+001,3.421191302989e+000
    6222,-2.187501181250e+000,-9.652116315797e+001,3.655393779655e+000
    6223,-2.187501181250e+000,-9.717027988019e+001,4.041516760514e+000
    6224,-2.187501181250e+000,-9.586744592255e+001,2.192626568281e+001
    6225,-2.187501181250e+000,-9.093396519988e+001,1.881437630737e+001
    6226,-2.187501181250e+000,-9.418772411293e+001,1.920651232840e+001
    6227,-2.187501181250e+000,-9.432095046788e+001,1.901773108167e+001
    6228,-2.187501181250e+000,-9.154258672651e+001,2.753226653031e+001
    6229,-2.187501181250e+000,-9.132676122595e+001,2.752002710660e+001
    6230,-2.187501181250e+000,-9.114132693912e+001,2.777062207358e+001
    6231,-2.187501181250e+000,-9.164539818720e+001,2.770162813682e+001
    6232,-2.187501181250e+000,-9.035111359194e+001,2.471232048522e+001
    6233,-2.187501181250e+000,-9.106105704953e+001,3.631728348043e+000
    6234,-2.187501181250e+000,-9.177651288412e+001,2.788395894025e+001
    6235,-2.187501181250e+000,-9.202673953941e+001,2.782206674514e+001
    6236,-2.187501181250e+000,-9.645685482169e+001,7.994559248252e+000
    6237,-2.187501181250e+000,-9.638369351117e+001,7.437891535641e+000
    6238,-2.187501181250e+000,-9.470346482251e+001,1.880309718435e+001
    6239,-2.187501181250e+000,-9.442354471926e+001,1.878419856693e+001
    6240,-2.187501181250e+000,-9.395791722829e+001,1.917318806701e+001
    6241,-2.187501181250e+000,-9.388588547849e+001,1.887434138840e+001
    6242,-2.187501181250e+000,-9.249843179970e+001,2.787929748671e+001
    6243,-2.187501181250e+000,-9.065663503214e+001,3.524736843546e+001
    6244,-2.187501181250e+000,-9.471756858725e+001,1.907670147597e+001
    6245,-2.187501181250e+000,-9.113442791454e+001,8.657900210146e+000
    6246,-2.187501181250e+000,-9.106574877385e+001,8.955805278092e+000
    6247,-2.187501181250e+000,-9.170965874404e+001,4.442939103548e+001
    6248,-2.187501181250e+000,-9.163830359068e+001,4.385471268741e+001
    6249,-2.187501181250e+000,-9.208678102564e+001,2.759094872015e+001
    6250,-2.187501181250e+000,-9.212586379639e+001,3.856788917953e+001
    6251,-2.187501181250e+000,-9.627005673882e+001,6.845603092474e+000
    6252,-2.187501181250e+000,-9.627402259626e+001,6.192320717455e+000
    6253,-2.187501181250e+000,-9.582779954069e+001,7.192636362215e+000
    6254,-2.187501181250e+000,-9.585470814756e+001,1.864054979669e+001
    6255,-2.187501181250e+000,-9.434452911339e+001,2.763294373091e+001
    6256,-2.187501181250e+000,-9.149416363694e+001,8.563789945248e+000
    6257,-2.187501181250e+000,-9.177736726337e+001,8.495736663398e+000
    6258,-2.187501181250e+000,-9.557469510516e+001,1.867415923784e+001
    6259,-2.187501181250e+000,-9.532251692581e+001,2.588388395391e+001
    6260,-2.187501181250e+000,-9.527799796828e+001,2.604112628593e+001
    6261,-2.187501181250e+000,-9.120551281794e+001,8.300102777280e+000
    6262,-2.187501181250e+000,-9.421463985114e+001,1.877419785197e+001
    6263,-2.187501181250e+000,-9.491460639693e+001,2.928570015675e+001
    6264,-2.187501181250e+000,-9.505730546951e+001,2.957577069187e+001
    6265,-2.187501181250e+000,-9.398503047834e+001,2.801804805433e+001
    6266,-2.062501113750e+000,-9.881867247598e+001,1.936726473612e+000
    6267,-2.187501181250e+000,-9.154074643424e+001,4.096670500633e+001
    6268,-2.187501181250e+000,-9.152588696657e+001,4.136899561435e+001
    6269,-2.062501113750e+000,-9.908905988107e+001,1.936726473612e+000
    6270,-2.187501181250e+000,-9.405465589001e+001,3.604239715460e+001
    6271,-2.187501181250e+000,-9.387850031978e+001,3.591250113554e+001
    6272,-2.187501181250e+000,-9.557314022675e+001,6.031818979009e+000
    6273,-2.187501181250e+000,-9.613300005468e+001,5.623791777416e+000
    6274,-2.187501181250e+000,-9.489117807377e+001,1.885206686369e+001
    6275,-2.187501181250e+000,-9.240868612000e+001,3.765322595662e+001
    6276,-2.187501181250e+000,-9.220991305615e+001,3.768866179592e+001
    6277,-2.187501181250e+000,-9.653334850923e+001,8.813705288036e+000
    6278,-2.187501181250e+000,-9.663015610923e+001,8.381327978305e+000
    6279,-2.187501181250e+000,-9.245071306760e+001,8.345197769778e+000
    6280,-2.187501181250e+000,-9.264670302565e+001,7.989039443504e+000
    6281,-2.187501181250e+000,-9.213736832028e+001,8.392539863282e+000
    6282,-2.187501181250e+000,-9.115922694254e+001,4.011732965623e+000
    6283,-2.187501181250e+000,-9.121419329518e+001,4.388635601009e+000
    6284,-2.187501181250e+000,-9.147117521521e+001,3.831959753704e+000
    6285,-2.187501181250e+000,-9.153341827704e+001,6.192004882425e+000
    6286,-2.187501181250e+000,-9.154908821579e+001,6.607826564990e+000
    6287,-2.187501181250e+000,-9.116080165074e+001,1.867807122164e+001
    6288,-2.187501181250e+000,-9.520970155958e+001,8.588598121303e+000
    6289,-2.062501113750e+000,-9.079626290370e+001,1.936726473612e+000
    6290,-2.062501113750e+000,-9.109052860925e+001,1.936726473612e+000
    6291,-2.187501181250e+000,-9.553786436185e+001,8.680498914727e+000
    6292,-2.187501181250e+000,-9.577779893991e+001,8.716136862742e+000
    6293,-2.187501181250e+000,-9.537693206489e+001,8.371760585389e+000
    6294,-2.187501181250e+000,-9.126373994801e+001,7.931186605215e+000
    6295,-2.187501181250e+000,-9.138676214294e+001,7.517553835208e+000
    6296,-2.187501181250e+000,-9.168827073526e+001,7.792359742376e+000
    6297,-2.187501181250e+000,-9.699832797938e+001,9.318986754485e+000
    6298,-2.187501181250e+000,-9.611473760059e+001,8.171693535435e+000
    6299,-2.187501181250e+000,-9.155969834244e+001,2.792170284643e+001
    6300,-2.187501181250e+000,-9.132881350807e+001,2.796831689089e+001
    6301,-2.187501181250e+000,-9.420496011070e+001,2.783020746694e+001
    6302,-2.187501181250e+000,-9.192524959725e+001,8.102795712266e+000
    6303,-2.187501181250e+000,-9.143919146800e+001,7.128091080589e+000
    6304,-2.187501181250e+000,-9.186758434896e+001,3.765300903439e+001
    6305,-2.187501181250e+000,-9.166854316768e+001,3.761248870378e+001
    6306,-2.187501181250e+000,-9.206173614449e+001,3.788616141922e+001
    6307,-2.187501181250e+000,-9.255567348773e+001,3.823399909831e+001
    6308,-2.187501181250e+000,-9.281823197752e+001,3.785104495164e+001
    6309,-2.187501181250e+000,-9.125564143618e+001,9.108278919954e+000
    6310,-2.187501181250e+000,-9.318421516130e+001,3.751111409159e+001
    6311,-2.187501181250e+000,-9.301734051041e+001,3.759218361758e+001
    6312,-2.187501181250e+000,-9.137404710751e+001,1.877699900575e+001
    6313,-2.187501181250e+000,-9.160397347806e+001,1.879854573547e+001
    6314,-2.187501181250e+000,-9.098337122149e+001,4.524264748274e+001
    6315,-2.187501181250e+000,-9.260317338457e+001,3.766295284669e+001
    6316,-2.187501181250e+000,-9.225130783618e+001,2.774913123464e+001
    6317,-2.187501181250e+000,-9.549044279745e+001,3.999897134720e+000
    6318,-2.187501181250e+000,-9.520269912149e+001,3.975810463633e+000
    6319,-2.187501181250e+000,-9.492895276658e+001,4.112199617270e+000
    6320,-2.062501113750e+000,-9.223075241770e+001,1.936726473612e+000
    6321,-2.187501181250e+000,-9.441301222378e+001,4.316509097308e+000
    6322,-2.187501181250e+000,-9.409380823499e+001,4.329176768725e+000
    6323,-2.187501181250e+000,-9.478433822473e+001,4.638658559438e+000
    6324,-2.187501181250e+000,-9.360880370045e+001,4.125505634384e+000
    6325,-2.187501181250e+000,-9.329327589757e+001,4.010546342472e+000
    6326,-2.187501181250e+000,-9.378339314738e+001,4.639296905135e+000
    6327,-2.187501181250e+000,-9.299036620583e+001,4.052572573376e+000
    6328,-2.062501113750e+000,-9.166578514756e+001,1.936726473612e+000
    6329,-2.062501113750e+000,-9.137151944200e+001,1.936726473612e+000
    6330,-2.187501181250e+000,-9.254165925463e+001,4.061078483079e+000
    6331,-2.187501181250e+000,-9.221579187629e+001,4.036581583345e+000
    6332,-2.187501181250e+000,-9.284968166163e+001,4.444131680497e+000
    6333,-2.187501181250e+000,-9.179997707518e+001,3.916244973886e+000
    6334,-2.187501181250e+000,-9.197425516034e+001,3.825570426197e+001
    6335,-2.187501181250e+000,-9.402114541131e+001,2.760234026653e+001
    6336,-2.187501181250e+000,-9.036553164609e+001,1.603415564539e+001
    6337,-2.187501181250e+000,-9.633578350708e+001,2.030654666265e+001
    6338,-2.187501181250e+000,-9.156577645828e+001,4.339189931267e+001
    6339,-2.187501181250e+000,-9.204827179217e+001,7.689162942259e+000
    6340,-2.187501181250e+000,-9.624292928894e+001,2.009621772925e+001
    6341,-2.187501181250e+000,-9.141457472084e+001,5.621406238566e+000
    6342,-2.187501181250e+000,-9.191224286957e+001,5.767599297312e+000
    6343,-2.187501181250e+000,-9.132622039775e+001,4.881153742093e+000
    6344,-2.187501181250e+000,-9.128058221618e+001,5.255781218251e+000
    6345,-2.187501181250e+000,-9.342861673074e+001,7.692461781545e+000
    6346,-2.187501181250e+000,-9.291876564121e+001,7.472292509353e+000
    6347,-2.187501181250e+000,-9.333922697481e+001,7.186274316039e+000
    6348,-2.187501181250e+000,-9.374640982238e+001,7.789565682421e+000
    6349,-2.187501181250e+000,-9.409078966645e+001,7.759623033046e+000
    6350,-2.187501181250e+000,-9.460696454346e+001,7.747328608662e+000
    6351,-2.187501181250e+000,-9.496509854048e+001,7.830857265714e+000
    6352,-2.187501181250e+000,-9.436525294135e+001,7.394149163848e+000
    6353,-2.187501181250e+000,-9.168137221079e+001,4.704482512368e+000
    6354,-2.187501181250e+000,-9.182561232283e+001,1.892315050272e+001
    6355,-2.187501181250e+000,-9.401269776698e+001,3.677710621648e+001
    6356,-2.187501181250e+000,-9.198515990932e+001,4.332300980743e+000
    6357,-2.187501181250e+000,-9.541143206570e+001,7.583389772423e+000
    6358,-2.187501181250e+000,-9.529779529335e+001,6.991101329256e+000
    6359,-2.187501181250e+000,-9.209718701190e+001,4.824819121827e+000
    6360,-2.187501181250e+000,-9.192118967798e+001,6.858462456770e+000
    6361,-2.187501181250e+000,-9.243023115552e+001,6.652151492509e+000
    6362,-2.187501181250e+000,-9.232033440773e+001,7.172416008108e+000
    6363,-2.187501181250e+000,-9.662126253083e+001,5.286090298985e+000
    6364,-2.187501181250e+000,-9.697709263474e+001,4.522623461450e+000
    6365,-2.187501181250e+000,-9.113496619912e+001,4.491610290454e+001
    6366,-2.187501181250e+000,-9.502313034888e+001,6.406961389484e+000
    6367,-2.187501181250e+000,-9.488210780729e+001,5.838432449445e+000
    6368,-2.187501181250e+000,-9.460676287389e+001,6.797714799692e+000
    6369,-2.187501181250e+000,-9.132150530015e+001,4.455092979394e+001
    6370,-2.187501181250e+000,-9.243346617351e+001,5.355546476522e+000
    6371,-2.187501181250e+000,-9.255230972972e+001,5.926145120381e+000
    6372,-2.187501181250e+000,-9.549510278783e+001,8.032392298673e+000
    6373,-2.187501181250e+000,-9.592038016131e+001,5.125588560539e+000
    6374,-2.187501181250e+000,-9.606927095038e+001,8.763537306079e+000
    6375,-2.187501181250e+000,-9.626414686885e+001,8.827478264713e+000
    6376,-3.521428901571e+000,-8.937504826250e+001,1.936726473612e+000
    6377,-3.746880023314e+000,-8.937504826250e+001,1.936726473612e+000
    6378,-2.187501181250e+000,-9.599656687765e+001,8.511061822150e+000
    6379,-2.187501181250e+000,-9.617536403213e+001,3.784001235035e+000
    6380,-2.187501181250e+000,-9.589201285204e+001,3.824166890518e+000
    6381,-2.187501181250e+000,-9.570184882212e+001,4.258618835197e+000
    6382,-2.187501181250e+000,-9.644921800253e+001,3.954281135615e+000
    6383,-2.062501113750e+000,-9.194147426648e+001,1.936726473612e+000
    6384,-2.187501181250e+000,-9.430024780567e+001,5.528271449698e+000
    6385,-2.187501181250e+000,-9.485025768355e+001,5.153129039223e+000
    6386,-2.187501181250e+000,-9.140297548170e+001,3.769000347775e+001
    6387,-2.187501181250e+000,-9.163192645315e+001,3.822005150044e+001
    6388,-2.187501181250e+000,-9.255731326972e+001,7.482851977998e+000
    6389,-3.090182168697e+000,-9.966431641938e+001,1.936726473612e+000
    6390,-2.713720965409e+000,-9.966431641938e+001,1.936726473612e+000
    6391,-3.672724983270e+000,-9.966431641938e+001,1.936726473612e+000
    6392,-3.387915329473e+000,-9.966431641938e+001,1.936726473612e+000
    6393,-2.187501181250e+000,-9.485824696012e+001,2.969726004488e+001
    6394,-2.187501181250e+000,-9.582326559011e+001,8.124293092097e+000
    6395,-2.187501181250e+000,-9.536619822635e+001,4.948819559185e+000
    6396,-2.187501181250e+000,-9.585446070250e+001,4.611118080753e+000
    6397,-2.187501181250e+000,-9.295145445947e+001,6.240098671719e+000
    6398,-2.187501181250e+000,-9.367096535780e+001,5.178530169533e+000
    6399,-2.187501181250e+000,-9.318596082325e+001,4.974859035192e+000
    6400,-2.187501181250e+000,-9.625603075708e+001,4.435387836551e+000
    6401,-2.187501181250e+000,-9.273725387205e+001,4.983364944896e+000
    6402,-2.187501181250e+000,-9.660182988291e+001,4.306780381172e+000
    6403,-2.187501181250e+000,-9.409058799688e+001,6.810009224076e+000
    6404,-2.187501181250e+000,-9.370281548154e+001,5.863833579756e+000
    6405,-2.187501181250e+000,-9.358073690735e+001,6.589839951884e+000
    6406,-2.062501113750e+000,-9.333984502985e+001,3.632408645041e+001
    6407,-2.062501113750e+000,-9.338230039730e+001,3.621399512493e+001
    6408,-2.062501113750e+000,-9.314564066314e+001,3.657448744206e+001
    6409,-2.062501113750e+000,-9.325611849144e+001,3.645966074164e+001
    6410,-2.062501113750e+000,-9.289479070827e+001,3.671345620782e+001
    6411,-2.062501113750e+000,-9.302668364639e+001,3.665620350638e+001
    6412,-2.062501113750e+000,-9.278056704404e+001,3.674082254215e+001
    6413,-2.062501113750e+000,-9.425535993082e+001,2.973563884730e+001
    6414,-2.062501113750e+000,-9.344545949347e+001,3.580989212740e+001
    6415,-2.062501113750e+000,-9.347059284038e+001,3.562139202561e+001
    6416,-2.062501113750e+000,-9.342595948294e+001,3.595614220637e+001
    6417,-2.062501113750e+000,-9.423672658742e+001,2.987538892277e+001
    6418,-2.062501113750e+000,-9.421072657338e+001,3.007038902807e+001
    6419,-2.062501113750e+000,-9.418342655864e+001,3.027513913863e+001
    6420,-2.062501113750e+000,-9.349702618798e+001,3.542314191855e+001
    6421,-2.062501113750e+000,-9.414745987255e+001,3.054488928430e+001
    6422,-2.062501113750e+000,-9.406859316329e+001,3.113638960371e+001
    6423,-2.062501113750e+000,-9.410759318435e+001,3.084388944576e+001
    6424,-2.062501113750e+000,-9.403175981007e+001,3.141263975288e+001
    6425,-2.062501113750e+000,-9.353385954121e+001,3.514689176938e+001
    6426,-2.062501113750e+000,-9.399275978901e+001,3.170513991083e+001
    6427,-2.062501113750e+000,-9.391649308116e+001,3.227714021971e+001
    6428,-2.062501113750e+000,-9.395549310222e+001,3.198464006176e+001
    6429,-2.062501113750e+000,-9.383849303904e+001,3.286214053561e+001
    6430,-2.062501113750e+000,-9.387705972653e+001,3.257289037942e+001
    6431,-2.062501113750e+000,-9.372539297797e+001,3.371039099367e+001
    6432,-2.062501113750e+000,-9.376439299903e+001,3.341789083572e+001
    6433,-2.062501113750e+000,-9.364739293585e+001,3.429539130957e+001
    6434,-2.062501113750e+000,-9.368639295691e+001,3.400289115162e+001
    6435,-2.062501113750e+000,-9.357199289513e+001,3.486089161494e+001
    6436,-2.062501113750e+000,-9.361055958262e+001,3.457164145874e+001
    6437,-2.062501113750e+000,-9.380209301938e+001,3.313514068303e+001
    6438,-2.062501113750e+000,-9.366230601117e+001,2.876175284238e+001
    6439,-2.062501113750e+000,-9.393417954585e+001,2.886815239043e+001
    6440,-2.062501113750e+000,-9.379093562447e+001,2.879681928136e+001
    6441,-2.062501113750e+000,-9.417265795542e+001,2.911314450046e+001
    6442,-2.062501113750e+000,-9.405948263855e+001,2.896870104140e+001
    6443,-2.062501113750e+000,-9.427771825324e+001,2.943980554869e+001
    6444,-2.062501113750e+000,-9.424755708925e+001,2.928135789009e+001
    6445,-2.062501113750e+000,-9.210962753687e+001,2.875001552500e+001
    6446,-2.062501113750e+000,-9.192805845187e+001,2.875001552500e+001
    6447,-2.062501113750e+000,-9.335390979588e+001,2.875001552500e+001
    6448,-2.062501113750e+000,-9.317412079995e+001,2.875001552500e+001
    6449,-2.062501113750e+000,-9.263475381214e+001,2.875001552500e+001
    6450,-2.062501113750e+000,-9.236952054090e+001,2.875001552500e+001
    6451,-2.062501113750e+000,-9.291066761778e+001,2.875001552500e+001
    6452,-2.062501113750e+000,-9.101204192724e+001,2.936642939017e+001
    6453,-2.062501113750e+000,-9.112710228421e+001,2.908235899210e+001
    6454,-2.062501113750e+000,-9.124008423558e+001,2.895007412336e+001
    6455,-2.062501113750e+000,-9.136169704195e+001,2.885839069602e+001
    6456,-2.062501113750e+000,-9.162284383930e+001,2.876088176360e+001
    6457,-2.062501113750e+000,-9.149932412507e+001,2.879316561253e+001
    6458,-2.062501113750e+000,-9.104763675064e+001,2.923711504789e+001
    6459,-2.062501113750e+000,-9.100004914000e+001,3.585051935927e+001
    6460,-2.062501113750e+000,-9.100004914000e+001,3.548651916271e+001
    6461,-2.062501113750e+000,-9.100004914000e+001,3.569451927503e+001
    6462,-2.062501113750e+000,-9.100004914000e+001,3.024751633365e+001
    6463,-2.062501113750e+000,-9.100004914000e+001,3.049776646879e+001
    6464,-2.062501113750e+000,-9.100004914000e+001,2.977951608093e+001
    6465,-2.062501113750e+000,-9.100004914000e+001,2.998101618974e+001
    6466,-2.062501113750e+000,-9.100004914000e+001,2.963976600547e+001
    6467,-2.062501113750e+000,-9.100004914000e+001,3.523301902582e+001
    6468,-2.062501113750e+000,-9.100004914000e+001,3.077076661621e+001
    6469,-2.062501113750e+000,-9.100004914000e+001,3.106651677591e+001
    6470,-2.062501113750e+000,-9.100004914000e+001,3.495676887665e+001
    6471,-2.062501113750e+000,-9.100004914000e+001,3.439126857127e+001
    6472,-2.062501113750e+000,-9.100004914000e+001,3.467726872571e+001
    6473,-2.062501113750e+000,-9.100004914000e+001,3.384201827468e+001
    6474,-2.062501113750e+000,-9.100004914000e+001,3.412801842912e+001
    6475,-2.062501113750e+000,-9.100004914000e+001,3.188876721993e+001
    6476,-2.062501113750e+000,-9.100004914000e+001,3.217801737612e+001
    6477,-2.062501113750e+000,-9.100004914000e+001,3.133626692157e+001
    6478,-2.062501113750e+000,-9.100004914000e+001,3.162551707777e+001
    6479,-2.062501113750e+000,-9.100004914000e+001,3.357226812902e+001
    6480,-2.062501113750e+000,-9.100004914000e+001,3.245426752529e+001
    6481,-2.062501113750e+000,-9.100004914000e+001,3.328301797282e+001
    6482,-2.062501113750e+000,-9.100004914000e+001,3.274351768149e+001
    6483,-2.062501113750e+000,-9.100004914000e+001,3.300351782189e+001
    6484,-2.062501113750e+000,-9.162284383930e+001,3.673915360640e+001
    6485,-2.062501113750e+000,-9.149932412507e+001,3.670686975747e+001
    6486,-2.062501113750e+000,-9.135717140015e+001,3.663888356546e+001
    6487,-2.062501113750e+000,-9.112222522248e+001,3.641030863990e+001
    6488,-2.062501113750e+000,-9.104519020106e+001,3.625628865930e+001
    6489,-2.062501113750e+000,-9.101142061214e+001,3.613012673049e+001
    6490,-2.062501113750e+000,-9.123236083527e+001,3.654269706744e+001
    6491,-2.062501113750e+000,-9.251960752441e+001,3.675001984500e+001
    6492,-2.062501113750e+000,-9.211998542828e+001,3.675001984500e+001
    6493,-2.062501113750e+000,-9.229033861897e+001,3.675001984500e+001
    6494,-2.062501113750e+000,-9.189254336671e+001,3.675001984500e+001
    6495,-2.062501113750e+000,-9.461793942300e+001,2.642036305855e+001
    6496,-2.062501113750e+000,-9.469782888736e+001,2.626659772898e+001
    6497,-2.062501113750e+000,-9.415682908369e+001,2.673274391555e+001
    6498,-2.062501113750e+000,-9.430948279513e+001,2.668172771658e+001
    6499,-2.062501113750e+000,-9.448144889737e+001,2.657239626915e+001
    6500,-2.062501113750e+000,-9.545229391049e+001,2.075863399972e+001
    6501,-2.062501113750e+000,-9.475892686941e+001,2.595888680786e+001
    6502,-2.062501113750e+000,-9.542956056488e+001,2.092913409179e+001
    6503,-2.062501113750e+000,-9.477762687951e+001,2.581863673212e+001
    6504,-2.062501113750e+000,-9.480402689376e+001,2.562063662520e+001
    6505,-2.062501113750e+000,-9.483042690802e+001,2.542263651828e+001
    6506,-2.062501113750e+000,-9.540059388257e+001,2.114638420911e+001
    6507,-2.062501113750e+000,-9.532946051083e+001,2.167988449720e+001
    6508,-2.062501113750e+000,-9.536576053043e+001,2.140763435018e+001
    6509,-2.062501113750e+000,-9.525172713552e+001,2.226288481202e+001
    6510,-2.062501113750e+000,-9.529169382377e+001,2.196313465015e+001
    6511,-2.062501113750e+000,-9.521469378219e+001,2.254063496200e+001
    6512,-2.062501113750e+000,-9.486819359508e+001,2.513938636533e+001
    6513,-2.062501113750e+000,-9.517436042708e+001,2.284313512535e+001
    6514,-2.062501113750e+000,-9.509516038431e+001,2.343713544611e+001
    6515,-2.062501113750e+000,-9.513512707256e+001,2.313738528425e+001
    6516,-2.062501113750e+000,-9.501742700900e+001,2.402013576093e+001
    6517,-2.062501113750e+000,-9.505739369725e+001,2.372038559907e+001
    6518,-2.062501113750e+000,-9.490669361587e+001,2.485063620940e+001
    6519,-2.062501113750e+000,-9.494372696920e+001,2.457288605942e+001
    6520,-2.062501113750e+000,-9.498076032253e+001,2.429513590943e+001
    6521,-2.062501113750e+000,-9.487172700907e+001,1.976349663206e+001
    6522,-2.062501113750e+000,-9.516436622484e+001,1.988849855830e+001
    6523,-2.062501113750e+000,-9.500822289867e+001,1.980346954335e+001
    6524,-2.062501113750e+000,-9.539574897685e+001,2.015437496862e+001
    6525,-2.062501113750e+000,-9.529610743341e+001,2.000789255166e+001
    6526,-2.062501113750e+000,-9.547901312041e+001,2.045891908524e+001
    6527,-2.062501113750e+000,-9.545825186271e+001,2.032014265218e+001
    6528,-2.062501113750e+000,-9.190948434484e+001,1.975001066500e+001
    6529,-2.062501113750e+000,-9.231179645659e+001,1.975001066500e+001
    6530,-2.062501113750e+000,-9.210021008671e+001,1.975001066500e+001
    6531,-2.062501113750e+000,-9.284821260560e+001,1.975001066500e+001
    6532,-2.062501113750e+000,-9.260384524883e+001,1.975001066500e+001
    6533,-2.062501113750e+000,-9.340548938262e+001,1.975001066500e+001
    6534,-2.062501113750e+000,-9.312685099411e+001,1.975001066500e+001
    6535,-2.062501113750e+000,-9.394488562134e+001,1.975001066500e+001
    6536,-2.062501113750e+000,-9.369604812999e+001,1.975001066500e+001
    6537,-2.062501113750e+000,-9.441722984143e+001,1.975001066500e+001
    6538,-2.062501113750e+000,-9.421458374070e+001,1.975001066500e+001
    6539,-2.062501113750e+000,-9.458560491043e+001,1.975001066500e+001
    6540,-2.062501113750e+000,-9.104319922753e+001,2.024928565007e+001
    6541,-2.062501113750e+000,-9.101081569945e+001,2.037338591809e+001
    6542,-2.062501113750e+000,-9.123578077566e+001,1.995409144186e+001
    6543,-2.062501113750e+000,-9.112222522248e+001,2.008972187010e+001
    6544,-2.062501113750e+000,-9.135867777745e+001,1.986022302145e+001
    6545,-2.062501113750e+000,-9.149821411696e+001,1.979355546298e+001
    6546,-2.062501113750e+000,-9.162226336397e+001,1.976097703869e+001
    6547,-2.062501113750e+000,-9.100004914000e+001,2.569751387665e+001
    6548,-2.062501113750e+000,-9.100004914000e+001,2.585426396130e+001
    6549,-2.062501113750e+000,-9.100004914000e+001,2.529326365836e+001
    6550,-2.062501113750e+000,-9.100004914000e+001,2.550501377270e+001
    6551,-2.062501113750e+000,-9.100004914000e+001,2.142126156747e+001
    6552,-2.062501113750e+000,-9.100004914000e+001,2.167976170707e+001
    6553,-2.062501113750e+000,-9.100004914000e+001,2.097576132691e+001
    6554,-2.062501113750e+000,-9.100004914000e+001,2.118476143976e+001
    6555,-2.062501113750e+000,-9.100004914000e+001,2.064026114574e+001
    6556,-2.062501113750e+000,-9.100004914000e+001,2.078876122592e+001
    6557,-2.062501113750e+000,-9.100004914000e+001,2.366251277775e+001
    6558,-2.062501113750e+000,-9.100004914000e+001,2.339576263370e+001
    6559,-2.062501113750e+000,-9.100004914000e+001,2.309051246887e+001
    6560,-2.062501113750e+000,-9.100004914000e+001,2.282651232631e+001
    6561,-2.062501113750e+000,-9.100004914000e+001,2.252126216147e+001
    6562,-2.062501113750e+000,-9.100004914000e+001,2.224626201297e+001
    6563,-2.062501113750e+000,-9.100004914000e+001,2.193826184665e+001
    6564,-2.062501113750e+000,-9.100004914000e+001,2.479001338660e+001
    6565,-2.062501113750e+000,-9.100004914000e+001,2.504301352322e+001
    6566,-2.062501113750e+000,-9.100004914000e+001,2.423726308812e+001
    6567,-2.062501113750e+000,-9.100004914000e+001,2.452601324404e+001
    6568,-2.062501113750e+000,-9.100004914000e+001,2.396776294258e+001
    6569,-2.062501113750e+000,-9.162110265016e+001,2.673884643359e+001
    6570,-2.062501113750e+000,-9.135566720397e+001,2.663795069562e+001
    6571,-2.062501113750e+000,-9.149544182122e+001,2.670547524694e+001
    6572,-2.062501113750e+000,-9.112029875825e+001,2.640734014288e+001
    6573,-2.062501113750e+000,-9.123236083527e+001,2.654269166744e+001
    6574,-2.062501113750e+000,-9.101071647630e+001,2.612605856001e+001
    6575,-2.062501113750e+000,-9.104280626117e+001,2.624962883318e+001
    6576,-2.062501113750e+000,-9.386087679512e+001,2.675001444500e+001
    6577,-2.062501113750e+000,-9.353959068893e+001,2.675001444500e+001
    6578,-2.062501113750e+000,-9.370809738798e+001,2.675001444500e+001
    6579,-2.062501113750e+000,-9.311046029534e+001,2.675001444500e+001
    6580,-2.062501113750e+000,-9.333513589408e+001,2.675001444500e+001
    6581,-2.062501113750e+000,-9.259819993023e+001,2.675001444500e+001
    6582,-2.062501113750e+000,-9.283523268689e+001,2.675001444500e+001
    6583,-2.062501113750e+000,-9.209604996705e+001,2.675001444500e+001
    6584,-2.062501113750e+000,-9.230050476190e+001,2.675001444500e+001
    6585,-2.062501113750e+000,-9.190282895214e+001,2.675001444500e+001
    6586,-2.062501113750e+000,-9.634570456940e+001,9.805134367850e+000
    6587,-2.062501113750e+000,-9.620694240864e+001,9.763855395480e+000
    6588,-2.062501113750e+000,-9.662691936120e+001,1.000500146745e+001
    6589,-2.062501113750e+000,-9.649822092989e+001,9.888863199814e+000
    6590,-2.062501113750e+000,-9.672521551193e+001,1.014702143193e+001
    6591,-2.062501113750e+000,-9.681201020481e+001,1.045317478151e+001
    6592,-2.062501113750e+000,-9.678858012111e+001,1.030837913932e+001
    6593,-2.062501113750e+000,-9.192042978392e+001,9.750005265000e+000
    6594,-2.062501113750e+000,-9.287800986086e+001,9.750005265000e+000
    6595,-2.062501113750e+000,-9.261920443466e+001,9.750005265000e+000
    6596,-2.062501113750e+000,-9.560840710728e+001,9.750005265000e+000
    6597,-2.062501113750e+000,-9.542724330894e+001,9.750005265000e+000
    6598,-2.062501113750e+000,-9.592544375438e+001,9.750005265000e+000
    6599,-2.062501113750e+000,-9.578525748185e+001,9.750005265000e+000
    6600,-2.062501113750e+000,-9.210590700603e+001,9.750005265000e+000
    6601,-2.062501113750e+000,-9.314328542272e+001,9.750005265000e+000
    6602,-2.062501113750e+000,-9.233667517772e+001,9.750005265000e+000
    6603,-2.062501113750e+000,-9.517275130651e+001,9.750005265000e+000
    6604,-2.062501113750e+000,-9.344522508662e+001,9.750005265000e+000
    6605,-2.062501113750e+000,-9.403616414311e+001,9.750005265000e+000
    6606,-2.062501113750e+000,-9.373206776732e+001,9.750005265000e+000
    6607,-2.062501113750e+000,-9.491178916842e+001,9.750005265000e+000
    6608,-2.062501113750e+000,-9.431437997628e+001,9.750005265000e+000
    6609,-2.062501113750e+000,-9.462278977583e+001,9.750005265000e+000
    6610,-2.062501113750e+000,-9.101172922024e+001,1.036815838885e+001
    6611,-2.062501113750e+000,-9.112449038199e+001,1.008627104361e+001
    6612,-2.062501113750e+000,-9.123578077566e+001,9.954086041862e+000
    6613,-2.062501113750e+000,-9.135968323659e+001,9.859603645677e+000
    6614,-2.062501113750e+000,-9.162342439309e+001,9.760771824452e+000
    6615,-2.062501113750e+000,-9.104640566309e+001,1.024041773701e+001
    6616,-2.062501113750e+000,-9.150043475182e+001,9.792762386169e+000
    6617,-2.062501113750e+000,-9.100004914000e+001,1.685375910103e+001
    6618,-2.062501113750e+000,-9.100004914000e+001,1.599575863770e+001
    6619,-2.062501113750e+000,-9.100004914000e+001,1.624925877459e+001
    6620,-2.062501113750e+000,-9.100004914000e+001,1.127025608593e+001
    6621,-2.062501113750e+000,-9.100004914000e+001,1.152700622458e+001
    6622,-2.062501113750e+000,-9.100004914000e+001,1.079575582971e+001
    6623,-2.062501113750e+000,-9.100004914000e+001,1.100050594027e+001
    6624,-2.062501113750e+000,-9.100004914000e+001,1.064625574898e+001
    6625,-2.062501113750e+000,-9.100004914000e+001,1.670425902030e+001
    6626,-2.062501113750e+000,-9.100004914000e+001,1.649950890973e+001
    6627,-2.062501113750e+000,-9.100004914000e+001,1.573250849555e+001
    6628,-2.062501113750e+000,-9.100004914000e+001,1.180325637376e+001
    6629,-2.062501113750e+000,-9.100004914000e+001,1.544325833935e+001
    6630,-2.062501113750e+000,-9.100004914000e+001,1.488425803749e+001
    6631,-2.062501113750e+000,-9.100004914000e+001,1.517350819369e+001
    6632,-2.062501113750e+000,-9.100004914000e+001,1.292450697923e+001
    6633,-2.062501113750e+000,-9.100004914000e+001,1.321375713542e+001
    6634,-2.062501113750e+000,-9.100004914000e+001,1.236875667912e+001
    6635,-2.062501113750e+000,-9.100004914000e+001,1.265800683532e+001
    6636,-2.062501113750e+000,-9.100004914000e+001,1.210225653522e+001
    6637,-2.062501113750e+000,-9.100004914000e+001,1.461775789359e+001
    6638,-2.062501113750e+000,-9.100004914000e+001,1.349650728811e+001
    6639,-2.062501113750e+000,-9.100004914000e+001,1.432525773563e+001
    6640,-2.062501113750e+000,-9.100004914000e+001,1.378575744430e+001
    6641,-2.062501113750e+000,-9.100004914000e+001,1.404900758646e+001
    6642,-2.062501113750e+000,-9.162226336397e+001,1.773904321131e+001
    6643,-2.062501113750e+000,-9.135968323659e+001,1.764041120432e+001
    6644,-2.062501113750e+000,-9.123749836775e+001,1.754754173446e+001
    6645,-2.062501113750e+000,-9.112514104631e+001,1.741472592159e+001
    6646,-2.062501113750e+000,-9.104640566309e+001,1.725959711299e+001
    6647,-2.062501113750e+000,-9.101172922024e+001,1.713185646115e+001
    6648,-2.062501113750e+000,-9.149821411696e+001,1.770646478702e+001
    6649,-2.062501113750e+000,-9.492795916279e+001,1.775000958500e+001
    6650,-2.062501113750e+000,-9.506410604989e+001,1.775000958500e+001
    6651,-2.062501113750e+000,-9.459362376916e+001,1.775000958500e+001
    6652,-2.062501113750e+000,-9.476423822261e+001,1.775000958500e+001
    6653,-2.062501113750e+000,-9.413692851498e+001,1.775000958500e+001
    6654,-2.062501113750e+000,-9.437647810114e+001,1.775000958500e+001
    6655,-2.062501113750e+000,-9.255831397599e+001,1.775000958500e+001
    6656,-2.062501113750e+000,-9.280648045374e+001,1.775000958500e+001
    6657,-2.062501113750e+000,-9.190860035023e+001,1.775000958500e+001
    6658,-2.062501113750e+000,-9.304947679653e+001,1.775000958500e+001
    6659,-2.062501113750e+000,-9.207576804704e+001,1.775000958500e+001
    6660,-2.062501113750e+000,-9.229119033675e+001,1.775000958500e+001
    6661,-2.062501113750e+000,-9.333211084063e+001,1.775000958500e+001
    6662,-2.062501113750e+000,-9.361302150641e+001,1.775000958500e+001
    6663,-2.062501113750e+000,-9.388531528060e+001,1.775000958500e+001
    6664,-2.062501113750e+000,-9.590341714831e+001,1.725140835951e+001
    6665,-2.062501113750e+000,-9.583577586607e+001,1.739271562027e+001
    6666,-2.062501113750e+000,-9.537050094750e+001,1.772961916853e+001
    6667,-2.062501113750e+000,-9.553523256252e+001,1.766931343918e+001
    6668,-2.062501113750e+000,-9.570489467758e+001,1.755168543152e+001
    6669,-2.062501113750e+000,-9.678869463215e+001,1.073562858730e+001
    6670,-2.062501113750e+000,-9.674796127682e+001,1.104112875227e+001
    6671,-2.062501113750e+000,-9.677006128875e+001,1.087537866277e+001
    6672,-2.062501113750e+000,-9.596232751924e+001,1.693338193409e+001
    6673,-2.062501113750e+000,-9.672499459775e+001,1.121337884529e+001
    6674,-2.062501113750e+000,-9.598529419831e+001,1.676113184107e+001
    6675,-2.062501113750e+000,-9.601649421516e+001,1.652713171471e+001
    6676,-2.062501113750e+000,-9.605029423341e+001,1.627363157782e+001
    6677,-2.062501113750e+000,-9.669422791447e+001,1.144412896989e+001
    6678,-2.062501113750e+000,-9.613046094337e+001,1.567238125315e+001
    6679,-2.062501113750e+000,-9.616859429729e+001,1.538638109871e+001
    6680,-2.062501113750e+000,-9.666129456335e+001,1.169112910327e+001
    6681,-2.062501113750e+000,-9.620456098338e+001,1.511663095304e+001
    6682,-2.062501113750e+000,-9.608929425447e+001,1.598113141987e+001
    6683,-2.062501113750e+000,-9.662186120873e+001,1.198687926298e+001
    6684,-2.062501113750e+000,-9.654602783444e+001,1.255562957010e+001
    6685,-2.062501113750e+000,-9.658459452193e+001,1.226637941391e+001
    6686,-2.062501113750e+000,-9.646976112659e+001,1.312762987898e+001
    6687,-2.062501113750e+000,-9.650789448052e+001,1.284162972454e+001
    6688,-2.062501113750e+000,-9.635752773265e+001,1.396938033353e+001
    6689,-2.062501113750e+000,-9.639609442014e+001,1.368013017733e+001
    6690,-2.062501113750e+000,-9.628039435767e+001,1.454788064592e+001
    6691,-2.062501113750e+000,-9.631896104516e+001,1.425863048972e+001
    6692,-2.062501113750e+000,-9.624312767088e+001,1.482738079685e+001
    6693,-2.062501113750e+000,-9.643249443980e+001,1.340713002991e+001
    6694,-2.384609287688e+000,-9.368590582174e+001,4.677480595590e+001
    6695,-2.254673717523e+000,-9.368590582174e+001,4.677480595590e+001
    6696,-2.801695012914e+000,-9.368590582174e+001,4.677480595590e+001
    6697,-2.613245411152e+000,-9.368590582174e+001,4.677480595590e+001
    6698,-3.661141477015e+000,-9.368590582174e+001,4.677480595590e+001
    6699,-3.386641828786e+000,-9.368590582174e+001,4.677480595590e+001
    6700,-3.069310657427e+000,-9.368590582174e+001,4.677480595590e+001
    6701,-2.062501113750e+000,-9.368590582174e+001,4.677480595590e+001
    6702,-3.908502110590e+000,-9.375465589157e+001,4.625918043221e+001
    6703,-3.908502110590e+000,-9.371880525255e+001,4.652806022484e+001
    6704,-3.908502110590e+000,-9.963739870326e+001,2.138609344481e+000
    6705,-3.908502110590e+000,-9.961051072400e+001,2.340269188952e+000
    6706,-3.908502110590e+000,-9.379951875176e+001,4.592270898076e+001
    6707,-3.908502110590e+000,-9.384731960378e+001,4.556420259059e+001
    6708,-3.908502110590e+000,-9.956564786381e+001,2.676740640401e+000
    6709,-3.908502110590e+000,-9.952083456503e+001,3.012840381186e+000
    6710,-3.908502110590e+000,-9.406553324264e+001,4.392760029913e+001
    6711,-3.908502110590e+000,-9.401773239062e+001,4.428610668930e+001
    6712,-3.908502110590e+000,-9.416417536546e+001,4.318778437803e+001
    6713,-3.908502110590e+000,-9.411338696018e+001,4.356869741758e+001
    6714,-3.908502110590e+000,-9.427178345212e+001,4.238072372806e+001
    6715,-3.908502110590e+000,-9.421501994034e+001,4.280645006638e+001
    6716,-3.908502110590e+000,-9.437641059372e+001,4.159602016605e+001
    6717,-3.908502110590e+000,-9.432860974170e+001,4.195452655622e+001
    6718,-3.908502110590e+000,-9.447505271653e+001,4.085620424495e+001
    6719,-3.908502110590e+000,-9.442426431126e+001,4.123711728450e+001
    6720,-3.908502110590e+000,-9.457369814344e+001,4.011636354313e+001
    6721,-3.908502110590e+000,-9.452589729142e+001,4.047486993331e+001
    6722,-3.908502110590e+000,-9.478892092496e+001,3.850219268177e+001
    6723,-3.908502110590e+000,-9.473813251968e+001,3.888310572133e+001
    6724,-3.908502110590e+000,-9.488756635187e+001,3.776235197996e+001
    6725,-3.908502110590e+000,-9.483976549984e+001,3.812085837013e+001
    6726,-3.908502110590e+000,-9.498620847468e+001,3.702253605886e+001
    6727,-3.908502110590e+000,-9.493542006940e+001,3.740344909841e+001
    6728,-3.908502110590e+000,-9.508485059749e+001,3.628272013775e+001
    6729,-3.908502110590e+000,-9.503406219222e+001,3.666363317731e+001
    6730,-3.908502110590e+000,-9.518349602440e+001,3.554287943594e+001
    6731,-3.908502110590e+000,-9.513569517238e+001,3.590138582611e+001
    6732,-3.908502110590e+000,-9.528213814721e+001,3.480306351484e+001
    6733,-3.908502110590e+000,-9.523134974194e+001,3.518397655440e+001
    6734,-3.908502110590e+000,-9.538675868063e+001,3.401840951425e+001
    6735,-3.908502110590e+000,-9.533298272210e+001,3.442172920320e+001
    6736,-3.908502110590e+000,-9.549138251813e+001,3.323373073296e+001
    6737,-3.908502110590e+000,-9.544059411286e+001,3.361464377252e+001
    6738,-3.908502110590e+000,-9.559301549829e+001,3.247148338176e+001
    6739,-3.908502110590e+000,-9.554222709302e+001,3.285239642132e+001
    6740,-3.908502110590e+000,-9.569166092520e+001,3.173164267995e+001
    6741,-3.908502110590e+000,-9.564386007318e+001,3.209014907012e+001
    6742,-3.908502110590e+000,-9.591286211731e+001,3.007263373910e+001
    6743,-3.908502110590e+000,-9.586506126529e+001,3.043114012927e+001
    6744,-3.908502110590e+000,-9.600851668687e+001,2.935522446739e+001
    6745,-3.908502110590e+000,-9.596071583485e+001,2.971373085756e+001
    6746,-3.908502110590e+000,-9.611014966703e+001,2.859297711619e+001
    6747,-3.908502110590e+000,-9.605936126176e+001,2.897389015574e+001
    6748,-3.908502110590e+000,-9.632238159120e+001,2.700123768492e+001
    6749,-3.908502110590e+000,-9.627458073918e+001,2.735974407509e+001
    6750,-3.908502110590e+000,-9.641803616077e+001,2.628382841320e+001
    6751,-3.908502110590e+000,-9.637023530874e+001,2.664233480338e+001
    6752,-3.908502110590e+000,-9.652564755152e+001,2.547674298252e+001
    6753,-3.908502110590e+000,-9.647187159300e+001,2.588006267147e+001
    6754,-3.908502110590e+000,-9.668405065165e+001,2.428871973157e+001
    6755,-3.908502110590e+000,-9.663624979963e+001,2.464722612175e+001
    6756,-3.908502110590e+000,-9.678568363181e+001,2.352647238038e+001
    6757,-3.908502110590e+000,-9.673489522654e+001,2.390738541993e+001
    6758,-3.908502110590e+000,-9.699492800273e+001,2.195713959850e+001
    6759,-3.908502110590e+000,-9.694712715070e+001,2.231564598867e+001
    6760,-3.908502110590e+000,-9.709656098289e+001,2.119489224730e+001
    6761,-3.908502110590e+000,-9.704577257761e+001,2.157580528685e+001
    6762,-3.908502110590e+000,-9.719221555245e+001,2.047748297558e+001
    6763,-3.908502110590e+000,-9.714441470043e+001,2.083598936575e+001
    6764,-3.908502110590e+000,-9.745529205150e+001,1.850440923267e+001
    6765,-3.908502110590e+000,-9.740749119948e+001,1.886291562284e+001
    6766,-3.908502110590e+000,-9.755393417432e+001,1.776459331157e+001
    6767,-3.908502110590e+000,-9.750314576904e+001,1.814550635113e+001
    6768,-3.908502110590e+000,-9.765556715448e+001,1.700234596037e+001
    6769,-3.908502110590e+000,-9.760477874920e+001,1.738325899993e+001
    6770,-3.908502110590e+000,-9.781994866520e+001,1.576948462994e+001
    6771,-3.908502110590e+000,-9.776916025993e+001,1.615039766950e+001
    6772,-3.908502110590e+000,-9.791859409211e+001,1.502964392813e+001
    6773,-3.908502110590e+000,-9.787079324009e+001,1.538815031830e+001
    6774,-3.908502110590e+000,-9.813381356953e+001,1.341549784748e+001
    6775,-3.908502110590e+000,-9.808003761100e+001,1.381881753642e+001
    6776,-3.908502110590e+000,-9.828629112458e+001,1.227191618463e+001
    6777,-3.908502110590e+000,-9.823550271930e+001,1.265282922419e+001
    6778,-3.908502110590e+000,-9.838194569414e+001,1.155450691292e+001
    6779,-3.908502110590e+000,-9.833414484211e+001,1.191301330309e+001
    6780,-3.908502110590e+000,-9.859716847565e+001,9.940336051555e+000
    6781,-3.908502110590e+000,-9.854936762363e+001,1.029884244173e+001
    6782,-3.908502110590e+000,-9.869282304521e+001,9.222926779839e+000
    6783,-3.908502110590e+000,-9.864502219319e+001,9.581433170010e+000
    6784,-3.908502110590e+000,-9.879146516803e+001,8.483110858736e+000
    6785,-3.908502110590e+000,-9.874067676275e+001,8.864023898293e+000
    6786,-3.908502110590e+000,-9.895883753610e+001,7.227818098209e+000
    6787,-3.908502110590e+000,-9.891103668408e+001,7.586324488380e+000
    6788,-3.908502110590e+000,-9.906047051626e+001,6.465570747010e+000
    6789,-3.908502110590e+000,-9.900968211098e+001,6.846483786567e+000
    6790,-3.908502110590e+000,-9.915911263907e+001,5.725754825907e+000
    6791,-3.908502110590e+000,-9.910832423380e+001,6.106667865464e+000
    6792,-3.908502110590e+000,-9.926373317248e+001,4.941100825323e+000
    6793,-3.908502110590e+000,-9.920995721396e+001,5.344420514265e+000
    6794,-3.908502110590e+000,-9.936835700999e+001,4.156422044027e+000
    6795,-3.908502110590e+000,-9.931756860472e+001,4.537335083584e+000
    6796,-3.908502110590e+000,-9.946998999015e+001,3.394174692829e+000
    6797,-3.908502110590e+000,-9.941920158488e+001,3.775087732385e+000
    6798,-3.908502110590e+000,-9.468429708745e+001,3.928687146307e+001
    6799,-3.908502110590e+000,-9.581421669040e+001,3.081247444092e+001
    6800,-3.908502110590e+000,-9.622373616430e+001,2.774107838673e+001
    6801,-3.908502110590e+000,-9.735664662459e+001,1.924424993449e+001
    6802,-3.908502110590e+000,-9.818465814442e+001,1.303416353583e+001
    6803,-3.908502110590e+000,-9.849852304874e+001,1.068017675337e+001
    6804,-3.908502110590e+000,-9.396688781573e+001,4.466744100094e+001
    6805,-3.908502110590e+000,-9.462753357567e+001,3.971259780140e+001
    6806,-3.908502110590e+000,-9.658247384110e+001,2.505054581069e+001
    6807,-3.908502110590e+000,-9.683353734935e+001,2.316756949883e+001
    6808,-3.908502110590e+000,-9.724306012733e+001,2.009614866394e+001
    6809,-3.908502110590e+000,-9.796644780965e+001,1.467074104658e+001
    6810,-3.908502110590e+000,-9.616398509927e+001,2.818921137445e+001
    6811,-3.908502110590e+000,-9.390713675071e+001,4.511557398866e+001
    6812,-3.908502110590e+000,-9.575147807212e+001,3.128301407801e+001
    6813,-3.908502110590e+000,-9.689036363893e+001,2.274137232699e+001
    6814,-3.908502110590e+000,-9.729689555957e+001,1.969238292220e+001
    6815,-3.908502110590e+000,-9.771538430140e+001,1.655371735844e+001
    6816,-3.908502110590e+000,-9.802321132143e+001,1.424501470825e+001
    6817,-3.908502110590e+000,-9.843877198372e+001,1.112830974108e+001
    6818,-3.908502110590e+000,-9.885427317230e+001,8.012050826708e+000
    6819,-3.661141477015e+000,-9.390466058429e+001,4.655284093573e+001
    6820,-3.611381950365e+000,-9.400480993352e+001,4.580172081650e+001
    6821,-3.611381950365e+000,-9.395994707333e+001,4.613819226795e+001
    6822,-3.410719697279e+000,-9.424043862909e+001,4.403450559971e+001
    6823,-3.410719697279e+000,-9.418959405421e+001,4.441583991135e+001
    6824,-3.647909684616e+000,-9.442217048682e+001,4.267151666673e+001
    6825,-3.647909684616e+000,-9.437132591194e+001,4.305285097837e+001
    6826,-3.392170896009e+000,-9.462956588418e+001,4.111605118651e+001
    6827,-3.392170896009e+000,-9.458171216665e+001,4.147495406806e+001
    6828,-3.477418288888e+000,-9.483669292059e+001,3.956259841348e+001
    6829,-3.477418288888e+000,-9.478285748836e+001,3.996636415521e+001
    6830,-3.402456440229e+000,-9.504496502955e+001,3.800055759627e+001
    6831,-3.402456440229e+000,-9.499412045466e+001,3.838189190792e+001
    6832,-3.464008590675e+000,-9.524050352994e+001,3.653401884333e+001
    6833,-3.464008590675e+000,-9.519264981240e+001,3.689292172488e+001
    6834,-3.419035349461e+000,-9.545067404060e+001,3.495774001338e+001
    6835,-3.419035349461e+000,-9.540282032306e+001,3.531664289492e+001
    6836,-3.620270161317e+000,-9.564086629667e+001,3.353129809287e+001
    6837,-3.620270161317e+000,-9.558703086444e+001,3.393506383461e+001
    6838,-3.429720438431e+000,-9.584961038034e+001,3.196571746534e+001
    6839,-3.429720438431e+000,-9.579876580546e+001,3.234705177698e+001
    6840,-3.392317511716e+000,-9.606991452706e+001,3.031343636495e+001
    6841,-3.392317511716e+000,-9.601906995217e+001,3.069477067659e+001
    6842,-3.636069608568e+000,-9.626824964360e+001,2.882592299090e+001
    6843,-3.636069608568e+000,-9.621740506871e+001,2.920725730254e+001
    6844,-3.606925336883e+000,-9.646443229239e+001,2.735455312493e+001
    6845,-3.606925336883e+000,-9.651527686728e+001,2.697321881329e+001
    6846,-3.589700366232e+000,-9.667780089496e+001,2.575428860570e+001
    6847,-3.589700366232e+000,-9.662396546273e+001,2.615805434744e+001
    6848,-3.623906578321e+000,-9.679049970472e+001,2.490904753247e+001
    6849,-3.623906578321e+000,-9.673367341514e+001,2.533524470431e+001
    6850,-3.443788067172e+000,-9.699753322759e+001,2.335629611096e+001
    6851,-3.443788067172e+000,-9.694967951005e+001,2.371519899250e+001
    6852,-3.618825974509e+000,-9.720801413646e+001,2.177768929443e+001
    6853,-3.618825974509e+000,-9.715716956158e+001,2.215902360607e+001
    6854,-3.446101857866e+000,-9.740776887676e+001,2.027952874222e+001
    6855,-3.446101857866e+000,-9.735692430187e+001,2.066086305386e+001
    6856,-3.608516993248e+000,-9.761126899151e+001,1.875327788157e+001
    6857,-3.608516993248e+000,-9.756042441662e+001,1.913461219322e+001
    6858,-3.616398099019e+000,-9.779446238984e+001,1.737932739412e+001
    6859,-3.616398099019e+000,-9.774361781495e+001,1.776066170576e+001
    6860,-3.406724564160e+000,-9.802824179367e+001,1.562598186541e+001
    6861,-3.406724564160e+000,-9.797739721878e+001,1.600731617705e+001
    6862,-3.619103515341e+000,-9.823739881070e+001,1.405730423766e+001
    6863,-3.619103515341e+000,-9.818057252112e+001,1.448350140949e+001
    6864,-3.454956275506e+000,-9.844660208225e+001,1.248827970105e+001
    6865,-3.454956275506e+000,-9.839575750736e+001,1.286961401269e+001
    6866,-3.603382538383e+000,-9.863628853099e+001,1.106563133544e+001
    6867,-3.603382538383e+000,-9.869311482057e+001,1.063943416361e+001
    6868,-3.626017254758e+000,-9.884614994205e+001,9.491670752530e+000
    6869,-3.626017254758e+000,-9.879829622451e+001,9.850573634075e+000
    6870,-3.435885268525e+000,-9.907113400458e+001,7.804290283576e+000
    6871,-3.435885268525e+000,-9.900832600031e+001,8.275350315605e+000
    6872,-3.403399725510e+000,-9.927605939440e+001,6.267349859893e+000
    6873,-3.403399725510e+000,-9.922820567686e+001,6.626252741439e+000
    6874,-3.437332940369e+000,-9.948881652134e+001,4.671671407848e+000
    6875,-3.437332940369e+000,-9.943498108911e+001,5.075437149587e+000
    6876,-3.618332416707e+000,-9.969463965032e+001,3.127997940530e+000
    6877,-3.618332416707e+000,-9.964379507543e+001,3.509332252172e+000
    6878,-3.623692456793e+000,-9.982655812979e+001,2.138609344481e+000
    6879,-2.931760011127e+000,-9.981273240772e+001,2.242302259985e+000
    6880,-3.308221214416e+000,-9.981273240772e+001,2.242302259985e+000
    6881,-2.261730721334e+000,-9.981459470040e+001,2.228335064867e+000
    6882,-2.428853198290e+000,-9.956052757793e+001,4.133838483400e+000
    6883,-2.428853198290e+000,-9.962632643955e+001,3.640347021275e+000
    6884,-2.451832408199e+000,-9.943797194645e+001,5.053005719490e+000
    6885,-2.451832408199e+000,-9.950077995072e+001,4.581945687462e+000
    6886,-2.417899193340e+000,-9.925811425032e+001,6.401938440473e+000
    6887,-2.417899193340e+000,-9.932989482663e+001,5.863584118154e+000
    6888,-2.417899193340e+000,-9.919829710340e+001,6.850567042404e+000
    6889,-2.450384736355e+000,-9.902627114438e+001,8.140761735025e+000
    6890,-2.450384736355e+000,-9.909207000600e+001,7.647270272900e+000
    6891,-2.268444190358e+000,-9.875458279880e+001,1.017842432687e+001
    6892,-2.268444190358e+000,-9.881739080307e+001,9.707364294846e+000
    6893,-2.306013002197e+000,-9.863116405051e+001,1.110406493908e+001
    6894,-2.306013002197e+000,-9.868499948274e+001,1.070029919734e+001
    6895,-2.306013002197e+000,-9.857433776093e+001,1.153026211092e+001
    6896,-2.469455743336e+000,-9.839874836471e+001,1.284718258260e+001
    6897,-2.469455743336e+000,-9.846753808367e+001,1.233125969038e+001
    6898,-2.277634316347e+000,-9.816176712828e+001,1.462454185579e+001
    6899,-2.277634316347e+000,-9.822158427520e+001,1.417591325386e+001
    6900,-2.421224031990e+000,-9.800132407755e+001,1.582786473628e+001
    6901,-2.421224031990e+000,-9.806114122447e+001,1.537923613434e+001
    6902,-2.421224031990e+000,-9.792954350124e+001,1.636621905859e+001
    6903,-2.266476828855e+000,-9.775947988304e+001,1.764169619508e+001
    6904,-2.266476828855e+000,-9.782228788731e+001,1.717063616305e+001
    6905,-2.247895848441e+000,-9.751331182987e+001,1.948795659386e+001
    6906,-2.247895848441e+000,-9.758210154883e+001,1.897203370164e+001
    6907,-2.460601325696e+000,-9.736589687391e+001,2.059356876357e+001
    6908,-2.460601325696e+000,-9.742571402083e+001,2.014494016164e+001
    6909,-2.262035003016e+000,-9.712379648820e+001,2.240932165639e+001
    6910,-2.262035003016e+000,-9.718660449247e+001,2.193826162436e+001
    6911,-2.458287535001e+000,-9.696164293944e+001,2.362547327212e+001
    6912,-2.458287535001e+000,-9.703043265840e+001,2.310955037989e+001
    6913,-2.270471439900e+000,-9.671009778948e+001,2.551206189682e+001
    6914,-2.270471439900e+000,-9.677888750844e+001,2.499613900460e+001
    6915,-2.270546379709e+000,-9.658091577525e+001,2.648092700353e+001
    6916,-2.270546379709e+000,-9.664671463686e+001,2.598743554141e+001
    6917,-2.325089712338e+000,-9.643959812554e+001,2.754080937633e+001
    6918,-2.325089712338e+000,-9.650240612981e+001,2.706974934430e+001
    6919,-2.325089712338e+000,-9.637080840658e+001,2.805673226855e+001
    6920,-2.296641120142e+000,-9.620712067339e+001,2.928439026744e+001
    6921,-2.296641120142e+000,-9.626693782032e+001,2.883576166550e+001
    6922,-2.406816979546e+000,-9.604000595360e+001,3.053775066592e+001
    6923,-2.406816979546e+000,-9.610879567256e+001,3.002182777370e+001
    6924,-2.406816979546e+000,-9.597420709198e+001,3.103124212804e+001
    6925,-2.444219906261e+000,-9.579876580546e+001,3.234705177698e+001
    6926,-2.444219906261e+000,-9.586456466707e+001,3.185356031486e+001
    6927,-2.283629763674e+000,-9.554055798749e+001,3.428361041174e+001
    6928,-2.283629763674e+000,-9.560336599176e+001,3.381255037971e+001
    6929,-2.433534817291e+000,-9.540581118041e+001,3.529421146483e+001
    6930,-2.433534817291e+000,-9.547460089937e+001,3.477828857261e+001
    6931,-2.478508058505e+000,-9.517171381098e+001,3.704994173555e+001
    6932,-2.478508058505e+000,-9.524050352994e+001,3.653401884333e+001
    6933,-2.416955908059e+000,-9.501206559874e+001,3.824730332734e+001
    6934,-2.416955908059e+000,-9.507188274567e+001,3.779867472540e+001
    6935,-2.416955908059e+000,-9.494626673712e+001,3.874079478946e+001
    6936,-2.491917756718e+000,-9.477687577367e+001,4.001122701541e+001
    6937,-2.491917756718e+000,-9.484267463528e+001,3.951773555328e+001
    6938,-2.406670363839e+000,-9.460563902541e+001,4.129550262728e+001
    6939,-2.406670363839e+000,-9.467442874438e+001,4.077957973506e+001
    6940,-2.406670363839e+000,-9.454283102114e+001,4.176656265931e+001
    6941,-2.310469570151e+000,-9.436618304467e+001,4.309142248287e+001
    6942,-2.310469570151e+000,-9.443198190629e+001,4.259793102074e+001
    6943,-2.425219165109e+000,-9.421651177032e+001,4.421395704048e+001
    6944,-2.425219165109e+000,-9.429128320398e+001,4.365317128806e+001
    6945,-2.262423637924e+000,-9.400364711013e+001,4.581044199194e+001
    6946,-2.262423637924e+000,-9.404850997032e+001,4.547397054049e+001
    6947,-2.129673650023e+000,-9.389568801225e+001,4.662013522602e+001
    6948,-2.597949959474e+000,-9.390170539716e+001,4.657500483921e+001
    6949,-2.369313836011e+000,-9.390170539716e+001,4.657500483921e+001
    6950,-3.364021316791e+000,-9.392704764252e+001,4.638493799902e+001
    6951,-2.177141232238e+000,-9.392563225593e+001,4.639555339844e+001
    6952,-2.918680111991e+000,-9.416763074048e+001,4.458056476427e+001
    6953,-3.416462525302e+000,-9.412495671561e+001,4.490061995083e+001
    6954,-3.416462525302e+000,-9.406513956868e+001,4.534924855276e+001
    6955,-2.430961993132e+000,-9.415187443172e+001,4.469873707996e+001
    6956,-3.631020357967e+000,-9.432885412055e+001,4.337138941376e+001
    6957,-3.631020357967e+000,-9.428100040301e+001,4.373029229531e+001
    6958,-3.515539867798e+000,-9.452408236525e+001,4.190717757850e+001
    6959,-3.515539867798e+000,-9.446725607567e+001,4.233337475034e+001
    6960,-3.538148421317e+000,-9.473214058992e+001,4.034674089346e+001
    6961,-3.538148421317e+000,-9.468129601504e+001,4.072807520510e+001
    6962,-3.540704061878e+000,-9.494392232719e+001,3.875837786398e+001
    6963,-3.540704061878e+000,-9.489008689496e+001,3.916214360571e+001
    6964,-3.539258997808e+000,-9.514397648184e+001,3.725797170413e+001
    6965,-3.539258997808e+000,-9.509612276430e+001,3.761687458568e+001
    6966,-2.950006749206e+000,-9.537964897257e+001,3.549042802360e+001
    6967,-3.439473510335e+000,-9.534401847610e+001,3.575765674718e+001
    6968,-3.439473510335e+000,-9.529317390121e+001,3.613899105882e+001
    6969,-2.453972978165e+000,-9.534700933344e+001,3.573522531709e+001
    6970,-3.631032008872e+000,-9.554414014606e+001,3.425674422245e+001
    6971,-3.631032008872e+000,-9.549329557117e+001,3.463807853409e+001
    6972,-2.922218535538e+000,-9.576573567866e+001,3.259477772798e+001
    6973,-3.401000207696e+000,-9.574091629887e+001,3.278092307636e+001
    6974,-3.401000207696e+000,-9.569007172399e+001,3.316225738800e+001
    6975,-2.415499675526e+000,-9.574091629887e+001,3.278092307636e+001
    6976,-3.506508529631e+000,-9.596220664932e+001,3.112124544800e+001
    6977,-3.506508529631e+000,-9.590238950240e+001,3.156987404993e+001
    6978,-3.522912022624e+000,-9.617200883552e+001,2.954772905146e+001
    6979,-3.522912022624e+000,-9.612415511799e+001,2.990663193300e+001
    6980,-3.497043896121e+000,-9.636862290345e+001,2.807312354202e+001
    6981,-3.497043896121e+000,-9.631478747122e+001,2.847688928375e+001
    6982,-3.606925336883e+000,-9.656313058482e+001,2.661431593175e+001
    6983,-3.305104833962e+000,-9.670438039242e+001,2.555494237478e+001
    6984,-2.958497329104e+000,-9.691888056796e+001,2.394619105816e+001
    6985,-3.423211372522e+000,-9.689163670453e+001,2.415052003393e+001
    6986,-3.423211372522e+000,-9.684079212964e+001,2.453185434557e+001
    6987,-2.437710840352e+000,-9.690360013391e+001,2.406079431354e+001
    6988,-3.521165713736e+000,-9.710457983751e+001,2.255344653654e+001
    6989,-3.521165713736e+000,-9.704775354794e+001,2.297964370838e+001
    6990,-2.965960705044e+000,-9.732968480996e+001,2.086515924319e+001
    6991,-3.428360957768e+000,-9.730195275379e+001,2.107314966447e+001
    6992,-3.428360957768e+000,-9.725409903625e+001,2.143205254602e+001
    6993,-2.442860425598e+000,-9.731092532583e+001,2.100585537418e+001
    6994,-3.527792812887e+000,-9.751159469784e+001,1.950083508408e+001
    6995,-3.527792812887e+000,-9.745775926561e+001,1.990460082582e+001
    6996,-3.616398099019e+000,-9.769576409741e+001,1.811956458730e+001
    6997,-3.505590376058e+000,-9.791559196339e+001,1.647085559250e+001
    6998,-3.505590376058e+000,-9.785577481646e+001,1.691948419444e+001
    6999,-3.526539248122e+000,-9.813304776208e+001,1.483993710231e+001
    7000,-3.526539248122e+000,-9.808519404454e+001,1.519883998385e+001
    7001,-2.961193534025e+000,-9.836537512974e+001,1.309748184485e+001
    7002,-3.414739369108e+000,-9.833962822456e+001,1.329058363367e+001
    7003,-3.414739369108e+000,-9.828878364968e+001,1.367191794531e+001
    7004,-2.429238836938e+000,-9.834261908191e+001,1.326815220358e+001
    7005,-3.513053725533e+000,-9.854581447087e+001,1.174418678640e+001
    7006,-3.513053725533e+000,-9.849796075333e+001,1.210308966794e+001
    7007,-3.603382538383e+000,-9.874395939546e+001,1.025809985197e+001
    7008,-2.945442111917e+000,-9.898005379991e+001,8.487391818559e+000
    7009,-3.418058953981e+000,-9.894589158572e+001,8.743608424964e+000
    7010,-3.418058953981e+000,-9.889803786818e+001,9.102511306510e+000
    7011,-2.432558421811e+000,-9.896383672980e+001,8.609019844385e+000
    7012,-3.538493874958e+000,-9.917526091353e+001,7.023338466417e+000
    7013,-3.538493874958e+000,-9.912441633864e+001,7.404672778060e+000
    7014,-3.531005650691e+000,-9.937815402721e+001,5.501640113829e+000
    7015,-3.531005650691e+000,-9.932730945232e+001,5.882974425471e+000
    7016,-3.124184036577e+000,-9.963497825535e+001,3.575458402784e+000
    7017,-3.414353730460e+000,-9.959940872343e+001,3.842229892144e+000
    7018,-3.414353730460e+000,-9.954856414855e+001,4.223564203786e+000
    7019,-3.593030868213e+000,-9.978581469161e+001,2.444185130854e+000
    7020,-2.272499443929e+000,-9.975275407683e+001,2.692139741693e+000
    7021,-2.596729119012e+000,-9.979163522233e+001,2.400531150438e+000
    7022,-2.943184560239e+000,-9.953084427614e+001,4.356463246818e+000
    7023,-2.272499443929e+000,-9.969592778725e+001,3.118336913529e+000
    7024,-2.763851595969e+000,-9.966019325105e+001,3.386345935010e+000
    7025,-3.065877032894e+000,-9.909577054856e+001,7.619516203683e+000
    7026,-2.763501565920e+000,-9.884594489226e+001,9.493208625965e+000
    7027,-2.432558421811e+000,-9.888906529615e+001,9.169805596799e+000
    7028,-2.636956146306e+000,-9.870468708312e+001,1.055264219448e+001
    7029,-3.059507890449e+000,-9.847286308362e+001,1.229132219076e+001
    7030,-2.769372107035e+000,-9.825400990185e+001,1.393272105398e+001
    7031,-2.429238836938e+000,-9.827682022029e+001,1.376164366570e+001
    7032,-2.353053408687e+000,-9.770184482974e+001,1.807395909483e+001
    7033,-2.682029191292e+000,-9.772537586800e+001,1.789747630791e+001
    7034,-2.353053408687e+000,-9.763604596813e+001,1.856745055696e+001
    7035,-2.767394382365e+000,-9.721918214748e+001,2.169392921176e+001
    7036,-2.442860425598e+000,-9.724213560687e+001,2.152177826640e+001
    7037,-2.770681234002e+000,-9.679594228389e+001,2.486822818871e+001
    7038,-2.437710840352e+000,-9.684378298699e+001,2.450942291547e+001
    7039,-3.027726857473e+000,-9.587636430729e+001,3.176506301319e+001
    7040,-2.761628392950e+000,-9.563912558392e+001,3.354435343848e+001
