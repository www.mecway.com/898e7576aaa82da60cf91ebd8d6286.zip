    2817,-3.908502110590e+000,-9.404079762851e+001,4.269442170619e+001
    2818,-3.908502110590e+000,-9.414536199231e+001,4.191018897769e+001
    2819,-3.908502110590e+000,-9.424395124961e+001,4.117076954796e+001
    2820,-3.908502110590e+000,-9.434254050690e+001,4.043135011823e+001
    2821,-3.908502110590e+000,-9.444710487070e+001,3.964711738973e+001
    2822,-3.908502110590e+000,-9.455465678775e+001,3.884047801185e+001
    2823,-3.908502110590e+000,-9.465324604505e+001,3.810105858212e+001
    2824,-3.908502110590e+000,-9.475183530235e+001,3.736163915239e+001
    2825,-3.908502110590e+000,-9.485341211290e+001,3.659981307328e+001
    2826,-3.908502110590e+000,-9.495200137019e+001,3.586039364355e+001
    2827,-3.908502110590e+000,-9.505059062749e+001,3.512097421382e+001
    2828,-3.908502110590e+000,-9.515515499129e+001,3.433674148533e+001
    2829,-3.908502110590e+000,-9.525971935509e+001,3.355250875683e+001
    2830,-3.908502110590e+000,-9.536129616564e+001,3.279068267771e+001
    2831,-3.908502110590e+000,-9.545988542294e+001,3.205126324798e+001
    2832,-3.908502110590e+000,-9.557042489324e+001,3.122221722071e+001
    2833,-3.908502110590e+000,-9.568096436354e+001,3.039317119344e+001
    2834,-3.908502110590e+000,-9.577656606759e+001,2.967615841310e+001
    2835,-3.908502110590e+000,-9.587515532488e+001,2.893673898337e+001
    2836,-3.908502110590e+000,-9.598569479519e+001,2.810769295610e+001
    2837,-3.908502110590e+000,-9.609324671224e+001,2.730105357822e+001
    2838,-3.908502110590e+000,-9.618884841628e+001,2.658404079788e+001
    2839,-3.908502110590e+000,-9.629042522683e+001,2.582221471876e+001
    2840,-3.908502110590e+000,-9.639797714388e+001,2.501557534088e+001
    2841,-3.908502110590e+000,-9.649955395443e+001,2.425374926176e+001
    2842,-3.908502110590e+000,-9.659814321173e+001,2.351432983204e+001
    2843,-3.908502110590e+000,-9.670569512878e+001,2.270769045415e+001
    2844,-3.908502110590e+000,-9.681025949258e+001,2.192345772565e+001
    2845,-3.908502110590e+000,-9.690884874988e+001,2.118403829592e+001
    2846,-3.908502110590e+000,-9.700743800717e+001,2.044461886620e+001
    2847,-3.908502110590e+000,-9.711498992423e+001,1.963797948831e+001
    2848,-3.908502110590e+000,-9.722254184128e+001,1.883134011043e+001
    2849,-3.908502110590e+000,-9.732113109857e+001,1.809192068070e+001
    2850,-3.908502110590e+000,-9.742270790912e+001,1.733009460158e+001
    2851,-3.908502110590e+000,-9.752727227292e+001,1.654586187308e+001
    2852,-3.908502110590e+000,-9.763183663672e+001,1.576162914458e+001
    2853,-3.908502110590e+000,-9.773042589402e+001,1.502220971486e+001
    2854,-3.908502110590e+000,-9.783499025782e+001,1.423797698636e+001
    2855,-3.908502110590e+000,-9.794552972812e+001,1.340893095909e+001
    2856,-3.908502110590e+000,-9.805009409192e+001,1.262469823059e+001
    2857,-3.908502110590e+000,-9.814868334922e+001,1.188527880086e+001
    2858,-3.908502110590e+000,-9.825623526627e+001,1.107863942297e+001
    2859,-3.908502110590e+000,-9.836378718332e+001,1.027200004509e+001
    2860,-3.908502110590e+000,-9.845938888737e+001,9.554987264748e+000
    2861,-3.908502110590e+000,-9.855797814466e+001,8.815567835020e+000
    2862,-3.908502110590e+000,-9.866553006172e+001,8.008928457135e+000
    2863,-3.908502110590e+000,-9.877009442552e+001,7.224695728635e+000
    2864,-3.908502110590e+000,-9.886868368281e+001,6.485276298907e+000
    2865,-3.908502110590e+000,-9.897026049336e+001,5.723450219794e+000
    2866,-3.908502110590e+000,-9.907482485716e+001,4.939217491295e+000
    2867,-3.908502110590e+000,-9.917938922096e+001,4.154984762795e+000
    2868,-3.908502110590e+000,-9.928096603151e+001,3.393158683682e+000
    2869,-3.908502110590e+000,-9.937656773555e+001,2.676145903339e+000
    2870,-3.908502110590e+000,-9.944826901359e+001,2.138386318083e+000
    2871,-3.908502110590e+000,-9.966431641938e+001,1.936726473612e+000
    2872,-3.908502110590e+000,-9.390466058429e+001,4.655284093573e+001
    2873,-3.908502110590e+000,-9.398242287529e+001,4.596962375322e+001
    2874,-3.908502110590e+000,-9.408710288241e+001,4.518452369984e+001
    2875,-3.908502110590e+000,-9.419776460422e+001,4.435456078627e+001
    2876,-3.908502110590e+000,-9.429646289664e+001,4.361432359308e+001
    2877,-3.908502110590e+000,-9.439516118907e+001,4.287408639989e+001
    2878,-3.908502110590e+000,-9.450283205353e+001,4.206655491642e+001
    2879,-3.908502110590e+000,-9.460751206065e+001,4.128145486304e+001
    2880,-3.908502110590e+000,-9.470621035307e+001,4.054121766985e+001
    2881,-3.908502110590e+000,-9.481089036019e+001,3.975611761647e+001
    2882,-3.908502110590e+000,-9.491856122465e+001,3.894858613299e+001
    2883,-3.908502110590e+000,-9.502324123177e+001,3.816348607961e+001
    2884,-3.908502110590e+000,-9.512193952420e+001,3.742324888642e+001
    2885,-3.908502110590e+000,-9.521764695928e+001,3.670544312333e+001
    2886,-3.908502110590e+000,-9.531634525170e+001,3.596520593014e+001
    2887,-3.908502110590e+000,-9.541504354413e+001,3.522496873696e+001
    2888,-3.908502110590e+000,-9.551374183655e+001,3.448473154377e+001
    2889,-3.908502110590e+000,-9.561842184367e+001,3.369963149039e+001
    2890,-3.908502110590e+000,-9.572310185079e+001,3.291453143701e+001
    2891,-3.908502110590e+000,-9.582479100056e+001,3.215186281372e+001
    2892,-3.908502110590e+000,-9.593545272237e+001,3.132189990015e+001
    2893,-3.908502110590e+000,-9.604611444418e+001,3.049193698657e+001
    2894,-3.908502110590e+000,-9.614481273660e+001,2.975169979339e+001
    2895,-3.908502110590e+000,-9.624351102903e+001,2.901146260020e+001
    2896,-3.908502110590e+000,-9.634819103614e+001,2.822636254682e+001
    2897,-3.908502110590e+000,-9.645287104326e+001,2.744126249344e+001
    2898,-3.908502110590e+000,-9.655156933569e+001,2.670102530025e+001
    2899,-3.908502110590e+000,-9.665325848546e+001,2.593835667697e+001
    2900,-3.908502110590e+000,-9.676392020727e+001,2.510839376339e+001
    2901,-3.908502110590e+000,-9.687159107173e+001,2.430086227991e+001
    2902,-3.908502110590e+000,-9.697028936416e+001,2.356062508673e+001
    2903,-3.908502110590e+000,-9.707496937127e+001,2.277552503335e+001
    2904,-3.908502110590e+000,-9.718264023574e+001,2.196799354987e+001
    2905,-3.908502110590e+000,-9.728133852816e+001,2.122775635668e+001
    2906,-3.908502110590e+000,-9.738003682059e+001,2.048751916349e+001
    2907,-3.908502110590e+000,-9.748471682770e+001,1.970241911011e+001
    2908,-3.908502110590e+000,-9.758939683482e+001,1.891731905673e+001
    2909,-3.908502110590e+000,-9.768809512725e+001,1.817708186354e+001
    2910,-3.908502110590e+000,-9.778679341967e+001,1.743684467036e+001
    2911,-3.908502110590e+000,-9.789745514148e+001,1.660688175678e+001
    2912,-3.908502110590e+000,-9.800811686329e+001,1.577691884321e+001
    2913,-3.908502110590e+000,-9.810681515572e+001,1.503668165002e+001
    2914,-3.908502110590e+000,-9.821149516283e+001,1.425158159664e+001
    2915,-3.908502110590e+000,-9.831916602730e+001,1.344405011316e+001
    2916,-3.908502110590e+000,-9.842085517707e+001,1.268138148988e+001
    2917,-3.908502110590e+000,-9.851955346949e+001,1.194114429669e+001
    2918,-3.908502110590e+000,-9.862423347661e+001,1.115604424331e+001
    2919,-3.908502110590e+000,-9.873190434107e+001,1.034851275983e+001
    2920,-3.908502110590e+000,-9.883060263350e+001,9.608275566646e+000
    2921,-3.908502110590e+000,-9.892631006858e+001,8.890469803555e+000
    2922,-3.908502110590e+000,-9.903697179039e+001,8.060506889981e+000
    2923,-3.908502110590e+000,-9.915062436954e+001,7.208112546311e+000
    2924,-3.908502110590e+000,-9.924932266197e+001,6.467875353123e+000
    2925,-3.908502110590e+000,-9.934802095439e+001,5.727638159936e+000
    2926,-3.908502110590e+000,-9.945270096151e+001,4.942538106555e+000
    2927,-3.908502110590e+000,-9.955738096863e+001,4.157438053174e+000
    2928,-3.908502110590e+000,-9.965907011840e+001,3.394769429890e+000
    2929,-3.908502110590e+000,-9.975477755348e+001,2.676963666799e+000
    2930,-3.908502110590e+000,-9.982655812979e+001,2.138609344481e+000
    2931,-3.623692456793e+000,-9.985347584590e+001,1.936726473612e+000
    2932,-2.962421599707e+000,-9.985347584590e+001,1.936726473612e+000
    2933,-2.261730721334e+000,-9.985347584590e+001,1.936726473612e+000
    2934,-3.672724983270e+000,-9.947515699285e+001,1.936726473612e+000
    2935,-3.139214695175e+000,-9.947515699285e+001,1.936726473612e+000
    2936,-2.514491357825e+000,-9.947515699285e+001,1.936726473612e+000
    2937,-2.513630857360e+000,-8.950004833000e+001,1.936726473612e+000
    2938,-3.148680200286e+000,-8.950004833000e+001,1.936726473612e+000
    2939,-3.683050988846e+000,-8.950004833000e+001,1.936726473612e+000
    2940,-3.908502110590e+000,-8.950004833000e+001,2.115979668697e+000
    2941,-3.908502110590e+000,-8.950004833000e+001,2.519299357640e+000
    2942,-3.908502110590e+000,-8.950004833000e+001,3.034652293511e+000
    2943,-3.908502110590e+000,-8.950004833000e+001,3.594818528153e+000
    2944,-3.908502110590e+000,-8.950004833000e+001,4.132578113410e+000
    2945,-3.908502110590e+000,-8.950004833000e+001,4.670337698666e+000
    2946,-3.908502110590e+000,-8.950004833000e+001,5.208097283923e+000
    2947,-3.908502110590e+000,-8.950004833000e+001,5.768263518565e+000
    2948,-3.908502110590e+000,-8.950004833000e+001,6.328429753208e+000
    2949,-3.908502110590e+000,-8.950004833000e+001,6.866189338464e+000
    2950,-3.908502110590e+000,-8.950004833000e+001,7.403948923721e+000
    2951,-3.908502110590e+000,-8.950004833000e+001,7.941708508978e+000
    2952,-3.908502110590e+000,-8.950004833000e+001,8.501874743620e+000
    2953,-3.908502110590e+000,-8.950004833000e+001,9.062040978262e+000
    2954,-3.908502110590e+000,-8.950004833000e+001,9.599800563519e+000
    2955,-3.908502110590e+000,-8.950004833000e+001,1.013756014878e+001
    2956,-3.908502110590e+000,-8.950004833000e+001,1.067531973403e+001
    2957,-3.908502110590e+000,-8.950004833000e+001,1.123548596867e+001
    2958,-3.908502110590e+000,-8.950004833000e+001,1.179565220332e+001
    2959,-3.908502110590e+000,-8.950004833000e+001,1.237822508735e+001
    2960,-3.908502110590e+000,-8.950004833000e+001,1.296079797137e+001
    2961,-3.908502110590e+000,-8.950004833000e+001,1.349855755663e+001
    2962,-3.908502110590e+000,-8.950004833000e+001,1.403631714189e+001
    2963,-3.908502110590e+000,-8.950004833000e+001,1.459648337653e+001
    2964,-3.908502110590e+000,-8.950004833000e+001,1.515664961117e+001
    2965,-3.908502110590e+000,-8.950004833000e+001,1.571681584581e+001
    2966,-3.908502110590e+000,-8.950004833000e+001,1.627698208046e+001
    2967,-3.908502110590e+000,-8.950004833000e+001,1.683714831510e+001
    2968,-3.908502110590e+000,-8.950004833000e+001,1.739731454974e+001
    2969,-3.908502110590e+000,-8.950004833000e+001,1.795748078438e+001
    2970,-3.908502110590e+000,-8.950004833000e+001,1.851764701903e+001
    2971,-3.908502110590e+000,-8.950004833000e+001,1.907781325367e+001
    2972,-3.908502110590e+000,-8.950004833000e+001,1.963797948831e+001
    2973,-3.908502110590e+000,-8.950004833000e+001,2.019814572295e+001
    2974,-3.908502110590e+000,-8.950004833000e+001,2.075831195759e+001
    2975,-3.908502110590e+000,-8.950004833000e+001,2.129607154285e+001
    2976,-3.908502110590e+000,-8.950004833000e+001,2.183383112811e+001
    2977,-3.908502110590e+000,-8.950004833000e+001,2.239399736275e+001
    2978,-3.908502110590e+000,-8.950004833000e+001,2.295416359739e+001
    2979,-3.908502110590e+000,-8.950004833000e+001,2.351432983204e+001
    2980,-3.908502110590e+000,-8.950004833000e+001,2.407449606668e+001
    2981,-3.908502110590e+000,-8.950004833000e+001,2.461225565193e+001
    2982,-3.908502110590e+000,-8.950004833000e+001,2.517242188658e+001
    2983,-3.908502110590e+000,-8.950004833000e+001,2.573258812122e+001
    2984,-3.908502110590e+000,-8.950004833000e+001,2.627034770648e+001
    2985,-3.908502110590e+000,-8.950004833000e+001,2.680810729173e+001
    2986,-3.908502110590e+000,-8.950004833000e+001,2.734586687699e+001
    2987,-3.908502110590e+000,-8.950004833000e+001,2.788362646225e+001
    2988,-3.908502110590e+000,-8.950004833000e+001,2.844379269689e+001
    2989,-3.908502110590e+000,-8.950004833000e+001,2.900395893153e+001
    2990,-3.908502110590e+000,-8.950004833000e+001,2.956412516617e+001
    2991,-3.908502110590e+000,-8.950004833000e+001,3.012429140081e+001
    2992,-3.908502110590e+000,-8.950004833000e+001,3.066205098607e+001
    2993,-3.908502110590e+000,-8.950004833000e+001,3.119981057133e+001
    2994,-3.908502110590e+000,-8.950004833000e+001,3.173757015658e+001
    2995,-3.908502110590e+000,-8.950004833000e+001,3.227532974184e+001
    2996,-3.908502110590e+000,-8.950004833000e+001,3.283549597648e+001
    2997,-3.908502110590e+000,-8.950004833000e+001,3.341806886051e+001
    2998,-3.908502110590e+000,-8.950004833000e+001,3.397823509515e+001
    2999,-3.908502110590e+000,-8.950004833000e+001,3.451599468041e+001
    3000,-3.908502110590e+000,-8.950004833000e+001,3.505375426567e+001
    3001,-3.908502110590e+000,-8.950004833000e+001,3.561392050031e+001
    3002,-3.908502110590e+000,-8.950004833000e+001,3.617408673495e+001
    3003,-3.908502110590e+000,-8.950004833000e+001,3.671184632021e+001
    3004,-3.908502110590e+000,-8.950004833000e+001,3.724960590547e+001
    3005,-3.908502110590e+000,-8.950004833000e+001,3.778736549072e+001
    3006,-3.908502110590e+000,-8.950004833000e+001,3.834753172536e+001
    3007,-3.908502110590e+000,-8.950004833000e+001,3.890769796001e+001
    3008,-3.908502110590e+000,-8.950004833000e+001,3.946786419465e+001
    3009,-3.908502110590e+000,-8.950004833000e+001,4.002803042929e+001
    3010,-3.908502110590e+000,-8.950004833000e+001,4.058819666393e+001
    3011,-3.908502110590e+000,-8.950004833000e+001,4.114836289858e+001
    3012,-3.908502110590e+000,-8.950004833000e+001,4.168612248383e+001
    3013,-3.908502110590e+000,-8.950004833000e+001,4.222388206909e+001
    3014,-3.908502110590e+000,-8.950004833000e+001,4.278404830373e+001
    3015,-3.908502110590e+000,-8.950004833000e+001,4.334421453837e+001
    3016,-3.908502110590e+000,-8.950004833000e+001,4.390438077302e+001
    3017,-3.908502110590e+000,-8.950004833000e+001,4.446454700766e+001
    3018,-3.908502110590e+000,-8.950004833000e+001,4.500230659292e+001
    3019,-3.908502110590e+000,-8.950004833000e+001,4.556247282756e+001
    3020,-3.908502110590e+000,-8.950004833000e+001,4.612263906220e+001
    3021,-3.908502110590e+000,-8.950004833000e+001,4.657077204991e+001
    3022,-3.908502110590e+000,-8.925004819500e+001,2.093573019311e+000
    3023,-3.908502110590e+000,-8.925004819500e+001,2.407266110711e+000
    3024,-3.908502110590e+000,-8.925004819500e+001,2.810585799654e+000
    3025,-3.908502110590e+000,-8.925004819500e+001,3.370752034296e+000
    3026,-3.908502110590e+000,-8.925004819500e+001,3.975731567710e+000
    3027,-3.908502110590e+000,-8.925004819500e+001,4.558304451738e+000
    3028,-3.908502110590e+000,-8.925004819500e+001,5.140877335766e+000
    3029,-3.908502110590e+000,-8.925004819500e+001,5.723450219794e+000
    3030,-3.908502110590e+000,-8.925004819500e+001,6.306023103822e+000
    3031,-3.908502110590e+000,-8.925004819500e+001,6.911002637236e+000
    3032,-3.908502110590e+000,-8.925004819500e+001,7.515982170649e+000
    3033,-3.908502110590e+000,-8.925004819500e+001,8.098555054677e+000
    3034,-3.908502110590e+000,-8.925004819500e+001,8.681127938705e+000
    3035,-3.908502110590e+000,-8.925004819500e+001,9.263700822734e+000
    3036,-3.908502110590e+000,-8.925004819500e+001,9.846273706762e+000
    3037,-3.908502110590e+000,-8.925004819500e+001,1.045125324018e+001
    3038,-3.908502110590e+000,-8.925004819500e+001,1.105623277359e+001
    3039,-3.908502110590e+000,-8.925004819500e+001,1.163880565762e+001
    3040,-3.908502110590e+000,-8.925004819500e+001,1.222137854165e+001
    3041,-3.908502110590e+000,-8.925004819500e+001,1.280395142567e+001
    3042,-3.908502110590e+000,-8.925004819500e+001,1.338652430970e+001
    3043,-3.908502110590e+000,-8.925004819500e+001,1.399150384312e+001
    3044,-3.908502110590e+000,-8.925004819500e+001,1.459648337653e+001
    3045,-3.908502110590e+000,-8.925004819500e+001,1.517905626056e+001
    3046,-3.908502110590e+000,-8.925004819500e+001,1.576162914458e+001
    3047,-3.908502110590e+000,-8.925004819500e+001,1.634420202861e+001
    3048,-3.908502110590e+000,-8.925004819500e+001,1.692677491264e+001
    3049,-3.908502110590e+000,-8.925004819500e+001,1.753175444605e+001
    3050,-3.908502110590e+000,-8.925004819500e+001,1.813673397947e+001
    3051,-3.908502110590e+000,-8.925004819500e+001,1.871930686350e+001
    3052,-3.908502110590e+000,-8.925004819500e+001,1.930187974752e+001
    3053,-3.908502110590e+000,-8.925004819500e+001,1.988445263155e+001
    3054,-3.908502110590e+000,-8.925004819500e+001,2.046702551558e+001
    3055,-3.908502110590e+000,-8.925004819500e+001,2.107200504899e+001
    3056,-3.908502110590e+000,-8.925004819500e+001,2.167698458241e+001
    3057,-3.908502110590e+000,-8.925004819500e+001,2.225955746644e+001
    3058,-3.908502110590e+000,-8.925004819500e+001,2.284213035046e+001
    3059,-3.908502110590e+000,-8.925004819500e+001,2.342470323449e+001
    3060,-3.908502110590e+000,-8.925004819500e+001,2.400727611852e+001
    3061,-3.908502110590e+000,-8.925004819500e+001,2.461225565193e+001
    3062,-3.908502110590e+000,-8.925004819500e+001,2.521723518535e+001
    3063,-3.908502110590e+000,-8.925004819500e+001,2.579980806938e+001
    3064,-3.908502110590e+000,-8.925004819500e+001,2.638238095340e+001
    3065,-3.908502110590e+000,-8.925004819500e+001,2.696495383743e+001
    3066,-3.908502110590e+000,-8.925004819500e+001,2.754752672146e+001
    3067,-3.908502110590e+000,-8.925004819500e+001,2.815250625487e+001
    3068,-3.908502110590e+000,-8.925004819500e+001,2.875748578829e+001
    3069,-3.908502110590e+000,-8.925004819500e+001,2.934005867232e+001
    3070,-3.908502110590e+000,-8.925004819500e+001,2.992263155634e+001
    3071,-3.908502110590e+000,-8.925004819500e+001,3.050520444037e+001
    3072,-3.908502110590e+000,-8.925004819500e+001,3.108777732440e+001
    3073,-3.908502110590e+000,-8.925004819500e+001,3.169275685781e+001
    3074,-3.908502110590e+000,-8.925004819500e+001,3.229773639123e+001
    3075,-3.908502110590e+000,-8.925004819500e+001,3.288030927526e+001
    3076,-3.908502110590e+000,-8.925004819500e+001,3.346288215928e+001
    3077,-3.908502110590e+000,-8.925004819500e+001,3.404545504331e+001
    3078,-3.908502110590e+000,-8.925004819500e+001,3.462802792734e+001
    3079,-3.908502110590e+000,-8.925004819500e+001,3.523300746075e+001
    3080,-3.908502110590e+000,-8.925004819500e+001,3.583798699417e+001
    3081,-3.908502110590e+000,-8.925004819500e+001,3.642055987819e+001
    3082,-3.908502110590e+000,-8.925004819500e+001,3.700313276222e+001
    3083,-3.908502110590e+000,-8.925004819500e+001,3.758570564625e+001
    3084,-3.908502110590e+000,-8.925004819500e+001,3.816827853028e+001
    3085,-3.908502110590e+000,-8.925004819500e+001,3.877325806369e+001
    3086,-3.908502110590e+000,-8.925004819500e+001,3.937823759711e+001
    3087,-3.908502110590e+000,-8.925004819500e+001,3.996081048113e+001
    3088,-3.908502110590e+000,-8.925004819500e+001,4.054338336516e+001
    3089,-3.908502110590e+000,-8.925004819500e+001,4.112595624919e+001
    3090,-3.908502110590e+000,-8.925004819500e+001,4.170852913322e+001
    3091,-3.908502110590e+000,-8.925004819500e+001,4.231350866663e+001
    3092,-3.908502110590e+000,-8.925004819500e+001,4.291848820005e+001
    3093,-3.908502110590e+000,-8.925004819500e+001,4.350106108407e+001
    3094,-3.908502110590e+000,-8.925004819500e+001,4.408363396810e+001
    3095,-3.908502110590e+000,-8.925004819500e+001,4.466620685213e+001
    3096,-3.908502110590e+000,-8.925004819500e+001,4.527118638554e+001
    3097,-3.908502110590e+000,-8.925004819500e+001,4.585375926957e+001
    3098,-3.908502110590e+000,-8.925004819500e+001,4.630189225729e+001
    3099,-3.908502110590e+000,-8.925004819500e+001,4.661558534869e+001
    3100,-3.908502110590e+000,-8.937504826250e+001,1.936726473612e+000
    3101,-2.238078708562e+000,-8.925004819500e+001,1.936726473612e+000
    3102,-2.836277531589e+000,-8.925004819500e+001,1.936726473612e+000
    3103,-3.359578314171e+000,-8.925004819500e+001,1.936726473612e+000
    3104,-3.746880023314e+000,-8.925004819500e+001,1.936726473612e+000
    3105,-2.062501113750e+000,-9.337255042115e+001,4.675002524500e+001
    3106,-2.062501113750e+000,-9.322855034339e+001,4.675002524500e+001
    3107,-2.062501113750e+000,-9.307342525962e+001,4.675002524500e+001
    3108,-2.062501113750e+000,-9.289742516458e+001,4.675002524500e+001
    3109,-2.062501113750e+000,-9.269555005557e+001,4.675002524500e+001
    3110,-2.062501113750e+000,-9.244554992057e+001,4.675002524500e+001
    3111,-2.062501113750e+000,-9.218417477943e+001,4.675002524500e+001
    3112,-2.062501113750e+000,-9.189417462283e+001,4.675002524500e+001
    3113,-2.062501113750e+000,-9.162217447595e+001,4.675002524500e+001
    3114,-2.062501113750e+000,-9.134017432367e+001,4.675002524500e+001
    3115,-2.062501113750e+000,-9.106392417449e+001,4.675002524500e+001
    3116,-2.062501113750e+000,-9.077992402113e+001,4.675002524500e+001
    3117,-2.062501113750e+000,-9.050154887081e+001,4.675002524500e+001
    3118,-2.062501113750e+000,-9.020954871313e+001,4.675002524500e+001
    3119,-2.062501113750e+000,-8.993329856396e+001,4.675002524500e+001
    3120,-2.062501113750e+000,-8.965129841168e+001,4.675002524500e+001
    3121,-3.749836524911e+000,-8.937504826250e+001,4.675002524500e+001
    3122,-3.524385403167e+000,-8.937504826250e+001,4.675002524500e+001
    3123,-3.303633283961e+000,-8.937504826250e+001,4.675002524500e+001
    3124,-2.995574117609e+000,-8.937504826250e+001,4.675002524500e+001
    3125,-2.704851460619e+000,-8.937504826250e+001,4.675002524500e+001
    3126,-2.062501113750e+000,-8.937504826250e+001,4.675002524500e+001
    3127,-2.377861284044e+000,-8.937504826250e+001,4.675002524500e+001
    3128,-1.937501046250e+000,-9.202918639041e+001,9.542819771692e+000
    3129,-1.937501046250e+000,-9.184370916830e+001,9.542819771692e+000
    3130,-1.937501046250e+000,-9.307364158452e+001,9.554174083077e+000
    3131,-1.937501046250e+000,-9.280836602266e+001,9.554174083077e+000
    3132,-1.937501046250e+000,-9.418796293966e+001,9.494787809812e+000
    3133,-1.937501046250e+000,-9.390974710649e+001,9.494787809812e+000
    3134,-1.937501046250e+000,-9.528287895723e+001,9.536304804608e+000
    3135,-1.937501046250e+000,-9.502838695480e+001,9.536304804608e+000
    3136,-1.937501046250e+000,-9.601064812825e+001,9.583108056602e+000
    3137,-1.937501046250e+000,-9.587261856761e+001,9.583108056602e+000
    3138,-1.937501046250e+000,-9.634510087857e+001,9.627475913457e+000
    3139,-1.937501046250e+000,-9.620428120441e+001,9.600031420513e+000
    3140,-1.937501046250e+000,-9.669204548038e+001,9.813830540126e+000
    3141,-1.937501046250e+000,-9.655114213145e+001,9.713776931847e+000
    3142,-1.937501046250e+000,-9.691297085110e+001,1.015804832703e+001
    3143,-1.937501046250e+000,-9.683205900098e+001,1.000605067911e+001
    3144,-1.937501046250e+000,-9.696215599070e+001,1.051040281417e+001
    3145,-1.937501046250e+000,-9.695308020043e+001,1.036533693902e+001
    3146,-1.937501046250e+000,-9.691787133377e+001,1.080591243181e+001
    3147,-1.937501046250e+000,-9.693650467717e+001,1.066616235635e+001
    3148,-1.937501046250e+000,-9.685379936915e+001,1.160277603952e+001
    3149,-1.937501046250e+000,-9.688673272027e+001,1.135577590614e+001
    3150,-1.937501046250e+000,-9.695448568661e+001,1.265096586334e+001
    3151,-1.937501046250e+000,-9.699261904054e+001,1.236496570890e+001
    3152,-1.937501046250e+000,-9.677285126206e+001,1.388085616554e+001
    3153,-1.937501046250e+000,-9.680925128171e+001,1.360785601812e+001
    3154,-1.937501046250e+000,-9.648239577736e+001,1.498173390030e+001
    3155,-1.937501046250e+000,-9.651966246415e+001,1.470223374937e+001
    3156,-1.937501046250e+000,-9.634573238755e+001,1.611906744314e+001
    3157,-1.937501046250e+000,-9.638689907644e+001,1.581031727642e+001
    3158,-1.937501046250e+000,-9.608428109951e+001,1.705993595154e+001
    3159,-1.937501046250e+000,-9.610724777858e+001,1.688768585853e+001
    3160,-1.937501046250e+000,-9.599878369922e+001,1.737673149752e+001
    3161,-1.937501046250e+000,-9.605100951984e+001,1.722993969918e+001
    3162,-1.937501046250e+000,-9.574402033004e+001,1.771240519551e+001
    3163,-1.937501046250e+000,-9.589453268139e+001,1.757398468761e+001
    3164,-1.937501046250e+000,-9.534627132901e+001,1.787283890015e+001
    3165,-1.937501046250e+000,-9.551524382052e+001,1.783261242569e+001
    3166,-1.937501046250e+000,-9.502381014947e+001,1.790497763990e+001
    3167,-1.937501046250e+000,-9.515651027993e+001,1.790497763990e+001
    3168,-1.937501046250e+000,-9.425669179719e+001,1.794498107376e+001
    3169,-1.937501046250e+000,-9.447383746522e+001,1.794498107376e+001
    3170,-1.937501046250e+000,-9.326464676841e+001,1.798180976751e+001
    3171,-1.937501046250e+000,-9.354555743420e+001,1.798180976751e+001
    3172,-1.937501046250e+000,-9.219308184389e+001,1.801519677298e+001
    3173,-1.937501046250e+000,-9.246020548313e+001,1.801519677298e+001
    3174,-1.937501046250e+000,-9.151604200305e+001,1.786968829027e+001
    3175,-1.937501046250e+000,-9.164195971706e+001,1.789146068927e+001
    3176,-1.937501046250e+000,-9.121083048867e+001,1.772612393128e+001
    3177,-1.937501046250e+000,-9.134118836327e+001,1.780558545756e+001
    3178,-1.937501046250e+000,-9.096307877839e+001,1.743301450138e+001
    3179,-1.937501046250e+000,-9.105862513072e+001,1.757698681212e+001
    3180,-1.937501046250e+000,-9.086119785395e+001,1.711483567146e+001
    3181,-1.937501046250e+000,-9.088437611550e+001,1.724462963795e+001
    3182,-1.937501046250e+000,-9.085125766590e+001,1.680713562280e+001
    3183,-1.937501046250e+000,-9.085125766590e+001,1.695663570353e+001
    3184,-1.937501046250e+000,-9.078198480201e+001,1.582305929052e+001
    3185,-1.937501046250e+000,-9.078198480201e+001,1.608630943267e+001
    3186,-1.937501046250e+000,-9.072621056538e+001,1.472792313614e+001
    3187,-1.937501046250e+000,-9.072621056538e+001,1.499442328005e+001
    3188,-1.937501046250e+000,-9.078145900412e+001,1.365916398021e+001
    3189,-1.937501046250e+000,-9.078145900412e+001,1.392241412237e+001
    3190,-1.937501046250e+000,-9.073292439684e+001,1.256118813185e+001
    3191,-1.937501046250e+000,-9.073292439684e+001,1.282768827576e+001
    3192,-1.937501046250e+000,-9.059859304277e+001,1.146695693699e+001
    3193,-1.937501046250e+000,-9.059859304277e+001,1.174320708617e+001
    3194,-1.937501046250e+000,-9.085772495462e+001,1.054789652522e+001
    3195,-1.937501046250e+000,-9.085772495462e+001,1.069739660595e+001
    3196,-1.937501046250e+000,-9.088758339504e+001,1.025753470442e+001
    3197,-1.937501046250e+000,-9.086440513350e+001,1.038732867092e+001
    3198,-1.937501046250e+000,-9.105537924223e+001,9.936253690167e+000
    3199,-1.937501046250e+000,-9.096069168594e+001,1.007941953774e+001
    3200,-1.937501046250e+000,-9.133263843623e+001,9.712426806089e+000
    3201,-1.937501046250e+000,-9.120031144815e+001,9.793088633936e+000
    3202,-1.937501046250e+000,-9.162676226557e+001,9.603781938736e+000
    3203,-1.937501046250e+000,-9.150195486898e+001,9.625160499321e+000
    3204,-1.937501046250e+000,-9.133415855339e+001,9.544824919241e+000
    3205,-1.937501046250e+000,-9.172042188887e+001,9.396596445428e+000
    3206,-1.937501046250e+000,-9.558085557492e+001,2.084450112294e+001
    3207,-1.937501046250e+000,-9.560358892053e+001,2.067400103087e+001
    3208,-1.937501046250e+000,-9.571715981034e+001,2.191223694787e+001
    3209,-1.937501046250e+000,-9.575492649740e+001,2.162898679491e+001
    3210,-1.937501046250e+000,-9.550898221365e+001,2.309126831877e+001
    3211,-1.937501046250e+000,-9.554821556817e+001,2.279701815988e+001
    3212,-1.937501046250e+000,-9.530992325099e+001,2.430880623936e+001
    3213,-1.937501046250e+000,-9.534658993746e+001,2.403380609086e+001
    3214,-1.937501046250e+000,-9.527288989766e+001,2.458655638934e+001
    3215,-1.937501046250e+000,-9.525085049943e+001,2.529237308792e+001
    3216,-1.937501046250e+000,-9.528935052022e+001,2.500362293199e+001
    3217,-1.937501046250e+000,-9.489608046410e+001,2.608402842904e+001
    3218,-1.937501046250e+000,-9.491478047420e+001,2.594377835330e+001
    3219,-1.937501046250e+000,-9.477358870370e+001,2.642105432727e+001
    3220,-1.937501046250e+000,-9.483458136098e+001,2.626066462977e+001
    3221,-1.937501046250e+000,-9.450915101245e+001,2.676084184651e+001
    3222,-1.937501046250e+000,-9.466353038727e+001,2.662993612752e+001
    3223,-1.937501046250e+000,-9.412613991840e+001,2.686502307624e+001
    3224,-1.937501046250e+000,-9.428247854979e+001,2.683087971204e+001
    3225,-1.937501046250e+000,-9.380078161151e+001,2.688404081377e+001
    3226,-1.937501046250e+000,-9.395356101865e+001,2.688404081377e+001
    3227,-1.937501046250e+000,-9.288624237409e+001,2.697941110821e+001
    3228,-1.937501046250e+000,-9.316146998254e+001,2.697941110821e+001
    3229,-1.937501046250e+000,-9.152523004151e+001,2.686254660125e+001
    3230,-1.937501046250e+000,-9.165281089807e+001,2.688491629328e+001
    3231,-1.937501046250e+000,-9.120485798971e+001,2.670874338633e+001
    3232,-1.937501046250e+000,-9.133654738650e+001,2.679044200942e+001
    3233,-1.937501046250e+000,-9.095254958697e+001,2.643820980299e+001
    3234,-1.937501046250e+000,-9.104709658617e+001,2.658488991509e+001
    3235,-1.937501046250e+000,-9.087121139810e+001,2.611368644345e+001
    3236,-1.937501046250e+000,-9.089239434803e+001,2.623793821872e+001
    3237,-1.937501046250e+000,-9.084035538917e+001,2.579972126090e+001
    3238,-1.937501046250e+000,-9.084035538917e+001,2.594547133961e+001
    3239,-1.937501046250e+000,-9.073949005174e+001,2.493831192350e+001
    3240,-1.937501046250e+000,-9.073949005174e+001,2.518856205864e+001
    3241,-1.937501046250e+000,-9.078025595808e+001,2.387193014642e+001
    3242,-1.937501046250e+000,-9.078025595808e+001,2.414143029195e+001
    3243,-1.937501046250e+000,-9.072611924208e+001,2.282003823745e+001
    3244,-1.937501046250e+000,-9.072611924208e+001,2.308403838001e+001
    3245,-1.937501046250e+000,-9.079237315016e+001,2.176445400716e+001
    3246,-1.937501046250e+000,-9.079237315016e+001,2.202295414675e+001
    3247,-1.937501046250e+000,-9.080671392653e+001,2.087040881762e+001
    3248,-1.937501046250e+000,-9.080671392653e+001,2.105740891860e+001
    3249,-1.937501046250e+000,-9.089515625063e+001,2.025869822432e+001
    3250,-1.937501046250e+000,-9.087377769005e+001,2.038350562091e+001
    3251,-1.937501046250e+000,-9.106868687611e+001,1.991921557114e+001
    3252,-1.937501046250e+000,-9.097219961886e+001,2.006736798862e+001
    3253,-1.937501046250e+000,-9.134684794337e+001,1.971100169592e+001
    3254,-1.937501046250e+000,-9.121563127272e+001,1.979126968536e+001
    3255,-1.937501046250e+000,-9.164984232165e+001,1.960685210306e+001
    3256,-1.937501046250e+000,-9.152392460763e+001,1.962862450205e+001
    3257,-1.937501046250e+000,-9.254356636022e+001,1.954035497015e+001
    3258,-1.937501046250e+000,-9.225151756798e+001,1.954035497015e+001
    3259,-1.937501046250e+000,-9.372241210288e+001,1.951186774183e+001
    3260,-1.937501046250e+000,-9.343185335550e+001,1.951186774183e+001
    3261,-1.937501046250e+000,-9.466327223324e+001,1.959424398698e+001
    3262,-1.937501046250e+000,-9.449489716425e+001,1.959424398698e+001
    3263,-1.937501046250e+000,-9.498656819711e+001,1.964921651121e+001
    3264,-1.937501046250e+000,-9.484752637861e+001,1.962248707203e+001
    3265,-1.937501046250e+000,-9.533579511677e+001,1.982047608968e+001
    3266,-1.937501046250e+000,-9.519185284939e+001,1.971826458552e+001
    3267,-1.937501046250e+000,-9.558125815277e+001,2.015449088110e+001
    3268,-1.937501046250e+000,-9.550018593813e+001,1.999836583084e+001
    3269,-1.937501046250e+000,-9.561369333732e+001,2.050892865954e+001
    3270,-1.937501046250e+000,-9.560603897435e+001,2.036943302884e+001
    3271,-1.937501046250e+000,-9.437069229922e+001,2.980742980345e+001
    3272,-1.937501046250e+000,-9.438932564262e+001,2.966767972799e+001
    3273,-1.937501046250e+000,-9.450546901625e+001,3.079447533314e+001
    3274,-1.937501046250e+000,-9.454533570445e+001,3.049547517168e+001
    3275,-1.937501046250e+000,-9.431396342262e+001,3.177508078096e+001
    3276,-1.937501046250e+000,-9.435123010941e+001,3.149558063003e+001
    3277,-1.937501046250e+000,-9.413394875739e+001,3.316415964258e+001
    3278,-1.937501046250e+000,-9.417034877704e+001,3.289115949516e+001
    3279,-1.937501046250e+000,-9.404126647890e+001,3.417492859126e+001
    3280,-1.937501046250e+000,-9.408026649996e+001,3.388242843331e+001
    3281,-1.937501046250e+000,-9.386852649915e+001,3.516968534104e+001
    3282,-1.937501046250e+000,-9.390665985307e+001,3.488368518660e+001
    3283,-1.937501046250e+000,-9.356728196038e+001,3.604611115139e+001
    3284,-1.937501046250e+000,-9.358678197091e+001,3.589986107242e+001
    3285,-1.937501046250e+000,-9.348278102727e+001,3.631958105422e+001
    3286,-1.937501046250e+000,-9.351618848086e+001,3.620735221038e+001
    3287,-1.937501046250e+000,-9.330963089026e+001,3.662559360613e+001
    3288,-1.937501046250e+000,-9.340664301403e+001,3.650032331433e+001
    3289,-1.937501046250e+000,-9.303260671885e+001,3.680731218383e+001
    3290,-1.937501046250e+000,-9.315823819033e+001,3.673765435736e+001
    3291,-1.937501046250e+000,-9.275793312613e+001,3.688968801668e+001
    3292,-1.937501046250e+000,-9.287359274076e+001,3.687140619809e+001
    3293,-1.937501046250e+000,-9.150871031192e+001,3.687289263567e+001
    3294,-1.937501046250e+000,-9.163407302188e+001,3.689446767944e+001
    3295,-1.937501046250e+000,-9.119263926953e+001,3.670643592644e+001
    3296,-1.937501046250e+000,-9.132612091442e+001,3.678852227145e+001
    3297,-1.937501046250e+000,-9.095066814634e+001,3.640876783097e+001
    3298,-1.937501046250e+000,-9.104425346344e+001,3.655197203504e+001
    3299,-1.937501046250e+000,-9.087401135876e+001,3.610311496247e+001
    3300,-1.937501046250e+000,-9.089658188929e+001,3.623124957212e+001
    3301,-1.937501046250e+000,-9.086672342241e+001,3.579075377706e+001
    3302,-1.937501046250e+000,-9.086672342241e+001,3.594675386130e+001
    3303,-1.937501046250e+000,-9.073629539232e+001,3.476303676093e+001
    3304,-1.937501046250e+000,-9.073629539232e+001,3.504253691186e+001
    3305,-1.937501046250e+000,-9.073503390393e+001,3.369920659993e+001
    3306,-1.937501046250e+000,-9.073503390393e+001,3.396895674559e+001
    3307,-1.937501046250e+000,-9.073551523171e+001,3.260110064453e+001
    3308,-1.937501046250e+000,-9.073551523171e+001,3.286110078493e+001
    3309,-1.937501046250e+000,-9.073677349720e+001,3.153932539287e+001
    3310,-1.937501046250e+000,-9.073677349720e+001,3.180257553502e+001
    3311,-1.937501046250e+000,-9.078439544427e+001,3.045026951405e+001
    3312,-1.937501046250e+000,-9.078439544427e+001,3.072326966147e+001
    3313,-1.937501046250e+000,-9.085109166885e+001,2.954524136775e+001
    3314,-1.937501046250e+000,-9.085109166885e+001,2.968499144322e+001
    3315,-1.937501046250e+000,-9.088414160449e+001,2.925215355297e+001
    3316,-1.937501046250e+000,-9.086034779917e+001,2.938360399402e+001
    3317,-1.937501046250e+000,-9.106825121275e+001,2.893510486470e+001
    3318,-1.937501046250e+000,-9.097202747028e+001,2.907862532696e+001
    3319,-1.937501046250e+000,-9.134743224013e+001,2.871991747215e+001
    3320,-1.937501046250e+000,-9.121781229539e+001,2.879837172756e+001
    3321,-1.937501046250e+000,-9.162775290523e+001,2.861168377430e+001
    3322,-1.937501046250e+000,-9.150239019526e+001,2.863325881807e+001
    3323,-1.937501046250e+000,-9.249631617828e+001,2.855761405664e+001
    3324,-1.937501046250e+000,-9.223642317425e+001,2.855761405664e+001
    3325,-1.937501046250e+000,-9.343731795910e+001,2.855534313442e+001
    3326,-1.937501046250e+000,-9.326108914130e+001,2.855534313442e+001
    3327,-1.937501046250e+000,-9.411867518206e+001,2.879405308873e+001
    3328,-1.937501046250e+000,-9.398424895196e+001,2.870777217954e+001
    3329,-1.937501046250e+000,-9.437900448899e+001,2.913635320760e+001
    3330,-1.937501046250e+000,-9.428514121963e+001,2.897955913115e+001
    3331,-1.937501046250e+000,-9.441607133782e+001,2.950152677403e+001
    3332,-1.937501046250e+000,-9.440334807899e+001,2.934355319805e+001
    3333,-1.937501046250e+000,-9.953360386765e+001,2.228335064867e+000
    3334,-1.937501046250e+000,-9.942203751860e+001,2.587709701286e+000
    3335,-1.937501046250e+000,-9.936521122902e+001,3.013906873121e+000
    3336,-1.937501046250e+000,-9.917992783135e+001,2.296101110030e+000
    3337,-1.937501046250e+000,-9.927861600702e+001,3.490279332981e+000
    3338,-1.937501046250e+000,-9.921281714541e+001,3.983770795106e+000
    3339,-1.937501046250e+000,-9.908170727324e+001,4.498761333156e+000
    3340,-1.937501046250e+000,-9.901889926897e+001,4.969821365185e+000
    3341,-1.937501046250e+000,-9.876406116613e+001,4.123211204219e+000
    3342,-1.937501046250e+000,-9.891423398068e+001,5.483044675477e+000
    3343,-1.937501046250e+000,-9.884245340437e+001,6.021398997795e+000
    3344,-1.937501046250e+000,-9.852828600567e+001,5.151425052561e+000
    3345,-1.937501046250e+000,-9.878694409350e+001,6.564414698045e+000
    3346,-1.937501046250e+000,-9.872712694658e+001,7.013043299976e+000
    3347,-1.937501046250e+000,-9.836811140651e+001,6.207664063103e+000
    3348,-1.937501046250e+000,-9.866597887356e+001,7.516866289873e+000
    3349,-1.937501046250e+000,-9.860018001195e+001,8.010357751998e+000
    3350,-1.937501046250e+000,-9.825145402264e+001,7.254502753249e+000
    3351,-1.937501046250e+000,-9.858515450386e+001,8.530887754504e+000
    3352,-1.937501046250e+000,-9.851038307020e+001,9.091673506919e+000
    3353,-1.937501046250e+000,-9.817528044153e+001,8.278855745652e+000
    3354,-1.937501046250e+000,-9.838101087208e+001,1.047104231634e+001
    3355,-1.937501046250e+000,-9.832717543985e+001,1.087480805808e+001
    3356,-1.937501046250e+000,-9.818468241825e+001,1.128061366722e+001
    3357,-1.937501046250e+000,-9.812785612867e+001,1.170681083906e+001
    3358,-1.937501046250e+000,-9.788463352414e+001,1.102180891208e+001
    3359,-1.937501046250e+000,-9.795775765732e+001,1.221990457775e+001
    3360,-1.937501046250e+000,-9.788896793836e+001,1.273582746997e+001
    3361,-1.937501046250e+000,-9.778100022025e+001,1.341321747383e+001
    3362,-1.937501046250e+000,-9.771520135863e+001,1.390670893595e+001
    3363,-1.937501046250e+000,-9.770323764461e+001,1.518018862524e+001
    3364,-1.937501046250e+000,-9.764342049768e+001,1.562881722718e+001
    3365,-1.937501046250e+000,-9.747149141127e+001,1.705212820822e+001
    3366,-1.937501046250e+000,-9.740868340700e+001,1.752318824025e+001
    3367,-1.937501046250e+000,-9.733417382932e+001,1.804465322934e+001
    3368,-1.937501046250e+000,-9.726837496771e+001,1.853814469147e+001
    3369,-1.937501046250e+000,-9.700690839153e+001,1.774966248759e+001
    3370,-1.937501046250e+000,-9.718454788896e+001,1.904410131626e+001
    3371,-1.937501046250e+000,-9.711575816999e+001,1.956002420848e+001
    3372,-1.937501046250e+000,-9.708692425333e+001,2.006536608869e+001
    3373,-1.937501046250e+000,-9.702710710641e+001,2.051399469063e+001
    3374,-1.937501046250e+000,-9.673591073970e+001,1.978838260648e+001
    3375,-1.937501046250e+000,-9.696920418882e+001,2.090163178959e+001
    3376,-1.937501046250e+000,-9.690041446986e+001,2.141755468181e+001
    3377,-1.937501046250e+000,-9.664917390545e+001,2.068136158566e+001
    3378,-1.937501046250e+000,-9.668049187675e+001,2.178072494447e+001
    3379,-1.937501046250e+000,-9.661768387248e+001,2.225178497650e+001
    3380,-1.937501046250e+000,-9.648577298365e+001,2.285881603852e+001
    3381,-1.937501046250e+000,-9.641698326468e+001,2.337473893074e+001
    3382,-1.937501046250e+000,-9.629235767556e+001,2.403402654987e+001
    3383,-1.937501046250e+000,-9.623254052863e+001,2.448265515181e+001
    3384,-1.937501046250e+000,-9.624900115119e+001,2.489972169446e+001
    3385,-1.937501046250e+000,-9.618021143223e+001,2.541564458668e+001
    3386,-1.937501046250e+000,-9.617216036457e+001,2.688762130113e+001
    3387,-1.937501046250e+000,-9.610935236030e+001,2.735868133316e+001
    3388,-1.937501046250e+000,-9.599411001857e+001,2.781469010784e+001
    3389,-1.937501046250e+000,-9.592532029961e+001,2.833061300007e+001
    3390,-1.937501046250e+000,-9.567152733703e+001,2.757508893689e+001
    3391,-1.937501046250e+000,-9.592356613027e+001,2.880752125338e+001
    3392,-1.937501046250e+000,-9.586374898335e+001,2.925614985531e+001
    3393,-1.937501046250e+000,-9.555453082596e+001,2.850800596489e+001
    3394,-1.937501046250e+000,-9.575283311677e+001,2.968320564828e+001
    3395,-1.937501046250e+000,-9.568404339781e+001,3.019912854051e+001
    3396,-1.937501046250e+000,-9.544186079006e+001,2.941197001117e+001
    3397,-1.937501046250e+000,-9.547306002833e+001,3.063102123728e+001
    3398,-1.937501046250e+000,-9.540726116672e+001,3.112451269941e+001
    3399,-1.937501046250e+000,-9.528985561309e+001,3.154936784712e+001
    3400,-1.937501046250e+000,-9.522405675148e+001,3.204285930925e+001
    3401,-1.937501046250e+000,-9.511987546053e+001,3.286318786375e+001
    3402,-1.937501046250e+000,-9.505108574157e+001,3.337911075597e+001
    3403,-1.937501046250e+000,-9.503510350450e+001,3.381462939402e+001
    3404,-1.937501046250e+000,-9.497229550023e+001,3.428568942604e+001
    3405,-1.937501046250e+000,-9.487452222762e+001,3.471819587221e+001
    3406,-1.937501046250e+000,-9.480573250866e+001,3.523411876443e+001
    3407,-1.937501046250e+000,-9.462829757977e+001,3.761236974832e+001
    3408,-1.937501046250e+000,-9.456848043285e+001,3.806099835025e+001
    3409,-1.937501046250e+000,-9.455227711558e+001,3.852435072480e+001
    3410,-1.937501046250e+000,-9.448647825396e+001,3.901784218692e+001
    3411,-1.937501046250e+000,-9.411247060338e+001,3.830970584496e+001
    3412,-1.937501046250e+000,-9.446154608629e+001,3.946896803787e+001
    3413,-1.937501046250e+000,-9.439574722467e+001,3.996245950000e+001
    3414,-1.937501046250e+000,-9.407133511844e+001,3.922418407045e+001
    3415,-1.937501046250e+000,-9.431892593645e+001,4.046643118665e+001
    3416,-1.937501046250e+000,-9.425013621749e+001,4.098235407887e+001
    3417,-1.937501046250e+000,-9.396958166255e+001,4.017928160805e+001
    3418,-1.937501046250e+000,-9.415323598660e+001,4.147277664593e+001
    3419,-1.937501046250e+000,-9.409042798233e+001,4.194383667796e+001
    3420,-1.937501046250e+000,-9.379586014343e+001,4.117367586177e+001
    3421,-1.937501046250e+000,-9.402454640978e+001,4.245686505219e+001
    3422,-1.937501046250e+000,-9.395874754816e+001,4.295035651432e+001
    3423,-1.937501046250e+000,-9.363307834000e+001,4.217712680306e+001
    3424,-1.937501046250e+000,-9.392038679083e+001,4.344334831639e+001
    3425,-1.937501046250e+000,-9.384561535717e+001,4.400413406880e+001
    3426,-1.937501046250e+000,-9.352883601012e+001,4.318314697936e+001
    3427,-1.937501046250e+000,-9.382444280413e+001,4.448268908312e+001
    3428,-1.937501046250e+000,-9.376761651455e+001,4.490888625495e+001
    3429,-1.937501046250e+000,-9.346930269974e+001,4.415469379575e+001
    3430,-1.937501046250e+000,-9.376877337986e+001,4.592202285080e+001
    3431,-1.937501046250e+000,-9.372989223436e+001,4.621363144205e+001
    3432,-1.937501046250e+000,-8.952573731392e+001,2.205606266240e+000
    3433,-1.937501046250e+000,-8.989762283447e+001,2.179955725102e+000
    3434,-1.937501046250e+000,-9.018391538105e+001,2.179955725102e+000
    3435,-1.937501046250e+000,-9.046321752367e+001,2.198674164186e+000
    3436,-1.937501046250e+000,-9.073890664260e+001,2.198674164186e+000
    3437,-1.937501046250e+000,-9.027312137873e+001,2.441903415676e+000
    3438,-1.937501046250e+000,-9.105571627509e+001,2.200315298345e+000
    3439,-1.937501046250e+000,-9.133670710783e+001,2.200315298345e+000
    3440,-1.937501046250e+000,-9.086923315384e+001,2.462262988919e+000
    3441,-1.937501046250e+000,-9.162063406734e+001,2.198759810680e+000
    3442,-1.937501046250e+000,-9.189632318626e+001,2.198759810680e+000
    3443,-1.937501046250e+000,-9.146996974583e+001,2.462348635413e+000
    3444,-1.937501046250e+000,-9.216737058776e+001,2.196573300154e+000
    3445,-1.937501046250e+000,-9.244836142050e+001,2.196573300154e+000
    3446,-1.937501046250e+000,-9.202494410683e+001,2.458606637222e+000
    3447,-1.937501046250e+000,-9.271648173889e+001,2.198287592732e+000
    3448,-1.937501046250e+000,-9.299217085781e+001,2.198287592732e+000
    3449,-1.937501046250e+000,-9.256411182670e+001,2.458134419274e+000
    3450,-1.937501046250e+000,-9.331056026986e+001,2.199436489075e+000
    3451,-1.937501046250e+000,-9.359685281643e+001,2.199436489075e+000
    3452,-1.937501046250e+000,-9.315062155714e+001,2.460997608195e+000
    3453,-1.937501046250e+000,-9.387004933977e+001,2.188636737858e+000
    3454,-1.937501046250e+000,-9.414573845869e+001,2.188636737858e+000
    3455,-1.937501046250e+000,-9.374220749252e+001,2.451346753322e+000
    3456,-1.937501046250e+000,-9.441446652250e+001,2.185412552254e+000
    3457,-1.937501046250e+000,-9.469545735525e+001,2.185412552254e+000
    3458,-1.937501046250e+000,-9.428413207966e+001,2.437322816501e+000
    3459,-1.937501046250e+000,-9.495861123747e+001,2.192571172834e+000
    3460,-1.937501046250e+000,-9.522899864257e+001,2.192571172834e+000
    3461,-1.937501046250e+000,-9.481601402569e+001,2.441257251477e+000
    3462,-1.937501046250e+000,-9.553500994565e+001,2.198898174595e+000
    3463,-1.937501046250e+000,-9.583190591987e+001,2.198898174595e+000
    3464,-1.937501046250e+000,-9.538517921100e+001,2.454742873818e+000
    3465,-1.937501046250e+000,-9.611394885538e+001,2.203605200319e+000
    3466,-1.937501046250e+000,-9.638963797430e+001,2.203605200319e+000
    3467,-1.937501046250e+000,-9.597323344958e+001,2.465776901302e+000
    3468,-1.937501046250e+000,-9.667438678322e+001,2.213975483379e+000
    3469,-1.937501046250e+000,-9.694477418831e+001,2.213975483379e+000
    3470,-1.937501046250e+000,-9.654002519400e+001,2.480854210086e+000
    3471,-1.937501046250e+000,-9.722275828424e+001,2.206180350994e+000
    3472,-1.937501046250e+000,-9.749844740317e+001,2.206180350994e+000
    3473,-1.937501046250e+000,-9.710275809884e+001,2.483429360762e+000
    3474,-1.937501046250e+000,-9.778624829202e+001,2.194533662781e+000
    3475,-1.937501046250e+000,-9.807784255242e+001,2.194533662781e+000
    3476,-1.937501046250e+000,-9.766854308362e+001,2.463987540164e+000
    3477,-1.937501046250e+000,-9.834845139497e+001,2.174612388828e+000
    3478,-1.937501046250e+000,-9.862414051390e+001,2.174612388828e+000
    3479,-1.937501046250e+000,-9.822695281503e+001,2.432419577997e+000
    3480,-1.937501046250e+000,-8.952629834418e+001,4.639151885483e+001
    3481,-1.937501046250e+000,-8.947073479496e+001,4.582840106587e+001
    3482,-1.937501046250e+000,-8.947073479496e+001,4.546989467570e+001
    3483,-1.937501046250e+000,-8.954003891115e+001,4.514358929352e+001
    3484,-1.937501046250e+000,-8.954003891115e+001,4.474026960458e+001
    3485,-1.937501046250e+000,-8.976072551111e+001,4.529748428491e+001
    3486,-1.937501046250e+000,-8.957612979921e+001,4.438386296908e+001
    3487,-1.937501046250e+000,-8.957612979921e+001,4.402535657891e+001
    3488,-1.937501046250e+000,-8.986612051537e+001,4.461477226723e+001
    3489,-1.937501046250e+000,-8.956547454798e+001,4.365209177375e+001
    3490,-1.937501046250e+000,-8.956547454798e+001,4.331599203296e+001
    3491,-1.937501046250e+000,-8.989155615219e+001,4.388510082657e+001
    3492,-1.937501046250e+000,-8.958341302955e+001,4.293870182135e+001
    3493,-1.937501046250e+000,-8.958341302955e+001,4.258019543118e+001
    3494,-1.937501046250e+000,-8.989883938253e+001,4.313454580979e+001
    3495,-1.937501046250e+000,-8.959579442061e+001,4.222565104773e+001
    3496,-1.937501046250e+000,-8.959579442061e+001,4.184473800817e+001
    3497,-1.937501046250e+000,-8.992915925515e+001,4.240271121473e+001
    3498,-1.937501046250e+000,-8.955893489397e+001,4.142257454710e+001
    3499,-1.937501046250e+000,-8.955893489397e+001,4.099684820877e+001
    3500,-1.937501046250e+000,-8.958085865724e+001,4.062672879218e+001
    3501,-1.937501046250e+000,-8.958085865724e+001,4.029062905140e+001
    3502,-1.937501046250e+000,-8.988974535621e+001,4.083372049255e+001
    3503,-1.937501046250e+000,-8.962460955632e+001,3.991927576103e+001
    3504,-1.937501046250e+000,-8.962460955632e+001,3.956076937086e+001
    3505,-1.937501046250e+000,-8.995542001856e+001,4.009224778559e+001
    3506,-1.937501046250e+000,-8.963518363936e+001,3.918100144243e+001
    3507,-1.937501046250e+000,-8.963518363936e+001,3.882249505226e+001
    3508,-1.937501046250e+000,-9.000974500068e+001,3.934112656679e+001
    3509,-1.937501046250e+000,-8.961663245259e+001,3.842893260122e+001
    3510,-1.937501046250e+000,-8.961663245259e+001,3.798079961350e+001
    3511,-1.937501046250e+000,-9.000176789695e+001,3.856779618732e+001
    3512,-1.937501046250e+000,-8.958221662710e+001,3.759729495214e+001
    3513,-1.937501046250e+000,-8.958221662710e+001,3.723878856197e+001
    3514,-1.937501046250e+000,-8.994880088470e+001,3.779072907492e+001
    3515,-1.937501046250e+000,-8.955486067312e+001,3.688373250711e+001
    3516,-1.937501046250e+000,-8.955486067312e+001,3.652522611694e+001
    3517,-1.937501046250e+000,-8.988702910523e+001,3.705216835871e+001
    3518,-1.937501046250e+000,-8.957516677162e+001,3.616142854855e+001
    3519,-1.937501046250e+000,-8.957516677162e+001,3.575810885961e+001
    3520,-1.937501046250e+000,-8.987997924974e+001,3.633331473546e+001
    3521,-1.937501046250e+000,-8.955995573762e+001,3.537742636818e+001
    3522,-1.937501046250e+000,-8.955995573762e+001,3.499651332863e+001
    3523,-1.937501046250e+000,-8.960144799001e+001,3.460221836822e+001
    3524,-1.937501046250e+000,-8.960144799001e+001,3.419889867927e+001
    3525,-1.937501046250e+000,-8.991135553263e+001,3.481385722380e+001
    3526,-1.937501046250e+000,-8.955872708328e+001,3.379389663766e+001
    3527,-1.937501046250e+000,-8.955872708328e+001,3.343539024749e+001
    3528,-1.937501046250e+000,-8.991012687829e+001,3.401456022178e+001
    3529,-1.937501046250e+000,-8.955950810106e+001,3.310809675549e+001
    3530,-1.937501046250e+000,-8.955950810106e+001,3.277199701470e+001
    3531,-1.937501046250e+000,-8.986818698934e+001,3.328226468817e+001
    3532,-1.937501046250e+000,-8.959857105252e+001,3.238779067928e+001
    3533,-1.937501046250e+000,-8.959857105252e+001,3.202928428911e+001
    3534,-1.937501046250e+000,-8.990803095858e+001,3.257076486074e+001
    3535,-1.937501046250e+000,-8.956652213588e+001,3.165427468245e+001
    3536,-1.937501046250e+000,-8.956652213588e+001,3.129576829228e+001
    3537,-1.937501046250e+000,-8.991504499340e+001,3.181154891866e+001
    3538,-1.937501046250e+000,-8.960869089195e+001,3.089577937093e+001
    3539,-1.937501046250e+000,-8.960869089195e+001,3.047005303261e+001
    3540,-1.937501046250e+000,-8.992516483283e+001,3.103655039066e+001
    3541,-1.937501046250e+000,-8.954659461508e+001,3.007821493630e+001
    3542,-1.937501046250e+000,-8.954659461508e+001,2.971970854613e+001
    3543,-1.937501046250e+000,-8.990523731203e+001,3.024472337301e+001
    3544,-1.937501046250e+000,-8.953303976038e+001,2.938819546163e+001
    3545,-1.937501046250e+000,-8.953303976038e+001,2.900728242207e+001
    3546,-1.937501046250e+000,-8.982958618046e+001,2.952137219220e+001
    3547,-1.937501046250e+000,-8.955651500295e+001,2.865171170927e+001
    3548,-1.937501046250e+000,-8.955651500295e+001,2.831561196848e+001
    3549,-1.937501046250e+000,-8.983950656833e+001,2.883428839489e+001
    3550,-1.937501046250e+000,-8.957344766224e+001,2.795922328519e+001
    3551,-1.937501046250e+000,-8.957344766224e+001,2.760071689502e+001
    3552,-1.937501046250e+000,-8.987991447019e+001,2.812232899880e+001
    3553,-1.937501046250e+000,-8.955497794908e+001,2.719791452405e+001
    3554,-1.937501046250e+000,-8.955497794908e+001,2.679459483510e+001
    3555,-1.937501046250e+000,-8.987837741632e+001,2.736313794453e+001
    3556,-1.937501046250e+000,-8.954668943241e+001,2.641259291850e+001
    3557,-1.937501046250e+000,-8.954668943241e+001,2.603167987894e+001
    3558,-1.937501046250e+000,-8.985161918650e+001,2.657833365696e+001
    3559,-1.937501046250e+000,-8.957797852140e+001,2.566256599394e+001
    3560,-1.937501046250e+000,-8.957797852140e+001,2.530405960376e+001
    3561,-1.937501046250e+000,-8.987461975882e+001,2.582721785535e+001
    3562,-1.937501046250e+000,-8.955750274824e+001,2.496434744319e+001
    3563,-1.937501046250e+000,-8.955750274824e+001,2.460584105302e+001
    3564,-1.937501046250e+000,-8.988543307464e+001,2.511839180977e+001
    3565,-1.937501046250e+000,-8.959110719085e+001,2.421385171016e+001
    3566,-1.937501046250e+000,-8.959110719085e+001,2.383293867060e+001
    3567,-1.937501046250e+000,-8.989856174409e+001,2.438669030633e+001
    3568,-1.937501046250e+000,-8.955749894632e+001,2.347248674054e+001
    3569,-1.937501046250e+000,-8.955749894632e+001,2.309157370098e+001
    3570,-1.937501046250e+000,-8.989855794217e+001,2.363424903341e+001
    3571,-1.937501046250e+000,-8.956209641982e+001,2.274960122559e+001
    3572,-1.937501046250e+000,-8.956209641982e+001,2.239109483542e+001
    3573,-1.937501046250e+000,-8.986954717114e+001,2.293182462796e+001
    3574,-1.937501046250e+000,-8.961311578166e+001,2.203100031045e+001
    3575,-1.937501046250e+000,-8.961311578166e+001,2.167249392028e+001
    3576,-1.937501046250e+000,-8.992516400647e+001,2.222975762760e+001
    3577,-1.937501046250e+000,-8.959186275162e+001,2.128310744505e+001
    3578,-1.937501046250e+000,-8.959186275162e+001,2.092460105487e+001
    3579,-1.937501046250e+000,-8.995493033827e+001,2.148027662739e+001
    3580,-1.937501046250e+000,-8.954547902547e+001,2.054584535060e+001
    3581,-1.937501046250e+000,-8.954547902547e+001,2.014252566165e+001
    3582,-1.937501046250e+000,-8.988729358209e+001,2.071213444788e+001
    3583,-1.937501046250e+000,-8.950868341181e+001,1.977727554589e+001
    3584,-1.937501046250e+000,-8.950868341181e+001,1.941876915572e+001
    3585,-1.937501046250e+000,-8.980411424229e+001,1.996812862783e+001
    3586,-1.937501046250e+000,-8.950358092610e+001,1.905808973053e+001
    3587,-1.937501046250e+000,-8.950358092610e+001,1.869958334035e+001
    3588,-1.937501046250e+000,-8.976221614292e+001,1.924219908687e+001
    3589,-1.937501046250e+000,-8.958454440062e+001,1.830342192434e+001
    3590,-1.937501046250e+000,-8.958454440062e+001,1.796732218355e+001
    3591,-1.937501046250e+000,-8.983807713172e+001,1.848535824567e+001
    3592,-1.937501046250e+000,-8.953886238837e+001,1.760523769827e+001
    3593,-1.937501046250e+000,-8.953886238837e+001,1.720191800933e+001
    3594,-1.937501046250e+000,-8.987335859399e+001,1.772711234437e+001
    3595,-1.937501046250e+000,-8.954515969917e+001,1.687510631982e+001
    3596,-1.937501046250e+000,-8.954515969917e+001,1.649419328027e+001
    3597,-1.937501046250e+000,-8.983397389254e+001,1.703821616958e+001
    3598,-1.937501046250e+000,-8.958984544979e+001,1.612155706301e+001
    3599,-1.937501046250e+000,-8.958984544979e+001,1.576305067284e+001
    3600,-1.937501046250e+000,-8.988495695396e+001,1.633876826282e+001
    3601,-1.937501046250e+000,-8.955666053545e+001,1.536850706746e+001
    3602,-1.937501046250e+000,-8.955666053545e+001,1.501000067729e+001
    3603,-1.937501046250e+000,-8.989645779024e+001,1.557158844018e+001
    3604,-1.937501046250e+000,-8.956154780676e+001,1.467863887760e+001
    3605,-1.937501046250e+000,-8.956154780676e+001,1.434253913681e+001
    3606,-1.937501046250e+000,-8.986816014721e+001,1.484568303511e+001
    3607,-1.937501046250e+000,-8.960338515082e+001,1.398479448599e+001
    3608,-1.937501046250e+000,-8.960338515082e+001,1.360388144644e+001
    3609,-1.937501046250e+000,-8.991488476258e+001,1.415657658460e+001
    3610,-1.937501046250e+000,-8.956102443379e+001,1.320628304159e+001
    3611,-1.937501046250e+000,-8.956102443379e+001,1.282537000203e+001
    3612,-1.937501046250e+000,-8.991436138962e+001,1.340123352894e+001
    3613,-1.937501046250e+000,-8.958538192664e+001,1.248059376639e+001
    3614,-1.937501046250e+000,-8.958538192664e+001,1.212208737622e+001
    3615,-1.937501046250e+000,-8.989635816543e+001,1.265885888845e+001
    3616,-1.937501046250e+000,-8.972359257027e+001,1.176274992541e+001
    3617,-1.937501046250e+000,-8.972359257027e+001,1.140424353524e+001
    3618,-1.937501046250e+000,-8.954865455738e+001,1.032097944275e+001
    3619,-1.937501046250e+000,-8.954865455738e+001,9.895253104419e+000
    3620,-1.937501046250e+000,-8.961378485422e+001,9.525444944626e+000
    3621,-1.937501046250e+000,-8.961378485422e+001,9.166938554454e+000
    3622,-1.937501046250e+000,-8.991239121661e+001,9.776084186754e+000
    3623,-1.937501046250e+000,-8.955833833657e+001,8.778978932633e+000
    3624,-1.937501046250e+000,-8.955833833657e+001,8.420472542462e+000
    3625,-1.937501046250e+000,-8.992207499579e+001,9.018316405139e+000
    3626,-1.937501046250e+000,-8.954049594145e+001,8.054582375537e+000
    3627,-1.937501046250e+000,-8.954049594145e+001,7.696075985366e+000
    3628,-1.937501046250e+000,-8.984878608302e+001,8.264466616393e+000
    3629,-1.937501046250e+000,-8.953636162696e+001,7.332327610641e+000
    3630,-1.937501046250e+000,-8.953636162696e+001,6.996227869856e+000
    3631,-1.937501046250e+000,-8.982680937340e+001,7.534828074744e+000
    3632,-1.937501046250e+000,-8.953982662200e+001,6.624458934577e+000
    3633,-1.937501046250e+000,-8.953982662200e+001,6.221139245634e+000
    3634,-1.937501046250e+000,-8.982614005396e+001,6.799310764740e+000
    3635,-1.937501046250e+000,-8.954027189785e+001,5.842200355836e+000
    3636,-1.937501046250e+000,-8.954027189785e+001,5.483693965665e+000
    3637,-1.937501046250e+000,-8.983005032485e+001,6.048602939662e+000
    3638,-1.937501046250e+000,-8.953818821700e+001,5.108995904461e+000
    3639,-1.937501046250e+000,-8.953818821700e+001,4.750489514290e+000
    3640,-1.937501046250e+000,-8.982841191985e+001,5.294965988660e+000
    3641,-1.937501046250e+000,-8.952618960198e+001,4.380813113324e+000
    3642,-1.937501046250e+000,-8.952618960198e+001,4.022306723152e+000
    3643,-1.937501046250e+000,-8.981432962398e+001,4.550591526490e+000
    3644,-1.937501046250e+000,-8.950360935280e+001,3.676969203549e+000
    3645,-1.937501046250e+000,-8.950360935280e+001,3.340869462763e+000
    3646,-1.937501046250e+000,-8.977975075978e+001,3.835577605920e+000
    3647,-1.937501046250e+000,-8.989802319750e+001,4.647250301796e+001
    3648,-1.937501046250e+000,-8.962177304833e+001,4.611399662779e+001
    3649,-1.937501046250e+000,-8.984245964828e+001,4.590938522901e+001
    3650,-1.937501046250e+000,-9.017427334668e+001,4.647250301796e+001
    3651,-1.937501046250e+000,-9.347462639012e+001,4.659093021604e+001
    3652,-1.937501046250e+000,-9.334712632127e+001,4.659093021604e+001
    3653,-1.937501046250e+000,-9.317060313861e+001,4.660800791125e+001
    3654,-1.937501046250e+000,-9.301547805484e+001,4.660800791125e+001
    3655,-1.937501046250e+000,-9.327267910758e+001,4.644891288228e+001
    3656,-1.937501046250e+000,-9.284153008285e+001,4.660279526679e+001
    3657,-1.937501046250e+000,-9.263965497384e+001,4.660279526679e+001
    3658,-1.937501046250e+000,-9.292220795293e+001,4.646077793304e+001
    3659,-1.937501046250e+000,-9.190378617971e+001,4.640175906395e+001
    3660,-1.937501046250e+000,-9.163178603283e+001,4.640175906395e+001
    3661,-1.937501046250e+000,-9.132148072369e+001,4.645191788397e+001
    3662,-1.937501046250e+000,-9.104523057451e+001,4.645191788397e+001
    3663,-1.937501046250e+000,-9.148896736582e+001,4.610365170291e+001
    3664,-1.937501046250e+000,-9.075331766427e+001,4.647843134686e+001
    3665,-1.937501046250e+000,-9.047494251395e+001,4.647843134686e+001
    3666,-1.937501046250e+000,-9.029416706892e+001,4.620090911982e+001
    3667,-1.937501046250e+000,-9.088674914643e+001,4.618032398582e+001
    3668,-1.937501046250e+000,-8.962193371555e+001,2.448835517730e+000
    3669,-1.937501046250e+000,-9.257093146181e+001,9.521553870355e+000
    3670,-1.937501046250e+000,-9.228840220487e+001,9.521553870355e+000
    3671,-1.937501046250e+000,-9.363230124227e+001,9.503024231670e+000
    3672,-1.937501046250e+000,-9.334545856157e+001,9.503024231670e+000
    3673,-1.937501046250e+000,-9.475512563571e+001,9.505367657268e+000
    3674,-1.937501046250e+000,-9.446612624312e+001,9.505367657268e+000
    3675,-1.937501046250e+000,-9.568473043630e+001,9.566910156983e+000
    3676,-1.937501046250e+000,-9.550788006173e+001,9.566910156983e+000
    3677,-1.937501046250e+000,-9.615145601764e+001,9.433134212114e+000
    3678,-1.937501046250e+000,-9.655113034668e+001,9.536358594415e+000
    3679,-1.937501046250e+000,-9.689718512016e+001,9.814879751784e+000
    3680,-1.937501046250e+000,-9.707730799010e+001,1.021438850275e+001
    3681,-1.937501046250e+000,-9.709176602589e+001,1.057743665692e+001
    3682,-1.937501046250e+000,-9.693173904716e+001,1.114629296211e+001
    3683,-1.937501046250e+000,-9.695470572622e+001,1.097404286910e+001
    3684,-1.937501046250e+000,-9.683803191298e+001,1.211941406818e+001
    3685,-1.937501046250e+000,-9.687529859977e+001,1.183991391725e+001
    3686,-1.937501046250e+000,-9.679105353465e+001,1.325307867878e+001
    3687,-1.937501046250e+000,-9.682832022144e+001,1.297357852785e+001
    3688,-1.937501046250e+000,-9.654089316885e+001,1.443087288905e+001
    3689,-1.937501046250e+000,-9.657945985634e+001,1.414162273286e+001
    3690,-1.937501046250e+000,-9.637150890444e+001,1.552199232743e+001
    3691,-1.937501046250e+000,-9.640747559053e+001,1.525224218176e+001
    3692,-1.937501046250e+000,-9.626115645481e+001,1.671506279291e+001
    3693,-1.937501046250e+000,-9.629495647306e+001,1.646156265602e+001
    3694,-1.937501046250e+000,-9.619506311204e+001,1.719074362713e+001
    3695,-1.937501046250e+000,-9.605754051454e+001,1.755800056485e+001
    3696,-1.937501046250e+000,-9.572451298719e+001,1.787546098512e+001
    3697,-1.937501046250e+000,-9.530597542859e+001,1.802780695505e+001
    3698,-1.937501046250e+000,-9.468164425579e+001,1.791451593859e+001
    3699,-1.937501046250e+000,-9.484536519596e+001,1.791451593859e+001
    3700,-1.937501046250e+000,-9.378256923267e+001,1.792951497905e+001
    3701,-1.937501046250e+000,-9.403418246705e+001,1.792951497905e+001
    3702,-1.937501046250e+000,-9.275118490818e+001,1.798855925227e+001
    3703,-1.937501046250e+000,-9.299418125098e+001,1.798855925227e+001
    3704,-1.937501046250e+000,-9.170850395693e+001,1.804213023640e+001
    3705,-1.937501046250e+000,-9.181659378487e+001,1.790067913213e+001
    3706,-1.937501046250e+000,-9.198376148168e+001,1.790067913213e+001
    3707,-1.937501046250e+000,-9.135901624936e+001,1.796880896081e+001
    3708,-1.937501046250e+000,-9.103195725164e+001,1.775556900894e+001
    3709,-1.937501046250e+000,-9.080104923080e+001,1.741804702634e+001
    3710,-1.937501046250e+000,-9.071240637985e+001,1.707146219498e+001
    3711,-1.937501046250e+000,-9.073643034224e+001,1.635081172360e+001
    3712,-1.937501046250e+000,-9.073643034224e+001,1.660106185874e+001
    3713,-1.937501046250e+000,-9.051836600425e+001,1.623661240801e+001
    3714,-1.937501046250e+000,-9.073277785971e+001,1.527129489990e+001
    3715,-1.937501046250e+000,-9.073277785971e+001,1.554104504557e+001
    3716,-1.937501046250e+000,-9.073651018675e+001,1.417122259035e+001
    3717,-1.937501046250e+000,-9.073651018675e+001,1.444747273952e+001
    3718,-1.937501046250e+000,-9.073704715914e+001,1.310844595189e+001
    3719,-1.937501046250e+000,-9.073704715914e+001,1.339119610458e+001
    3720,-1.937501046250e+000,-9.075574618755e+001,1.202985752500e+001
    3721,-1.937501046250e+000,-9.075574618755e+001,1.229635766891e+001
    3722,-1.937501046250e+000,-9.075250629333e+001,1.088785368086e+001
    3723,-1.937501046250e+000,-9.075250629333e+001,1.115760382652e+001
    3724,-1.937501046250e+000,-9.072208094812e+001,1.043521952614e+001
    3725,-1.937501046250e+000,-9.080186941789e+001,1.009653650515e+001
    3726,-1.937501046250e+000,-9.101990991472e+001,9.775256282241e+000
    3727,-1.937501046250e+000,-9.558291589497e+001,2.221999196058e+001
    3728,-1.937501046250e+000,-9.601718188629e+001,2.210309422265e+001
    3729,-1.937501046250e+000,-9.554588254164e+001,2.249774211056e+001
    3730,-1.937501046250e+000,-9.563223303095e+001,2.131660091485e+001
    3731,-1.937501046250e+000,-9.566706638309e+001,2.105535077377e+001
    3732,-1.937501046250e+000,-9.588527099746e+001,2.271012528468e+001
    3733,-1.937501046250e+000,-9.581982806058e+001,2.095971779898e+001
    3734,-1.937501046250e+000,-9.536692832068e+001,2.367005746343e+001
    3735,-1.937501046250e+000,-9.540469500774e+001,2.338680731048e+001
    3736,-2.062501113750e+000,-9.679863715551e+001,1.936726473612e+000
    3737,-2.062501113750e+000,-9.652824975042e+001,1.936726473612e+000
    3738,-1.937501046250e+000,-9.565481346828e+001,2.474504311490e+001
    3739,-1.937501046250e+000,-9.501990393864e+001,2.575942069672e+001
    3740,-1.937501046250e+000,-9.504630395290e+001,2.556142058980e+001
    3741,-1.937501046250e+000,-9.499043496576e+001,2.624555617521e+001
    3742,-1.937501046250e+000,-9.481887754621e+001,2.663107417619e+001
    3743,-1.937501046250e+000,-9.448214676711e+001,2.690999384196e+001
    3744,-1.937501046250e+000,-9.408289540470e+001,2.699904944501e+001
    3745,-1.937501046250e+000,-9.340443503810e+001,2.691364379858e+001
    3746,-1.937501046250e+000,-9.360888983295e+001,2.691364379858e+001
    3747,-1.937501046250e+000,-9.173881989356e+001,2.706731655155e+001
    3748,-1.937501046250e+000,-9.183605854048e+001,2.693241470327e+001
    3749,-1.937501046250e+000,-9.229165625460e+001,2.699397801815e+001
    3750,-1.937501046250e+000,-9.258935142292e+001,2.699397801815e+001
    3751,-1.937501046250e+000,-9.202927955539e+001,2.693241470327e+001
    3752,-1.937501046250e+000,-9.136688959614e+001,2.694771354973e+001
    3753,-1.937501046250e+000,-9.102044553761e+001,2.675175548667e+001
    3754,-1.937501046250e+000,-9.080252889514e+001,2.642763043117e+001
    3755,-1.937501046250e+000,-9.071151764727e+001,2.605914374306e+001
    3756,-1.937501046250e+000,-9.079381863283e+001,2.542576486753e+001
    3757,-1.937501046250e+000,-9.079381863283e+001,2.561826497148e+001
    3758,-1.937501046250e+000,-9.073368620367e+001,2.441207626922e+001
    3759,-1.937501046250e+000,-9.073368620367e+001,2.467607641178e+001
    3760,-1.937501046250e+000,-9.073361213570e+001,2.336246538993e+001
    3761,-1.937501046250e+000,-9.073361213570e+001,2.362921553397e+001
    3762,-1.937501046250e+000,-9.073905790657e+001,2.226534701959e+001
    3763,-1.937501046250e+000,-9.073905790657e+001,2.254034716809e+001
    3764,-1.937501046250e+000,-9.075846222027e+001,2.129046511370e+001
    3765,-1.937501046250e+000,-9.075846222027e+001,2.152696524141e+001
    3766,-1.937501046250e+000,-9.071920158022e+001,2.043877688766e+001
    3767,-1.937501046250e+000,-9.084547303017e+001,2.055528233675e+001
    3768,-1.937501046250e+000,-9.084547303017e+001,2.069553241249e+001
    3769,-1.937501046250e+000,-9.082454960832e+001,2.007566993612e+001
    3770,-1.937501046250e+000,-9.104853737317e+001,1.975639381464e+001
    3771,-1.937501046250e+000,-9.137255843404e+001,1.954607073499e+001
    3772,-1.937501046250e+000,-9.213955251722e+001,1.934997491970e+001
    3773,-1.937501046250e+000,-9.201953597797e+001,1.955963061455e+001
    3774,-1.937501046250e+000,-9.312747297466e+001,1.951959259845e+001
    3775,-1.937501046250e+000,-9.284883458615e+001,1.951959259845e+001
    3776,-1.937501046250e+000,-9.427617066984e+001,1.954541257144e+001
    3777,-1.937501046250e+000,-9.400647255048e+001,1.954541257144e+001
    3778,-1.937501046250e+000,-9.478065935017e+001,1.946672039401e+001
    3779,-1.937501046250e+000,-9.517019814783e+001,1.956401155338e+001
    3780,-1.937501046250e+000,-9.553987362148e+001,1.981094936886e+001
    3781,-1.937501046250e+000,-9.572904526442e+001,2.020378125776e+001
    3782,-1.937501046250e+000,-9.453183703979e+001,2.957006772842e+001
    3783,-1.937501046250e+000,-9.478248053035e+001,3.037808702503e+001
    3784,-1.937501046250e+000,-9.441883805027e+001,3.017075099901e+001
    3785,-1.937501046250e+000,-9.444613806501e+001,2.996600088844e+001
    3786,-1.937501046250e+000,-9.438806346263e+001,3.121933048085e+001
    3787,-1.937501046250e+000,-9.420072019660e+001,3.247247704799e+001
    3788,-1.937501046250e+000,-9.424015355123e+001,3.217672688829e+001
    3789,-1.937501046250e+000,-9.409624873703e+001,3.344690979527e+001
    3790,-1.937501046250e+000,-9.394349320630e+001,3.460743503743e+001
    3791,-1.937501046250e+000,-9.367054494886e+001,3.570902440099e+001
    3792,-1.937501046250e+000,-9.369697829646e+001,3.551077429393e+001
    3793,-1.937501046250e+000,-9.367657763526e+001,3.615432107818e+001
    3794,-1.937501046250e+000,-9.354934614251e+001,3.649630439726e+001
    3795,-1.937501046250e+000,-9.332181542935e+001,3.678910740860e+001
    3796,-1.937501046250e+000,-9.301140875133e+001,3.696526217409e+001
    3797,-1.937501046250e+000,-9.173133645756e+001,3.708132390404e+001
    3798,-1.937501046250e+000,-9.184731298068e+001,3.693687606960e+001
    3799,-1.937501046250e+000,-9.232754410766e+001,3.693456083187e+001
    3800,-1.937501046250e+000,-9.255681301310e+001,3.693456083187e+001
    3801,-1.937501046250e+000,-9.207475504225e+001,3.693687606960e+001
    3802,-1.937501046250e+000,-9.133550710127e+001,3.695454514966e+001
    3803,-1.937501046250e+000,-9.100453189770e+001,3.671571089404e+001
    3804,-1.937501046250e+000,-9.080205983457e+001,3.638372874378e+001
    3805,-1.937501046250e+000,-9.074068564117e+001,3.604984938376e+001
    3806,-1.937501046250e+000,-9.073150841183e+001,3.534348252100e+001
    3807,-1.937501046250e+000,-9.073150841183e+001,3.559698265789e+001
    3808,-1.937501046250e+000,-9.078512975987e+001,3.424589277353e+001
    3809,-1.937501046250e+000,-9.078512975987e+001,3.450914291569e+001
    3810,-1.937501046250e+000,-9.072746949889e+001,3.313939074580e+001
    3811,-1.937501046250e+000,-9.072746949889e+001,3.341889089673e+001
    3812,-1.937501046250e+000,-9.078198011310e+001,3.205111142042e+001
    3813,-1.937501046250e+000,-9.078198011310e+001,3.232736156959e+001
    3814,-1.937501046250e+000,-9.073771339770e+001,3.098571338429e+001
    3815,-1.937501046250e+000,-9.073771339770e+001,3.125546352995e+001
    3816,-1.937501046250e+000,-9.073799605652e+001,2.990047184144e+001
    3817,-1.937501046250e+000,-9.073799605652e+001,3.016697198535e+001
    3818,-1.937501046250e+000,-9.071139032802e+001,2.942882943177e+001
    3819,-1.937501046250e+000,-9.080853232413e+001,2.909366383204e+001
    3820,-1.937501046250e+000,-9.104597927256e+001,2.878340246890e+001
    3821,-1.937501046250e+000,-9.135049831032e+001,2.856001067768e+001
    3822,-1.937501046250e+000,-9.200145737496e+001,2.858198172110e+001
    3823,-1.937501046250e+000,-9.182344846809e+001,2.858198172110e+001
    3824,-1.937501046250e+000,-9.301755070437e+001,2.853898010393e+001
    3825,-1.937501046250e+000,-9.274163689872e+001,2.853898010393e+001
    3826,-1.937501046250e+000,-9.376761782321e+001,2.864583863882e+001
    3827,-1.937501046250e+000,-9.363691991802e+001,2.862232557614e+001
    3828,-1.937501046250e+000,-9.434342951742e+001,2.880400875112e+001
    3829,-1.937501046250e+000,-9.453423914499e+001,2.919671478401e+001
    3830,-1.937501046250e+000,-9.898176626030e+001,3.131848206309e+000
    3831,-1.937501046250e+000,-9.848060800983e+001,9.612201795584e+000
    3832,-1.937501046250e+000,-9.841780000555e+001,1.008326182761e+001
    3833,-1.937501046250e+000,-9.782997033458e+001,1.426395213924e+001
    3834,-1.937501046250e+000,-9.777015318765e+001,1.471258074117e+001
    3835,-1.937501046250e+000,-9.761047281362e+001,1.608777039235e+001
    3836,-1.937501046250e+000,-9.753869223732e+001,1.662612471467e+001
    3837,-1.937501046250e+000,-9.714861879526e+001,1.680219400495e+001
    3838,-1.937501046250e+000,-9.724876730536e+001,1.591723734622e+001
    3839,-1.937501046250e+000,-9.684857173511e+001,1.877708410147e+001
    3840,-1.937501046250e+000,-9.631513950702e+001,2.578646359151e+001
    3841,-1.937501046250e+000,-9.624934064541e+001,2.627995505364e+001
    3842,-1.937501046250e+000,-9.349468594397e+001,4.620920714296e+001
    3843,-1.937501046250e+000,-9.368440858063e+001,4.643625948616e+001
    3844,-1.937501046250e+000,-9.497734035579e+001,3.563502742851e+001
    3845,-1.937501046250e+000,-9.492350492356e+001,3.603879317025e+001
    3846,-1.937501046250e+000,-9.484925000650e+001,3.668482900751e+001
    3847,-1.937501046250e+000,-9.478046028753e+001,3.720075189974e+001
    3848,-1.937501046250e+000,-9.379078907598e+001,4.528618397839e+001
    3849,-1.937501046250e+000,-9.374592621579e+001,4.562265542984e+001
    3850,-1.937501046250e+000,-9.269323498138e+001,9.325722688432e+000
    3851,-1.937501046250e+000,-9.219658460607e+001,9.314368377047e+000
    3852,-1.937501046250e+000,-9.890954042626e+001,2.296101110030e+000
    3853,-1.937501046250e+000,-9.806391567922e+001,1.022822281421e+001
    3854,-1.937501046250e+000,-8.990468111958e+001,4.162600337021e+001
    3855,-1.937501046250e+000,-8.988507431424e+001,3.558883467564e+001
    3856,-1.937501046250e+000,-9.005892630190e+001,1.195474520200e+001
    3857,-1.937501046250e+000,-8.955662656274e+001,1.101356883236e+001
    3858,-1.937501046250e+000,-8.955662656274e+001,1.065506244219e+001
    3859,-1.937501046250e+000,-9.375174936055e+001,9.247806776482e+000
    3860,-1.937501046250e+000,-8.946982212104e+001,3.038572259026e+000
    3861,-1.937501046250e+000,-8.946982212104e+001,2.680065868855e+000
    3862,-1.937501046250e+000,-9.221394913159e+001,4.644385587277e+001
    3863,-1.937501046250e+000,-9.210943562684e+001,4.609558969171e+001
    3864,-1.937501046250e+000,-9.247532427273e+001,4.644385587277e+001
    3865,-1.937501046250e+000,-9.485878315078e+001,9.291667196876e+000
    3866,-1.937501046250e+000,-9.574372166920e+001,2.058379577682e+001
    3867,-1.937501046250e+000,-9.878296156994e+001,2.533987025246e+000
    3868,-1.937501046250e+000,-9.320248651928e+001,9.307193049747e+000
    3869,-1.937501046250e+000,-9.430735852823e+001,9.250150202079e+000
    3870,-1.937501046250e+000,-9.535704557436e+001,9.353209696590e+000
    3871,-1.937501046250e+000,-9.710294910481e+001,1.090132663639e+001
    3872,-1.937501046250e+000,-9.707127007411e+001,1.172556083946e+001
    3873,-1.937501046250e+000,-9.727577809467e+001,1.277641466313e+001
    3874,-1.937501046250e+000,-9.699261671791e+001,1.406934857364e+001
    3875,-1.937501046250e+000,-9.668184371596e+001,1.514334514305e+001
    3876,-1.937501046250e+000,-9.658692795866e+001,1.633299853538e+001
    3877,-1.937501046250e+000,-9.493776942601e+001,1.806948399348e+001
    3878,-1.937501046250e+000,-9.412120156122e+001,1.812448646781e+001
    3879,-1.937501046250e+000,-9.315420311670e+001,1.822035943478e+001
    3880,-1.937501046250e+000,-9.209245838694e+001,1.816586632011e+001
    3881,-1.937501046250e+000,-9.058763886814e+001,1.670718846300e+001
    3882,-1.937501046250e+000,-9.051471352172e+001,1.569009587212e+001
    3883,-1.937501046250e+000,-9.046267161213e+001,1.457388799085e+001
    3884,-1.937501046250e+000,-9.051845702326e+001,1.352785278264e+001
    3885,-1.937501046250e+000,-9.048862144439e+001,1.243353909180e+001
    3886,-1.937501046250e+000,-9.035105019610e+001,1.128605464072e+001
    3887,-1.937501046250e+000,-9.578331681808e+001,2.330494032569e+001
    3888,-1.937501046250e+000,-9.546672754431e+001,2.543115715943e+001
    3889,-1.937501046250e+000,-9.371842472639e+001,2.704767016735e+001
    3890,-1.937501046250e+000,-9.274371188554e+001,2.722337468135e+001
    3891,-1.937501046250e+000,-9.063412488200e+001,2.570947234979e+001
    3892,-1.937501046250e+000,-9.047312711541e+001,2.479137493086e+001
    3893,-1.937501046250e+000,-9.051381895379e+001,2.374513285215e+001
    3894,-1.937501046250e+000,-9.046512800865e+001,2.266587315051e+001
    3895,-1.937501046250e+000,-9.055078623043e+001,2.166390756972e+001
    3896,-1.937501046250e+000,-9.065213781670e+001,2.078543000864e+001
    3897,-1.937501046250e+000,-9.267680233317e+001,1.930993690360e+001
    3898,-1.937501046250e+000,-9.387489176838e+001,1.930726964827e+001
    3899,-1.937501046250e+000,-9.458053711038e+001,2.989479176737e+001
    3900,-1.937501046250e+000,-9.479157263090e+001,3.112766634542e+001
    3901,-1.937501046250e+000,-9.460035720589e+001,3.195416760046e+001
    3902,-2.062501113750e+000,-9.625256063149e+001,1.936726473612e+000
    3903,-1.937501046250e+000,-9.433606674865e+001,3.449672232439e+001
    3904,-1.937501046250e+000,-9.406674527336e+001,3.527031772344e+001
    3905,-1.937501046250e+000,-9.265127466021e+001,3.707422900355e+001
    3906,-1.937501046250e+000,-9.059818269424e+001,3.569971716343e+001
    3907,-1.937501046250e+000,-9.052137601219e+001,3.465016098074e+001
    3908,-1.937501046250e+000,-9.046245426282e+001,3.356207937641e+001
    3909,-1.937501046250e+000,-9.051744620482e+001,3.245144467655e+001
    3910,-1.937501046250e+000,-9.047443775490e+001,3.139677196790e+001
    3911,-1.937501046250e+000,-9.052234236079e+001,3.030472513064e+001
    3912,-1.937501046250e+000,-9.170115182832e+001,2.844364997040e+001
    3913,-1.937501046250e+000,-9.261209971021e+001,2.834657863558e+001
    3914,-1.937501046250e+000,-9.354409926343e+001,2.842765318555e+001
    3915,-1.937501046250e+000,-9.734863053247e+001,1.499067629697e+001
    3916,-1.937501046250e+000,-9.614526522118e+001,2.658029546671e+001
    3917,-1.937501046250e+000,-9.583705481621e+001,2.620408808030e+001
    3918,-1.937501046250e+000,-9.428083662841e+001,3.743473562182e+001
    3919,-1.937501046250e+000,-8.985523292513e+001,1.047997534599e+001
    3920,-1.937501046250e+000,-9.576993481018e+001,9.400012948584e+000
    3921,-1.937501046250e+000,-9.638224336794e+001,1.684811681387e+001
    3922,-1.937501046250e+000,-9.662231370114e+001,1.570217837351e+001
    3923,-1.937501046250e+000,-9.677799460749e+001,1.460147600127e+001
    3924,-1.937501046250e+000,-9.716781037656e+001,1.345380466699e+001
    3925,-1.937501046250e+000,-9.724735643229e+001,1.220825035791e+001
    3926,-1.937501046250e+000,-9.709477717038e+001,1.127894001770e+001
    3927,-1.937501046250e+000,-9.259275817420e+001,1.825374644025e+001
    3928,-1.937501046250e+000,-9.366168043261e+001,1.816131516156e+001
    3929,-1.937501046250e+000,-9.455151768193e+001,1.810948742735e+001
    3930,-1.937501046250e+000,-9.046992241598e+001,1.297912723088e+001
    3931,-1.937501046250e+000,-9.051792005087e+001,1.404462912625e+001
    3932,-1.937501046250e+000,-9.045893928509e+001,1.513121000732e+001
    3933,-1.937501046250e+000,-9.602873233521e+001,2.148295332987e+001
    3934,-1.937501046250e+000,-9.565869122895e+001,2.396422794482e+001
    3935,-1.937501046250e+000,-9.515705753333e+001,2.588456231789e+001
    3936,-1.937501046250e+000,-9.218444423517e+001,2.717637827642e+001
    3937,-1.937501046250e+000,-9.328356789226e+001,2.714304046179e+001
    3938,-1.937501046250e+000,-9.056512700680e+001,2.119336260887e+001
    3939,-1.937501046250e+000,-9.053138191673e+001,2.214378920830e+001
    3940,-1.937501046250e+000,-9.045968223779e+001,2.322399122979e+001
    3941,-1.937501046250e+000,-9.051389302175e+001,2.425849344187e+001
    3942,-1.937501046250e+000,-9.053325954458e+001,2.529081325148e+001
    3943,-1.937501046250e+000,-9.437767871039e+001,1.938964589341e+001
    3944,-1.937501046250e+000,-9.328645093994e+001,1.928144967528e+001
    3945,-1.937501046250e+000,-9.381143409273e+001,3.580224334776e+001
    3946,-2.062501113750e+000,-9.537212080049e+001,1.936726473612e+000
    3947,-2.062501113750e+000,-9.510173339539e+001,1.936726473612e+000
    3948,-1.937501046250e+000,-9.444982225832e+001,3.362869724018e+001
    3949,-1.937501046250e+000,-9.449617591495e+001,3.277449615496e+001
    3950,-2.062501113750e+000,-9.566139895171e+001,1.936726473612e+000
    3951,-2.062501113750e+000,-9.595829492594e+001,1.936726473612e+000
    3952,-1.937501046250e+000,-9.347130270813e+001,4.501054653350e+001
    3953,-1.937501046250e+000,-9.219736548177e+001,3.712141705648e+001
    3954,-1.937501046250e+000,-9.052205970197e+001,3.085046638216e+001
    3955,-1.937501046250e+000,-9.051870447030e+001,3.192916971621e+001
    3956,-1.937501046250e+000,-9.046293559060e+001,3.300347371235e+001
    3957,-1.937501046250e+000,-9.052011452380e+001,3.411933110755e+001
    3958,-1.937501046250e+000,-9.046775466415e+001,3.520500043513e+001
    3959,-1.937501046250e+000,-9.396033235109e+001,2.855656916799e+001
    3960,-1.937501046250e+000,-9.310095886759e+001,2.834430771335e+001
    3961,-1.937501046250e+000,-9.213181319047e+001,2.838958025274e+001
    3962,-1.937501046250e+000,-9.813047987307e+001,9.319914036823e+000
    3963,-1.937501046250e+000,-9.351732243363e+001,4.568721167790e+001
    3964,-1.937501046250e+000,-8.972338327884e+001,3.187942882579e+000
    3965,-1.937501046250e+000,-9.231328795740e+001,9.057476384599e+000
    3966,-1.937501046250e+000,-9.205407214294e+001,9.078742285937e+000
    3967,-1.937501046250e+000,-9.444097513208e+001,8.973960589453e+000
    3968,-1.937501046250e+000,-9.416281182861e+001,8.963380741997e+000
    3969,-1.937501046250e+000,-8.984170764159e+001,2.654415327716e+000
    3970,-1.937501046250e+000,-9.550530810564e+001,9.108782052713e+000
    3971,-1.937501046250e+000,-9.528030700113e+001,9.078176700338e+000
    3972,-1.937501046250e+000,-9.594730065859e+001,2.071201904449e+001
    3973,-1.937501046250e+000,-9.595740507538e+001,2.054694667316e+001
    3974,-1.937501046250e+000,-9.730113766756e+001,1.088692600120e+001
    3975,-1.937501046250e+000,-9.726430327511e+001,1.071879556391e+001
    3976,-1.937501046250e+000,-9.629201316086e+001,9.220350318178e+000
    3977,-1.937501046250e+000,-9.609838008471e+001,9.203426954267e+000
    3978,-1.937501046250e+000,-9.710738569385e+001,1.442659177693e+001
    3979,-1.937501046250e+000,-9.730077709957e+001,1.416582520962e+001
    3980,-1.937501046250e+000,-9.694431925928e+001,1.543606880278e+001
    3981,-1.937501046250e+000,-9.701923944611e+001,1.516556052132e+001
    3982,-1.937501046250e+000,-9.687598583274e+001,1.652584212983e+001
    3983,-1.937501046250e+000,-9.692676174722e+001,1.618334691695e+001
    3984,-1.937501046250e+000,-9.708615498915e+001,1.469795263725e+001
    3985,-1.937501046250e+000,-9.485900902702e+001,1.823620061452e+001
    3986,-1.937501046250e+000,-9.503745398052e+001,1.822666231583e+001
    3987,-1.937501046250e+000,-9.695970943128e+001,1.572439375177e+001
    3988,-1.937501046250e+000,-9.634448753768e+001,1.727578178746e+001
    3989,-1.937501046250e+000,-9.637775911735e+001,1.710577803982e+001
    3990,-1.937501046250e+000,-9.164373674427e+001,1.824517408854e+001
    3991,-1.937501046250e+000,-9.181837081207e+001,1.825439253140e+001
    3992,-1.937501046250e+000,-9.016890016314e+001,1.285100233942e+001
    3993,-1.937501046250e+000,-9.017302292543e+001,1.313176001555e+001
    3994,-1.937501046250e+000,-9.202769117428e+001,1.836891017225e+001
    3995,-1.937501046250e+000,-9.061018210795e+001,1.078624445535e+001
    3996,-1.937501046250e+000,-9.035429009032e+001,1.188205819003e+001
    3997,-1.937501046250e+000,-9.024678158430e+001,1.596912108132e+001
    3998,-1.937501046250e+000,-9.020122712453e+001,1.623362337225e+001
    3999,-1.937501046250e+000,-9.017300932600e+001,1.440387941483e+001
    4000,-1.937501046250e+000,-9.016270970464e+001,1.468432981145e+001
    4001,-1.937501046250e+000,-9.021538364246e+001,1.352935842040e+001
    4002,-1.937501046250e+000,-9.025979548745e+001,1.379732629603e+001
    4003,-1.937501046250e+000,-9.015782243333e+001,1.501569161114e+001
    4004,-1.937501046250e+000,-9.016438972766e+001,1.529256323099e+001
    4005,-1.937501046250e+000,-9.021484667007e+001,1.404613476401e+001
    4006,-1.937501046250e+000,-9.015654137392e+001,1.660625958951e+001
    4007,-1.937501046250e+000,-9.021607944668e+001,1.224139564083e+001
    4008,-1.937501046250e+000,-9.052933425369e+001,1.035899889243e+001
    4009,-1.937501046250e+000,-9.052265407481e+001,1.051956674674e+001
    4010,-1.937501046250e+000,-9.603351146677e+001,2.092286869532e+001
    4011,-1.937501046250e+000,-9.525267984849e+001,2.607955517561e+001
    4012,-1.937501046250e+000,-9.535780331294e+001,2.589519751902e+001
    4013,-1.937501046250e+000,-9.197198008162e+001,2.733634763449e+001
    4014,-1.937501046250e+000,-9.223435678083e+001,2.739791094937e+001
    4015,-1.937501046250e+000,-9.056027324067e+001,2.030124722194e+001
    4016,-1.937501046250e+000,-9.053196858080e+001,2.047302393778e+001
    4017,-1.937501046250e+000,-9.027352801065e+001,2.102559828297e+001
    4018,-1.937501046250e+000,-9.022527630439e+001,2.125865447806e+001
    4019,-1.937501046250e+000,-9.119432924981e+001,2.706529789768e+001
    4020,-1.937501046250e+000,-9.138301190482e+001,2.713740248950e+001
    4021,-1.937501046250e+000,-9.042692665635e+001,2.567149978291e+001
    4022,-1.937501046250e+000,-9.047346341269e+001,2.585295607233e+001
    4023,-1.937501046250e+000,-9.324640523689e+001,2.737533891986e+001
    4024,-1.937501046250e+000,-9.348937029245e+001,2.730957161023e+001
    4025,-1.937501046250e+000,-9.455016903830e+001,1.922573590336e+001
    4026,-1.937501046250e+000,-9.433144254389e+001,1.917690448782e+001
    4027,-1.937501046250e+000,-9.019967065906e+001,2.374855960159e+001
    4028,-1.937501046250e+000,-9.024631448144e+001,2.399127421404e+001
    4029,-1.937501046250e+000,-9.019241990565e+001,2.525585720646e+001
    4030,-1.937501046250e+000,-9.024674848674e+001,2.549306001535e+001
    4031,-1.937501046250e+000,-9.017610565888e+001,2.248801711686e+001
    4032,-1.937501046250e+000,-9.016316699440e+001,2.276770818622e+001
    4033,-1.937501046250e+000,-9.019974472702e+001,2.426192019130e+001
    4034,-1.937501046250e+000,-9.024652933443e+001,2.164804095330e+001
    4035,-1.937501046250e+000,-9.028044026432e+001,2.188552971905e+001
    4036,-1.937501046250e+000,-9.015856952091e+001,2.310968066161e+001
    4037,-1.937501046250e+000,-9.016606241453e+001,2.338810767152e+001
    4038,-1.937501046250e+000,-9.022712502073e+001,2.212792259189e+001
    4039,-1.937501046250e+000,-9.222353594915e+001,1.910717353876e+001
    4040,-1.937501046250e+000,-9.199155435914e+001,1.912644918316e+001
    4041,-1.937501046250e+000,-9.406349710689e+001,1.902652344843e+001
    4042,-1.937501046250e+000,-9.377943665929e+001,1.899297861882e+001
    4043,-1.937501046250e+000,-9.182881023611e+001,1.955963061455e+001
    4044,-1.937501046250e+000,-9.392859565467e+001,3.597741209140e+001
    4045,-1.937501046250e+000,-9.401235863262e+001,3.578657541997e+001
    4046,-1.937501046250e+000,-9.474718146992e+001,2.985806763492e+001
    4047,-1.937501046250e+000,-9.467173570413e+001,2.969949654993e+001
    4048,-1.937501046250e+000,-9.342338855408e+001,1.901133134154e+001
    4049,-1.937501046250e+000,-9.311900817324e+001,1.901905619816e+001
    4050,-1.937501046250e+000,-9.361199389259e+001,1.873058514170e+001
    4051,-1.937501046250e+000,-9.017194413248e+001,2.491614504589e+001
    4052,-1.937501046250e+000,-9.296071673868e+001,4.488657348285e+001
    4053,-1.937501046250e+000,-9.298388930011e+001,4.526387120629e+001
    4054,-1.937501046250e+000,-9.423835312049e+001,3.567122638752e+001
    4055,-1.937501046250e+000,-9.440990132318e+001,3.533013743463e+001
    4056,-1.937501046250e+000,-9.260597265412e+001,3.729804173720e+001
    4057,-1.937501046250e+000,-9.280709276716e+001,3.725316892201e+001
    4058,-1.937501046250e+000,-9.058903858537e+001,2.980594720372e+001
    4059,-1.937501046250e+000,-9.157960238859e+001,3.726655804622e+001
    4060,-1.937501046250e+000,-9.179284234738e+001,3.730896643638e+001
    4061,-1.937501046250e+000,-9.026803766872e+001,3.061229206433e+001
    4062,-1.937501046250e+000,-9.022135562215e+001,3.087473578715e+001
    4063,-1.937501046250e+000,-9.019325765598e+001,1.250622610378e+001
    4064,-1.937501046250e+000,-9.409285063408e+001,2.845016028366e+001
    4065,-1.937501046250e+000,-9.387621950534e+001,2.838822674294e+001
    4066,-1.937501046250e+000,-9.016114791467e+001,3.344566092669e+001
    4067,-1.937501046250e+000,-9.016871231971e+001,3.372597662989e+001
    4068,-1.937501046250e+000,-9.017120246243e+001,3.505610350510e+001
    4069,-1.937501046250e+000,-9.016641548195e+001,3.535704911424e+001
    4070,-1.937501046250e+000,-9.025550249812e+001,3.218213206346e+001
    4071,-1.937501046250e+000,-9.020903761673e+001,3.245587113840e+001
    4072,-1.937501046250e+000,-9.021143322644e+001,3.413097867150e+001
    4073,-1.937501046250e+000,-9.026152908238e+001,3.440791469944e+001
    4074,-1.937501046250e+000,-9.017918686609e+001,3.127472470850e+001
    4075,-1.937501046250e+000,-9.017824696558e+001,3.155858657141e+001
    4076,-1.937501046250e+000,-9.016997466527e+001,3.284007747383e+001
    4077,-1.937501046250e+000,-9.016192893245e+001,3.311836743469e+001
    4078,-1.937501046250e+000,-9.022163828097e+001,3.032899453563e+001
    4079,-1.937501046250e+000,-9.021029588221e+001,3.193359617807e+001
    4080,-1.937501046250e+000,-9.175420992553e+001,2.818688413495e+001
    4081,-1.937501046250e+000,-9.155851436267e+001,2.821658618816e+001
    4082,-1.937501046250e+000,-9.052397693808e+001,2.935881378467e+001
    4083,-1.937501046250e+000,-9.051472080776e+001,2.952045115840e+001
    4084,-1.937501046250e+000,-9.487012248030e+001,3.634754930941e+001
    4085,-1.937501046250e+000,-9.452812672705e+001,3.603980223787e+001
    4086,-1.937501046250e+000,-9.369565959537e+001,2.825487706723e+001
    4087,-1.937501046250e+000,-9.349605763646e+001,2.818789462552e+001
    4088,-1.937501046250e+000,-9.382817787836e+001,2.814846818291e+001
    4089,-1.937501046250e+000,-9.319968840629e+001,2.808072968356e+001
    4090,-1.937501046250e+000,-9.295614996936e+001,2.806436665307e+001
    4091,-1.937501046250e+000,-9.335124873823e+001,2.790795356524e+001
    4092,-1.937501046250e+000,-9.469257222309e+001,2.877086605580e+001
    4093,-1.937501046250e+000,-9.452610618551e+001,2.858536001338e+001
    4094,-1.937501046250e+000,-9.781544936127e+001,1.001509524193e+001
    4095,-1.937501046250e+000,-9.777866022779e+001,1.040287573065e+001
    4096,-1.937501046250e+000,-9.812678320171e+001,4.774438823169e+000
    4097,-1.937501046250e+000,-9.802211791342e+001,5.287662133461e+000
    4098,-1.937501046250e+000,-9.790735405106e+001,5.860683163306e+000
    4099,-1.937501046250e+000,-9.785184474019e+001,6.403698863555e+000
    4100,-1.937501046250e+000,-9.750585124710e+001,5.483696933913e+000
    4101,-1.937501046250e+000,-9.777931861652e+001,6.985114709229e+000
    4102,-1.937501046250e+000,-9.771817054351e+001,7.488937699126e+000
    4103,-1.937501046250e+000,-9.731856126107e+001,6.638133809432e+000
    4104,-1.937501046250e+000,-9.772938808301e+001,8.033450740836e+000
    4105,-1.937501046250e+000,-9.771436257492e+001,8.553980743342e+000
    4106,-1.937501046250e+000,-9.725725267690e+001,7.764062696817e+000
    4107,-1.937501046250e+000,-9.028863139306e+001,4.183348456643e+001
    4108,-1.937501046250e+000,-9.025177186642e+001,4.141132110536e+001
    4109,-1.937501046250e+000,-9.757204203119e+001,1.194070825992e+001
    4110,-1.937501046250e+000,-9.637134839476e+001,2.143216894728e+001
    4111,-1.937501046250e+000,-9.643403044391e+001,2.048444721376e+001
    4112,-1.937501046250e+000,-9.637612752632e+001,2.087208431272e+001
    4113,-1.937501046250e+000,-9.511996155401e+001,3.027091850093e+001
    4114,-1.937501046250e+000,-9.521576694324e+001,2.829165751481e+001
    4115,-1.937501046250e+000,-9.521401277391e+001,2.876856576813e+001
    4116,-1.937501046250e+000,-9.009655615543e+001,1.062870222923e+001
    4117,-1.937501046250e+000,-9.008858415007e+001,1.029461922979e+001
    4118,-1.937501046250e+000,-9.207329212445e+001,3.735116246115e+001
    4119,-1.937501046250e+000,-9.232608118986e+001,3.734884722342e+001
    4120,-1.937501046250e+000,-9.192155805547e+001,3.753639660332e+001
    4121,-1.937501046250e+000,-9.361616910257e+001,3.900998376611e+001
    4122,-1.937501046250e+000,-9.359123693490e+001,3.946110961706e+001
    4123,-1.937501046250e+000,-9.362976319162e+001,3.988870729751e+001
    4124,-1.937501046250e+000,-9.355294190340e+001,4.039267898416e+001
    4125,-1.937501046250e+000,-9.317459717574e+001,3.967450699316e+001
    4126,-1.937501046250e+000,-9.336867022146e+001,4.080313577659e+001
    4127,-1.937501046250e+000,-9.327176999057e+001,4.129355834365e+001
    4128,-1.937501046250e+000,-9.302885175053e+001,4.051256146604e+001
    4129,-1.937501046250e+000,-9.312424329021e+001,4.184771240100e+001
    4130,-1.937501046250e+000,-9.305836171767e+001,4.236074077523e+001
    4131,-1.937501046250e+000,-9.269705336824e+001,4.147717231582e+001
    4132,-1.937501046250e+000,-9.300715104435e+001,4.293989260652e+001
    4133,-1.937501046250e+000,-9.296879028701e+001,4.343288440859e+001
    4134,-1.937501046250e+000,-9.249831599456e+001,4.261047820445e+001
    4135,-1.937501046250e+000,-9.309027909384e+001,4.394957933303e+001
    4136,-1.937501046250e+000,-9.306910654081e+001,4.442813434734e+001
    4137,-1.937501046250e+000,-9.258169313278e+001,4.468145902013e+001
    4138,-1.937501046250e+000,-9.256859412808e+001,4.370632496018e+001
    4139,-1.937501046250e+000,-9.290932205570e+001,9.078585843471e+000
    4140,-1.937501046250e+000,-9.267188749485e+001,9.045965630749e+000
    4141,-1.937501046250e+000,-9.318113903275e+001,9.027435992064e+000
    4142,-1.937501046250e+000,-9.067121507504e+001,2.788772634184e+000
    4143,-1.937501046250e+000,-9.098802470753e+001,2.790413768344e+000
    4144,-1.937501046250e+000,-9.130404852177e+001,2.762517961884e+000
    4145,-1.937501046250e+000,-9.158797548127e+001,2.760962474218e+000
    4146,-1.937501046250e+000,-9.110603044296e+001,3.089027607149e+000
    4147,-1.937501046250e+000,-9.187624341752e+001,2.734982493683e+000
    4148,-1.937501046250e+000,-9.214729081901e+001,2.732795983158e+000
    4149,-1.937501046250e+000,-9.171032219345e+001,3.035151820154e+000
    4150,-1.937501046250e+000,-9.242574651011e+001,2.742570620894e+000
    4151,-1.937501046250e+000,-9.269386682849e+001,2.744284913471e+000
    4152,-1.937501046250e+000,-9.227704582080e+001,3.018946477354e+000
    4153,-1.937501046250e+000,-9.299203838403e+001,2.770185650425e+000
    4154,-1.937501046250e+000,-9.331042779608e+001,2.771334546769e+000
    4155,-1.937501046250e+000,-9.285367306743e+001,3.054621852045e+000
    4156,-1.937501046250e+000,-9.363871446067e+001,2.769167715239e+000
    4157,-1.937501046250e+000,-9.391191098401e+001,2.758367964022e+000
    4158,-1.937501046250e+000,-9.348013128756e+001,3.078355757469e+000
    4159,-1.937501046250e+000,-9.415804567588e+001,2.680683983294e+000
    4160,-1.937501046250e+000,-9.442677373968e+001,2.677459797690e+000
    4161,-1.937501046250e+000,-9.405455264403e+001,2.998504945211e+000
    4162,-1.937501046250e+000,-9.467747552206e+001,2.735720629187e+000
    4163,-1.937501046250e+000,-9.494062940428e+001,2.742879249766e+000
    4164,-1.937501046250e+000,-9.455138911827e+001,2.979081795979e+000
    4165,-1.937501046250e+000,-9.521130947874e+001,2.740245545294e+000
    4166,-1.937501046250e+000,-9.551732078182e+001,2.746572547055e+000
    4167,-1.937501046250e+000,-9.507277097511e+001,3.034708923003e+000
    4168,-1.937501046250e+000,-9.584677517328e+001,2.747425978314e+000
    4169,-1.937501046250e+000,-9.612881810879e+001,2.752133004038e+000
    4170,-1.937501046250e+000,-9.567290544103e+001,3.032928649790e+000
    4171,-1.937501046250e+000,-9.642435257154e+001,2.796715648724e+000
    4172,-1.937501046250e+000,-9.670910138045e+001,2.807085931784e+000
    4173,-1.937501046250e+000,-9.629789429524e+001,3.078364725735e+000
    4174,-1.937501046250e+000,-9.700810974057e+001,2.842318599438e+000
    4175,-1.937501046250e+000,-9.728609383650e+001,2.834523467053e+000
    4176,-1.937501046250e+000,-9.689243711811e+001,3.158180038076e+000
    4177,-1.937501046250e+000,-9.756048708112e+001,2.745275121396e+000
    4178,-1.937501046250e+000,-9.784828796997e+001,2.733628433183e+000
    4179,-1.937501046250e+000,-9.746583872285e+001,3.104164360073e+000
    4180,-1.937501046250e+000,-9.819142862877e+001,2.734954226777e+000
    4181,-1.937501046250e+000,-9.846203747133e+001,2.715032952824e+000
    4182,-1.937501046250e+000,-9.808337262628e+001,3.016241808010e+000
    4183,-1.937501046250e+000,-9.025796683506e+001,4.489048239505e+001
    4184,-1.937501046250e+000,-9.029405772312e+001,4.453407575956e+001
    4185,-1.937501046250e+000,-9.026943559270e+001,4.413216760355e+001
    4186,-1.937501046250e+000,-9.025878034147e+001,4.375890279839e+001
    4187,-1.937501046250e+000,-9.066128191240e+001,4.440787773138e+001
    4188,-1.937501046250e+000,-9.021194891406e+001,4.333391710604e+001
    4189,-1.937501046250e+000,-9.022988739562e+001,4.295662689442e+001
    4190,-1.937501046250e+000,-9.058982835457e+001,4.358098388302e+001
    4191,-1.937501046250e+000,-9.053210820538e+001,4.256912645716e+001
    4192,-1.937501046250e+000,-9.054448959644e+001,4.221458207372e+001
    4193,-1.937501046250e+000,-9.089158034328e+001,4.199989980887e+001
    4194,-1.937501046250e+000,-9.084521773690e+001,4.276849775341e+001
    4195,-1.937501046250e+000,-9.018162651595e+001,3.573773160567e+001
    4196,-1.937501046250e+000,-9.041780227835e+001,4.030339410933e+001
    4197,-1.937501046250e+000,-9.046155317743e+001,3.993204081896e+001
    4198,-1.937501046250e+000,-9.053202968111e+001,3.951283576082e+001
    4199,-1.937501046250e+000,-9.054260376415e+001,3.913306783239e+001
    4200,-1.937501046250e+000,-9.099441194090e+001,3.972398208455e+001
    4201,-1.937501046250e+000,-9.050703303179e+001,3.871426753023e+001
    4202,-1.937501046250e+000,-9.048848184502e+001,3.832070507919e+001
    4203,-1.937501046250e+000,-9.102931771222e+001,3.888597672426e+001
    4204,-1.937501046250e+000,-9.030584064468e+001,3.793231151032e+001
    4205,-1.937501046250e+000,-9.027142481919e+001,3.754880684896e+001
    4206,-1.937501046250e+000,-9.081110577952e+001,3.807878285323e+001
    4207,-1.937501046250e+000,-9.588634350973e+001,9.216169853295e+000
    4208,-1.937501046250e+000,-9.569845537842e+001,9.199971953676e+000
    4209,-1.937501046250e+000,-9.562171680519e+001,8.924938957423e+000
    4210,-1.937501046250e+000,-9.602690065295e+001,9.003385959358e+000
    4211,-1.937501046250e+000,-9.015954200410e+001,2.993715643932e+001
    4212,-1.937501046250e+000,-9.008522422649e+001,2.965166039400e+001
    4213,-1.937501046250e+000,-9.007166937179e+001,2.932014730950e+001
    4214,-1.937501046250e+000,-9.018135049099e+001,2.829024903938e+001
    4215,-1.937501046250e+000,-9.019828315028e+001,2.793386035608e+001
    4216,-1.937501046250e+000,-9.016614028440e+001,2.465390953417e+001
    4217,-1.937501046250e+000,-9.011148672055e+001,2.008501099718e+001
    4218,-1.937501046250e+000,-9.007469110689e+001,1.971976088141e+001
    4219,-1.937501046250e+000,-9.002744521083e+001,1.941760248587e+001
    4220,-1.937501046250e+000,-9.002234272512e+001,1.905692306068e+001
    4221,-1.937501046250e+000,-9.033481768909e+001,1.953448485521e+001
    4222,-1.937501046250e+000,-9.003697475046e+001,1.873144446033e+001
    4223,-1.937501046250e+000,-9.011793822497e+001,1.833528304431e+001
    4224,-1.937501046250e+000,-9.030220381837e+001,1.890684785932e+001
