    1409,-2.187501181250e+000,-9.031322092427e+001,3.520971781703e+001
    1410,-2.187501181250e+000,-9.034208929232e+001,3.383252468984e+001
    1411,-2.187501181250e+000,-9.032277720872e+001,3.214605343075e+001
    1412,-2.187501181250e+000,-9.033110095259e+001,3.094259516260e+001
    1413,-2.187501181250e+000,-9.002330484750e+001,2.926709892548e+001
    1414,-2.187501181250e+000,-9.021629813793e+001,2.782362463850e+001
    1415,-2.187501181250e+000,-9.023349816441e+001,2.623511429501e+001
    1416,-2.187501181250e+000,-9.011144185986e+001,2.489514814603e+001
    1417,-2.187501181250e+000,-9.030196982771e+001,2.327138983407e+001
    1418,-2.187501181250e+000,-9.007326954669e+001,2.184834201064e+001
    1419,-2.187501181250e+000,-9.023983994217e+001,2.058398821779e+001
    1420,-2.187501181250e+000,-9.007776243087e+001,1.889320402548e+001
    1421,-2.187501181250e+000,-9.023741235347e+001,1.752134212685e+001
    1422,-2.187501181250e+000,-9.009802460465e+001,1.603237914621e+001
    1423,-2.187501181250e+000,-9.028297464187e+001,1.449989716353e+001
    1424,-2.187501181250e+000,-9.028718432831e+001,1.310041969502e+001
    1425,-2.187501181250e+000,-9.028800546599e+001,1.169467825292e+001
    1426,-2.187501181250e+000,-9.031602813153e+001,1.012194634905e+001
    1427,-2.187501181250e+000,-9.014525470246e+001,8.638893008333e+000
    1428,-2.187501181250e+000,-9.020269749625e+001,7.203830730682e+000
    1429,-2.187501181250e+000,-9.014204659458e+001,5.718136074137e+000
    1430,-2.187501181250e+000,-9.010959596571e+001,4.224422884254e+000
    1431,-2.187501181250e+000,-9.001965853161e+001,2.743489713680e+000
    1432,-2.187501181250e+000,-9.633160881769e+001,9.478097796705e+000
    1433,-2.187501181250e+000,-9.671573627202e+001,9.650485570484e+000
    1434,-2.187501181250e+000,-9.697132170483e+001,1.001443894952e+001
    1435,-2.187501181250e+000,-9.711269517362e+001,1.041576394616e+001
    1436,-2.187501181250e+000,-9.186080268630e+001,9.351485291537e+000
    1437,-2.187501181250e+000,-9.233715669804e+001,9.294863742293e+000
    1438,-2.187501181250e+000,-9.285784142557e+001,9.266644428692e+000
    1439,-2.187501181250e+000,-9.347119640247e+001,9.281024490751e+000
    1440,-2.187501181250e+000,-9.404186006382e+001,9.291123250212e+000
    1441,-2.187501181250e+000,-9.458005356609e+001,9.318575998477e+000
    1442,-2.187501181250e+000,-9.511708752937e+001,9.355072563035e+000
    1443,-2.187501181250e+000,-9.559727189140e+001,9.374033654438e+000
    1444,-2.187501181250e+000,-9.597055726030e+001,9.417148755534e+000
    1445,-2.187501181250e+000,-9.076982648585e+001,1.029644706724e+001
    1446,-2.187501181250e+000,-9.086153934997e+001,9.954079497026e+000
    1447,-2.187501181250e+000,-9.116160511892e+001,9.666636579211e+000
    1448,-2.187501181250e+000,-9.149011859685e+001,9.474082711706e+000
    1449,-2.187501181250e+000,-9.071016692466e+001,1.686048900758e+001
    1450,-2.187501181250e+000,-9.060357724828e+001,1.649804812619e+001
    1451,-2.187501181250e+000,-9.056357344559e+001,1.498846218501e+001
    1452,-2.187501181250e+000,-9.030133920309e+001,1.243362088547e+001
    1453,-2.187501181250e+000,-9.061724519806e+001,1.115934563464e+001
    1454,-2.187501181250e+000,-9.063583773562e+001,1.061528344142e+001
    1455,-2.187501181250e+000,-9.150377263452e+001,1.804491049695e+001
    1456,-2.187501181250e+000,-9.116340433470e+001,1.787581468956e+001
    1457,-2.187501181250e+000,-9.085073749049e+001,1.756640095008e+001
    1458,-2.187501181250e+000,-9.069097117425e+001,1.719301932872e+001
    1459,-2.187501181250e+000,-9.510863974417e+001,1.810099164224e+001
    1460,-2.187501181250e+000,-9.472225373609e+001,1.812016990373e+001
    1461,-2.187501181250e+000,-9.432670345119e+001,1.805879290241e+001
    1462,-2.187501181250e+000,-9.384463206201e+001,1.816931939376e+001
    1463,-2.187501181250e+000,-9.278699952207e+001,1.820661300762e+001
    1464,-2.187501181250e+000,-9.228305407417e+001,1.820803206795e+001
    1465,-2.187501181250e+000,-9.186301145561e+001,1.814948464812e+001
    1466,-2.187501181250e+000,-9.615513853963e+001,1.735981237080e+001
    1467,-2.187501181250e+000,-9.597958434996e+001,1.779510826597e+001
    1468,-2.187501181250e+000,-9.550983155629e+001,1.802863289802e+001
    1469,-2.187501181250e+000,-9.711951056313e+001,1.081081579528e+001
    1470,-2.187501181250e+000,-9.665229542312e+001,1.619193335433e+001
    1471,-2.187501181250e+000,-9.627238997012e+001,1.699964946452e+001
    1472,-2.187501181250e+000,-9.503270150651e+001,2.637219332218e+001
    1473,-2.187501181250e+000,-9.477627718993e+001,2.684352520852e+001
    1474,-2.187501181250e+000,-9.427691049882e+001,2.700170899703e+001
    1475,-2.187501181250e+000,-9.578998683697e+001,2.079640803248e+001
    1476,-2.187501181250e+000,-9.571850039372e+001,2.116974985897e+001
    1477,-2.187501181250e+000,-9.573749829752e+001,2.160145123638e+001
    1478,-2.187501181250e+000,-9.561024331244e+001,2.470017079576e+001
    1479,-2.187501181250e+000,-9.541910562553e+001,2.532615788553e+001
    1480,-2.187501181250e+000,-9.513081407622e+001,2.571695789304e+001
    1481,-2.187501181250e+000,-9.504177616116e+001,2.603144255707e+001
    1482,-2.187501181250e+000,-9.498416772151e+001,1.951352950074e+001
    1483,-2.187501181250e+000,-9.536636404286e+001,1.969114921353e+001
    1484,-2.187501181250e+000,-9.563675786458e+001,2.003004186590e+001
    1485,-2.187501181250e+000,-9.575490235547e+001,2.041953266596e+001
    1486,-2.187501181250e+000,-9.188537296492e+001,1.938217686158e+001
    1487,-2.187501181250e+000,-9.226725087902e+001,1.931225214407e+001
    1488,-2.187501181250e+000,-9.277544835760e+001,1.928282940787e+001
    1489,-2.187501181250e+000,-9.380378885683e+001,1.933864576731e+001
    1490,-2.187501181250e+000,-9.426340262610e+001,1.940529429009e+001
    1491,-2.187501181250e+000,-9.463678834396e+001,1.944023520721e+001
    1492,-2.187501181250e+000,-9.069559106919e+001,2.031597200491e+001
    1493,-2.187501181250e+000,-9.078551661548e+001,1.987479637790e+001
    1494,-2.187501181250e+000,-9.116197976784e+001,1.957834667104e+001
    1495,-2.187501181250e+000,-9.154371242469e+001,1.944731817432e+001
    1496,-2.187501181250e+000,-9.062486705317e+001,2.587150690953e+001
    1497,-2.187501181250e+000,-9.057769377916e+001,2.542059130120e+001
    1498,-2.187501181250e+000,-9.064543775143e+001,2.497559305319e+001
    1499,-2.187501181250e+000,-9.027513040456e+001,2.399637160178e+001
    1500,-2.187501181250e+000,-9.057638048746e+001,2.201314972568e+001
    1501,-2.187501181250e+000,-9.061372911492e+001,2.096890966881e+001
    1502,-2.187501181250e+000,-9.071771470171e+001,2.063985548369e+001
    1503,-2.187501181250e+000,-9.154395841980e+001,2.699715406578e+001
    1504,-2.187501181250e+000,-9.116512747836e+001,2.688016379217e+001
    1505,-2.187501181250e+000,-9.077310956109e+001,2.659086087453e+001
    1506,-2.187501181250e+000,-9.073450354796e+001,2.618499538085e+001
    1507,-2.187501181250e+000,-9.392613135913e+001,2.704960176730e+001
    1508,-2.187501181250e+000,-9.355592591352e+001,2.709527338650e+001
    1509,-2.187501181250e+000,-9.310261200200e+001,2.719140545348e+001
    1510,-2.187501181250e+000,-9.265195542905e+001,2.716681923787e+001
    1511,-2.187501181250e+000,-9.222238994548e+001,2.707327973269e+001
    1512,-2.187501181250e+000,-9.185658411926e+001,2.702339703283e+001
    1513,-2.187501181250e+000,-9.363121686643e+001,3.634124189509e+001
    1514,-2.187501181250e+000,-9.345418533245e+001,3.665432801269e+001
    1515,-2.187501181250e+000,-9.317121884291e+001,3.688131430581e+001
    1516,-2.187501181250e+000,-9.286582929459e+001,3.699857086186e+001
    1517,-2.187501181250e+000,-9.453423113758e+001,2.973232678509e+001
    1518,-2.187501181250e+000,-9.453991990236e+001,3.009728068294e+001
    1519,-2.187501181250e+000,-9.427596707287e+001,3.464989857073e+001
    1520,-2.187501181250e+000,-9.406124282359e+001,3.521501611960e+001
    1521,-2.187501181250e+000,-9.371570078884e+001,3.605356400152e+001
    1522,-2.187501181250e+000,-9.376672214783e+001,2.851782318956e+001
    1523,-2.187501181250e+000,-9.411417918632e+001,2.865672264286e+001
    1524,-2.187501181250e+000,-9.443536501950e+001,2.894824921932e+001
    1525,-2.187501181250e+000,-9.454802460082e+001,2.936616880016e+001
    1526,-2.187501181250e+000,-9.193856993440e+001,2.842324756788e+001
    1527,-2.187501181250e+000,-9.243450265847e+001,2.835737125861e+001
    1528,-2.187501181250e+000,-9.295274141233e+001,2.835177964354e+001
    1529,-2.187501181250e+000,-9.340689451025e+001,2.844571711037e+001
    1530,-2.187501181250e+000,-9.076712626596e+001,2.925798258577e+001
    1531,-2.187501181250e+000,-9.090010976508e+001,2.889599572448e+001
    1532,-2.187501181250e+000,-9.119381345310e+001,2.862205810301e+001
    1533,-2.187501181250e+000,-9.155371666625e+001,2.848592364392e+001
    1534,-2.187501181250e+000,-9.067532057623e+001,3.574851421420e+001
    1535,-2.187501181250e+000,-9.030412414351e+001,3.450270592248e+001
    1536,-2.187501181250e+000,-9.034167664810e+001,3.278117469909e+001
    1537,-2.187501181250e+000,-9.044996896023e+001,3.039885711031e+001
    1538,-2.187501181250e+000,-9.070952397385e+001,2.957915034620e+001
    1539,-2.187501181250e+000,-9.151004315345e+001,3.701487049084e+001
    1540,-2.187501181250e+000,-9.115868890713e+001,3.688665136918e+001
    1541,-2.187501181250e+000,-9.085046972275e+001,3.656288480744e+001
    1542,-2.187501181250e+000,-9.068431686485e+001,3.617495794322e+001
    1543,-2.187501181250e+000,-9.256543108298e+001,3.704328305927e+001
    1544,-2.187501181250e+000,-9.220255627829e+001,3.705925529741e+001
    1545,-2.187501181250e+000,-9.184287225342e+001,3.705529094489e+001
    1546,-2.187501181250e+000,-9.786392120274e+001,6.534337926365e+000
    1547,-2.187501181250e+000,-9.843673836228e+001,4.601587060129e+000
    1548,-2.187501181250e+000,-9.789720211219e+001,8.410261588940e+000
    1549,-2.187501181250e+000,-9.765911034376e+001,1.050855040129e+001
    1550,-2.187501181250e+000,-9.686459253924e+001,1.472402586185e+001
    1551,-2.187501181250e+000,-9.682978316141e+001,1.686509375088e+001
    1552,-2.187501181250e+000,-9.658588555679e+001,1.821262686791e+001
    1553,-2.187501181250e+000,-9.646452372205e+001,2.003832296359e+001
    1554,-2.187501181250e+000,-9.623846585564e+001,2.123396583422e+001
    1555,-2.187501181250e+000,-9.566539593593e+001,2.393621131962e+001
    1556,-2.187501181250e+000,-9.548917448167e+001,2.671588606552e+001
    1557,-2.187501181250e+000,-9.517996661132e+001,2.832192030669e+001
    1558,-2.187501181250e+000,-9.509638001865e+001,3.030558549973e+001
    1559,-2.187501181250e+000,-9.432030135899e+001,3.392576464322e+001
    1560,-2.187501181250e+000,-9.422493062082e+001,3.688587253395e+001
    1561,-2.187501181250e+000,-9.365011586003e+001,3.854077703332e+001
    1562,-2.187501181250e+000,-9.362981823041e+001,4.029966921928e+001
    1563,-2.187501181250e+000,-9.324016372411e+001,4.219051895583e+001
    1564,-2.187501181250e+000,-9.301875154583e+001,4.425748384601e+001
    1565,-2.187501181250e+000,-9.317147695140e+001,4.580386237078e+001
    1566,-2.187501181250e+000,-9.018062475088e+001,4.428494593249e+001
    1567,-2.187501181250e+000,-9.214951239286e+001,4.618764907666e+001
    1568,-2.187501181250e+000,-9.093378055276e+001,4.621764469639e+001
    1569,-2.187501181250e+000,-9.000004207773e+001,4.576508114263e+001
    1570,-2.187501181250e+000,-9.021323973655e+001,4.277533375882e+001
    1571,-2.187501181250e+000,-9.019796454020e+001,4.041891696819e+001
    1572,-2.187501181250e+000,-9.037754213507e+001,3.900219644230e+001
    1573,-2.187501181250e+000,-9.022781341514e+001,3.739837817428e+001
    1574,-2.187501181250e+000,-9.016425044464e+001,3.595157608430e+001
    1575,-2.187501181250e+000,-9.031284094266e+001,3.154364215061e+001
    1576,-2.187501181250e+000,-9.002849741336e+001,2.991126337879e+001
    1577,-2.187501181250e+000,-9.008238429966e+001,2.856317445242e+001
    1578,-2.187501181250e+000,-9.016414784679e+001,2.693988810172e+001
    1579,-2.187501181250e+000,-9.009340058187e+001,2.561737372523e+001
    1580,-2.187501181250e+000,-9.030211481463e+001,2.254262130277e+001
    1581,-2.187501181250e+000,-9.007231948385e+001,2.117744542493e+001
    1582,-2.187501181250e+000,-9.015706559343e+001,1.957417748923e+001
    1583,-2.187501181250e+000,-9.010874068053e+001,1.822057060473e+001
    1584,-2.187501181250e+000,-9.021332614333e+001,1.685554057715e+001
    1585,-2.187501181250e+000,-9.005822124885e+001,1.521430287745e+001
    1586,-2.187501181250e+000,-9.029593331775e+001,1.381719710079e+001
    1587,-2.187501181250e+000,-9.011546446960e+001,1.085852884205e+001
    1588,-2.187501181250e+000,-9.013763039216e+001,9.348477880925e+000
    1589,-2.187501181250e+000,-9.018000390547e+001,7.940779807031e+000
    1590,-2.187501181250e+000,-9.021183985136e+001,6.453943145076e+000
    1591,-2.187501181250e+000,-9.010213846679e+001,4.959939179115e+000
    1592,-2.187501181250e+000,-9.009083927250e+001,3.460244628043e+000
    1593,-2.187501181250e+000,-9.054267913228e+001,1.549688142982e+001
    1594,-2.187501181250e+000,-9.332442744069e+001,1.820801570381e+001
    1595,-2.187501181250e+000,-9.636003078132e+001,1.662990658691e+001
    1596,-2.187501181250e+000,-9.330192041622e+001,1.929187249095e+001
    1597,-2.187501181250e+000,-9.059078532401e+001,2.452949282441e+001
    1598,-2.187501181250e+000,-9.054917283594e+001,2.149809081214e+001
    1599,-2.187501181250e+000,-9.453841903620e+001,3.054072108383e+001
    1600,-2.187501181250e+000,-9.047390417976e+001,3.330472018597e+001
    1601,-2.187501181250e+000,-9.061487287503e+001,2.993205438043e+001
    1602,-2.187501181250e+000,-9.722423352233e+001,3.178933245611e+000
    1603,-2.187501181250e+000,-9.659071378541e+001,3.016708925742e+000
    1604,-2.187501181250e+000,-9.599759255885e+001,2.947052031567e+000
    1605,-2.187501181250e+000,-9.534562349705e+001,2.947089975843e+000
    1606,-2.187501181250e+000,-9.478122047124e+001,2.981561939193e+000
    1607,-2.187501181250e+000,-9.421672107619e+001,3.038006507036e+000
    1608,-2.187501181250e+000,-9.364812226322e+001,3.004315561929e+000
    1609,-2.187501181250e+000,-9.296101470577e+001,2.995606177980e+000
    1610,-2.187501181250e+000,-9.239816382119e+001,2.999286570530e+000
    1611,-2.187501181250e+000,-9.183320921148e+001,2.954319694043e+000
    1612,-2.187501181250e+000,-9.130500054424e+001,2.862358074704e+000
    1613,-2.187501181250e+000,-9.754554263202e+001,4.257359840792e+000
    1614,-2.187501181250e+000,-9.210037171329e+001,4.118061869050e+001
    1615,-2.187501181250e+000,-9.452834381278e+001,2.786081093132e+001
    1616,-2.187501181250e+000,-9.697227333033e+001,8.204193691123e+000
    1617,-2.187501181250e+000,-9.264000649677e+001,3.969382763207e+001
    1618,-2.187501181250e+000,-9.323239910336e+001,3.778027572252e+001
    1619,-2.187501181250e+000,-9.188417533749e+001,4.553378799772e+001
    1620,-2.187501181250e+000,-9.211695258670e+001,4.354127948119e+001
    1621,-2.187501181250e+000,-9.256586375192e+001,4.565031683512e+001
    1622,-2.187501181250e+000,-9.101460032986e+001,4.324251914416e+001
    1623,-2.187501181250e+000,-9.078657639261e+001,4.489849211484e+001
    1624,-2.187501181250e+000,-9.098112115520e+001,4.075279132217e+001
    1625,-2.187501181250e+000,-9.154444546900e+001,3.858959434320e+001
    1626,-2.187501181250e+000,-9.115965459466e+001,4.416814589364e+001
    1627,-2.187501181250e+000,-9.095140221986e+001,4.155737253820e+001
    1628,-2.187501181250e+000,-9.132095832277e+001,4.239979903589e+001
    1629,-2.187501181250e+000,-9.067981058592e+001,1.862860342390e+001
    1630,-2.187501181250e+000,-9.096223135568e+001,7.656380698047e+000
    1631,-2.187501181250e+000,-9.103575012831e+001,6.045811823679e+000
    1632,-2.187501181250e+000,-9.106709000581e+001,6.877455188808e+000
    1633,-2.187501181250e+000,-9.070841881416e+001,8.990023178070e+000
    1634,-2.187501181250e+000,-9.085904148214e+001,4.565306830734e+000
    1635,-2.187501181250e+000,-9.063805667909e+001,3.028766796697e+000
    1636,-2.187501181250e+000,-9.677865813034e+001,9.068948310585e+000
    1637,-2.187501181250e+000,-9.682595070930e+001,7.090858265900e+000
    1638,-2.187501181250e+000,-9.261617548105e+001,8.690796627408e+000
    1639,-2.187501181250e+000,-9.320394342594e+001,8.715579744126e+000
    1640,-2.187501181250e+000,-9.385835301040e+001,8.766580012763e+000
    1641,-2.187501181250e+000,-9.442410035402e+001,8.787098297454e+000
    1642,-2.187501181250e+000,-9.488589384425e+001,8.929894807909e+000
    1643,-2.187501181250e+000,-9.537063385654e+001,8.897336450641e+000
    1644,-2.187501181250e+000,-9.067120088042e+001,9.565624100643e+000
    1645,-2.187501181250e+000,-9.365972535723e+001,1.874095241010e+001
    1646,-2.187501181250e+000,-9.068117115161e+001,1.802346201097e+001
    1647,-2.187501181250e+000,-9.431723410252e+001,1.854066533722e+001
    1648,-2.187501181250e+000,-9.641067405821e+001,1.765608209324e+001
    1649,-2.187501181250e+000,-9.596569710234e+001,1.836617190520e+001
    1650,-2.187501181250e+000,-9.653493830754e+001,1.727474847659e+001
    1651,-2.187501181250e+000,-9.589454450337e+001,1.959227059343e+001
    1652,-2.187501181250e+000,-9.251090612134e+001,1.875865308731e+001
    1653,-2.187501181250e+000,-9.029976723035e+001,2.008287518454e+001
    1654,-2.187501181250e+000,-9.072345228020e+001,1.929466006316e+001
    1655,-2.187501181250e+000,-9.122493880638e+001,2.730068217021e+001
    1656,-2.187501181250e+000,-9.070036375235e+001,2.720385822837e+001
    1657,-2.187501181250e+000,-9.337866619603e+001,2.755757845471e+001
    1658,-2.187501181250e+000,-9.280559724945e+001,2.777834571379e+001
    1659,-2.187501181250e+000,-9.231134932241e+001,2.751801320965e+001
    1660,-2.187501181250e+000,-9.408848454807e+001,2.823649210609e+001
    1661,-2.187501181250e+000,-9.360497526533e+001,3.712524468246e+001
    1662,-2.187501181250e+000,-9.307214012117e+001,1.874462384951e+001
    1663,-2.187501181250e+000,-9.068722124990e+001,2.840821565902e+001
    1664,-2.187501181250e+000,-9.108654352610e+001,3.752949829781e+001
    1665,-2.187501181250e+000,-9.201576126061e+001,3.745550941109e+001
    1666,-2.187501181250e+000,-9.057983359300e+001,4.564728304351e+001
    1667,-2.187501181250e+000,-9.683388242420e+001,5.784293515862e+000
    1668,-2.187501181250e+000,-9.738111155679e+001,1.006988119004e+001
    1669,-2.187501181250e+000,-9.084577709554e+001,8.394213042178e+000
    1670,-2.187501181250e+000,-9.540567101753e+001,1.843339078751e+001
    1671,-2.187501181250e+000,-9.165658980750e+001,2.732516101762e+001
    1672,-2.187501181250e+000,-9.460792847201e+001,2.730704989647e+001
    1673,-2.187501181250e+000,-9.416071441401e+001,2.740507653050e+001
    1674,-2.187501181250e+000,-9.535310330996e+001,1.929249185228e+001
    1675,-2.187501181250e+000,-9.602133485584e+001,2.015411249491e+001
    1676,-2.187501181250e+000,-9.118811981383e+001,1.900014919085e+001
    1677,-2.187501181250e+000,-9.164797255492e+001,1.904324265029e+001
    1678,-2.187501181250e+000,-9.380046491315e+001,3.666833989900e+001
    1679,-2.187501181250e+000,-9.380027948351e+001,2.738577305099e+001
    1680,-2.187501181250e+000,-9.313603121924e+001,3.724195246065e+001
    1681,-2.187501181250e+000,-9.280228191746e+001,3.740409151263e+001
    1682,-2.187501181250e+000,-9.046754458516e+001,2.894075084246e+001
    1683,-2.187501181250e+000,-9.487382769620e+001,2.986708336882e+001
    1684,-2.187501181250e+000,-9.046292473026e+001,2.932080272756e+001
    1685,-2.187501181250e+000,-9.458063730298e+001,2.848983930096e+001
    1686,-2.187501181250e+000,-9.498654656981e+001,2.904396359258e+001
    1687,-2.187501181250e+000,-9.161767889805e+001,3.737446874987e+001
    1688,-2.187501181250e+000,-9.231772105739e+001,4.250778863407e+001
    1689,-2.187501181250e+000,-9.069512107550e+001,3.700634130610e+001
    1690,-2.187501181250e+000,-9.241330738831e+001,3.738463773249e+001
    1691,-2.187501181250e+000,-9.113348348765e+001,1.835599325244e+001
    1692,-2.187501181250e+000,-9.792841041526e+001,3.173101696151e+000
    1693,-2.187501181250e+000,-9.198312963246e+001,2.730733394142e+001
    1694,-2.187501181250e+000,-9.783127001966e+001,9.743173646451e+000
    1695,-2.187501181250e+000,-9.225966289343e+001,4.469063617732e+001
    1696,-2.187501181250e+000,-9.118016605037e+001,4.558680285064e+001
    1697,-2.187501181250e+000,-9.487707430903e+001,1.857846257207e+001
    1698,-2.187501181250e+000,-9.124543627185e+001,3.976721960947e+001
    1699,-2.187501181250e+000,-9.036186794047e+001,2.961515070549e+001
    1700,-2.187501181250e+000,-9.198948598639e+001,8.785480814414e+000
    1701,-2.187501181250e+000,-9.200325209073e+001,1.880305835515e+001
    1702,-2.187501181250e+000,-9.076776511900e+001,5.314561783049e+000
    1703,-2.187501181250e+000,-9.074910877687e+001,3.811501559961e+000
    1704,-2.187501181250e+000,-9.142307873354e+001,8.921587378113e+000
    1705,-2.187501181250e+000,-9.085407023272e+001,2.780187210416e+001
    1706,-2.187501181250e+000,-9.624025484958e+001,9.096494263939e+000
    1707,-2.187501181250e+000,-9.108820413883e+001,9.294970461794e+000
    1708,-2.187501181250e+000,-9.585050301264e+001,8.968612346671e+000
    1709,-2.187501181250e+000,-9.155997440119e+001,1.855384882066e+001
    1710,-2.187501181250e+000,-9.122904337063e+001,2.819726173878e+001
    1711,-2.187501181250e+000,-9.452985533600e+001,1.902773179663e+001
    1712,-2.187501181250e+000,-9.369784523734e+001,2.820335511388e+001
    1713,-2.187501181250e+000,-9.332933042687e+001,2.800569487447e+001
    1714,-2.187501181250e+000,-9.169081303937e+001,2.810403364986e+001
    1715,-2.187501181250e+000,-9.721799782841e+001,9.569025198386e+000
    1716,-2.187501181250e+000,-9.490528183850e+001,1.912567115531e+001
    1717,-2.187501181250e+000,-9.620704329211e+001,2.057477036171e+001
    1718,-2.187501181250e+000,-9.406801192931e+001,3.631335603965e+001
    1719,-2.187501181250e+000,-9.484266622405e+001,2.952743672093e+001
    1720,-2.187501181250e+000,-9.219126634995e+001,2.798024925964e+001
    1721,-2.187501181250e+000,-9.624730918756e+001,3.485113879074e+000
    1722,-2.187501181250e+000,-9.568060682737e+001,3.565445190040e+000
    1723,-2.187501181250e+000,-9.510511947544e+001,3.517271847867e+000
    1724,-2.187501181250e+000,-9.455762676562e+001,3.790050155140e+000
    1725,-2.187501181250e+000,-9.391921878806e+001,3.815385497974e+000
    1726,-2.187501181250e+000,-9.328816318230e+001,3.585466914150e+000
    1727,-2.187501181250e+000,-9.268234379882e+001,3.669519375957e+000
    1728,-2.187501181250e+000,-9.203060904215e+001,3.620525576488e+000
    1729,-2.187501181250e+000,-9.137300532220e+001,3.451955136124e+000
    1730,-2.187501181250e+000,-9.186221272888e+001,2.766388423065e+001
    1731,-2.187501181250e+000,-9.270728212379e+001,3.854618401587e+001
    1732,-2.187501181250e+000,-9.148335600563e+001,4.493371369424e+001
    1733,-2.187501181250e+000,-9.300815539715e+001,7.978479974858e+000
    1734,-2.187501181250e+000,-9.574371919278e+001,1.891492768817e+001
    1735,-2.187501181250e+000,-9.525196177591e+001,1.884919937036e+001
    1736,-2.187501181250e+000,-9.388157640862e+001,2.779960400256e+001
    1737,-2.187501181250e+000,-9.364374158041e+001,8.172687776611e+000
    1738,-2.187501181250e+000,-9.433250126856e+001,8.112802477860e+000
    1739,-2.187501181250e+000,-9.679501712837e+001,3.825673680236e+000
    1740,-2.187501181250e+000,-9.411204559976e+001,1.900773036671e+001
    1741,-2.187501181250e+000,-9.142858364552e+001,2.773937204299e+001
    1742,-2.187501181250e+000,-9.594143631305e+001,7.784924805382e+000
    1743,-2.187501181250e+000,-9.571416276833e+001,6.600347919048e+000
    1744,-2.187501181250e+000,-9.156524854034e+001,8.205992512383e+000
    1745,-2.187501181250e+000,-9.543211768517e+001,5.463290038970e+000
    1746,-2.187501181250e+000,-9.240406485168e+001,3.792181418075e+001
    1747,-2.187501181250e+000,-9.628803888813e+001,8.558462265487e+000
    1748,-2.187501181250e+000,-9.228525065416e+001,7.999598912149e+000
    1749,-2.187501181250e+000,-9.156934510821e+001,4.211964371284e+000
    1750,-2.187501181250e+000,-9.203108642577e+001,6.338197941171e+000
    1751,-2.187501181250e+000,-9.504876926261e+001,8.279859791965e+000
    1752,-2.187501181250e+000,-9.570509486717e+001,8.463661378813e+000
    1753,-2.187501181250e+000,-9.181129293019e+001,7.378726972370e+000
    1754,-2.187501181250e+000,-9.171940743730e+001,3.785050865769e+001
    1755,-2.187501181250e+000,-9.530027876753e+001,4.434349079400e+000
    1756,-2.187501181250e+000,-9.426839768193e+001,4.842968039476e+000
    1757,-2.187501181250e+000,-9.329838861284e+001,4.435625770794e+000
    1758,-2.187501181250e+000,-9.240097471043e+001,4.452637590201e+000
    1759,-2.187501181250e+000,-9.063303868753e+001,1.603593214458e+001
    1760,-2.187501181250e+000,-9.179339931336e+001,5.197000653452e+000
    1761,-2.187501181250e+000,-9.282937588528e+001,6.966105043847e+000
    1762,-2.187501181250e+000,-9.384907806434e+001,7.406443588231e+000
    1763,-2.187501181250e+000,-9.488142781836e+001,7.381854739464e+000
    1764,-2.187501181250e+000,-9.640864263746e+001,4.787887082107e+000
    1765,-2.187501181250e+000,-9.433209792942e+001,6.213574859921e+000
    1766,-2.187501181250e+000,-9.307353303366e+001,5.514092299591e+000
    1767,-2.187501181250e+000,-9.610341887670e+001,4.082888590995e+000
    1768,-3.314261790140e+000,-9.398233413155e+001,4.597028933123e+001
    1769,-2.912937283969e+000,-9.423226807908e+001,4.409578472479e+001
    1770,-3.387317258642e+000,-9.439833520969e+001,4.285028124521e+001
    1771,-2.875839681427e+000,-9.460376599018e+001,4.130955039153e+001
    1772,-3.046334467187e+000,-9.480866004876e+001,3.977284495222e+001
    1773,-2.896410769868e+000,-9.501584425244e+001,3.821896342458e+001
    1774,-3.019515070759e+000,-9.521550638307e+001,3.672149744488e+001
    1775,-2.929568588333e+000,-9.543845081954e+001,3.504941417135e+001
    1776,-3.332038212044e+000,-9.560947531744e+001,3.376673043709e+001
    1777,-2.950938766273e+000,-9.582358518524e+001,3.216090642860e+001
    1778,-2.876132912841e+000,-9.604287003506e+001,3.051627005497e+001
    1779,-3.363637106546e+000,-9.624214368329e+001,2.902171769324e+001
    1780,-2.712678378425e+000,-9.644726120925e+001,2.748333624855e+001
    1781,-3.270898621873e+000,-9.664850787223e+001,2.597398627617e+001
    1782,-3.339311046051e+000,-9.676025291260e+001,2.513589847339e+001
    1783,-2.979074023753e+000,-9.697692337349e+001,2.351087001673e+001
    1784,-3.329149838429e+000,-9.718254346230e+001,2.196871935063e+001
    1785,-2.983701605142e+000,-9.738465635804e+001,2.045287263258e+001
    1786,-3.308531875906e+000,-9.758229657331e+001,1.897057101806e+001
    1787,-3.324294087448e+000,-9.775128678512e+001,1.770314442952e+001
    1788,-2.904947017730e+000,-9.799752214915e+001,1.585637919924e+001
    1789,-3.329704920092e+000,-9.820647616899e+001,1.428922405051e+001
    1790,-3.001410440423e+000,-9.842150441254e+001,1.267651222387e+001
    1791,-2.674524958145e+000,-9.863510376706e+001,1.107451706495e+001
    1792,-3.343532398927e+000,-9.881384353306e+001,9.733968819959e+000
    1793,-2.963268426461e+000,-9.904248821449e+001,8.019133709199e+000
    1794,-2.898297340429e+000,-9.925494240929e+001,6.425727248208e+000
    1795,-2.966163770148e+000,-9.947109664894e+001,4.804570450881e+000
    1796,-3.328162722824e+000,-9.967936460734e+001,3.242560762811e+000
    1797,-3.277559625836e+000,-9.977198896954e+001,2.547878046358e+000
    1798,-2.920205350330e+000,-9.959059190335e+001,3.908356042756e+000
    1799,-2.599387334467e+000,-9.877427039918e+001,1.003076732401e+001
    1800,-2.617767586444e+000,-9.819877395677e+001,1.434699064214e+001
    1801,-2.595452611460e+000,-9.778301092130e+001,1.746521340815e+001
    1802,-2.558290650632e+000,-9.755985197611e+001,1.913890549703e+001
    1803,-2.586568959783e+000,-9.716365103309e+001,2.211041256972e+001
    1804,-2.603441833550e+000,-9.673104680534e+001,2.535494427783e+001
    1805,-2.603591713169e+000,-9.660428050012e+001,2.630569156701e+001
    1806,-2.655781194034e+000,-9.623952003673e+001,2.904139504245e+001
    1807,-2.629758481097e+000,-9.557036499577e+001,3.406005784961e+001
    1808,-2.683438094052e+000,-9.438206776047e+001,4.297228711440e+001
    1809,-2.587346229597e+000,-9.400991705823e+001,4.576341738114e+001
    1810,-2.416781418226e+000,-9.393164964084e+001,4.635042301162e+001
    1811,-2.924422940014e+000,-9.410299340189e+001,4.506534480374e+001
    1812,-3.353538605343e+000,-9.431339162692e+001,4.348735811599e+001
    1813,-3.122577625006e+000,-9.448850638740e+001,4.217399741242e+001
    1814,-3.167794732045e+000,-9.470722625189e+001,4.053359842871e+001
    1815,-3.172906013165e+000,-9.491544799749e+001,3.897193533670e+001
    1816,-3.170015885026e+000,-9.511815972193e+001,3.745159740339e+001
    1817,-2.970444910079e+000,-9.532084712560e+001,3.593144187586e+001
    1818,-3.353561907153e+000,-9.552369388068e+001,3.441009121278e+001
    1819,-2.893498304803e+000,-9.570788617207e+001,3.302864902736e+001
    1820,-3.104514948672e+000,-9.592914342935e+001,3.136921959778e+001
    1821,-3.137321934658e+000,-9.615135121691e+001,2.970266119108e+001
    1822,-3.085585681652e+000,-9.633521933853e+001,2.832365027895e+001
    1823,-3.305348563176e+000,-9.652683811641e+001,2.688650944479e+001
    1824,-2.937920634455e+000,-9.686083776244e+001,2.438151209958e+001
    1825,-3.133829316882e+000,-9.707736401418e+001,2.275756521157e+001
    1826,-2.948219804947e+000,-9.727471326188e+001,2.127744585380e+001
    1827,-3.147083515183e+000,-9.748463713575e+001,1.970301679978e+001
    1828,-2.768605771124e+000,-9.766774081470e+001,1.832973920766e+001
    1829,-3.102678641526e+000,-9.787391163837e+001,1.678345803016e+001
    1830,-3.144576385654e+000,-9.811142665090e+001,1.500209543614e+001
    1831,-2.920976627627e+000,-9.830924584694e+001,1.351845146582e+001
    1832,-3.117605340476e+000,-9.852422175470e+001,1.190613215765e+001
    1833,-3.298262966176e+000,-9.870516987495e+001,1.054902125574e+001
    1834,-2.927615797372e+000,-9.891761938533e+001,8.955649927918e+000
    1835,-3.168485639327e+000,-9.914905288263e+001,7.219898698166e+000
    1836,-3.153509190792e+000,-9.935744252514e+001,5.656976379364e+000
    1837,-2.607497841607e+000,-9.972979459875e+001,2.864335827264e+000
    1838,-2.901048753863e+000,-9.393497691733e+001,4.632546843793e+001
    1839,-3.296723009316e+000,-9.939737101436e+001,2.520121312327e+000
    1840,-2.656338850147e+000,-9.941407203102e+001,2.394863687376e+000
    1841,-3.172275976721e+000,-9.358117973089e+001,4.614155593835e+001
    1842,-3.017332409752e+000,-9.369479986775e+001,4.528940491191e+001
    1843,-3.096097771265e+000,-9.381863438525e+001,4.436064603061e+001
    1844,-3.133514909313e+000,-9.392967711063e+001,4.352782559027e+001
    1845,-3.245241774724e+000,-9.403404021694e+001,4.274510229295e+001
    1846,-3.071759637644e+000,-9.413736916087e+001,4.197013521349e+001
    1847,-3.258121400233e+000,-9.424256513195e+001,4.118116543040e+001
    1848,-3.111934461764e+000,-9.433856468809e+001,4.046116875933e+001
    1849,-3.104667653018e+000,-9.445277560217e+001,3.960458690372e+001
    1850,-3.133867643415e+000,-9.455944148223e+001,3.880459280325e+001
    1851,-3.273436810050e+000,-9.465284595443e+001,3.810405926177e+001
    1852,-3.102030693931e+000,-9.474419336051e+001,3.741895371621e+001
    1853,-3.091075826895e+000,-9.484524356927e+001,3.666107715051e+001
    1854,-3.117557503847e+000,-9.495065081971e+001,3.587052277216e+001
    1855,-3.103570602668e+000,-9.505753773770e+001,3.506887088724e+001
    1856,-3.108759024818e+000,-9.516435297546e+001,3.426775660404e+001
    1857,-3.260945914224e+000,-9.526208274688e+001,3.353478331838e+001
    1858,-3.128777408282e+000,-9.535430376620e+001,3.284312567352e+001
    1859,-3.095498082176e+000,-9.545873856115e+001,3.205986471139e+001
    1860,-3.072177340543e+000,-9.557197960679e+001,3.121055686905e+001
    1861,-3.065114597190e+000,-9.568359171788e+001,3.037346603587e+001
    1862,-3.044778885566e+000,-9.578741078023e+001,2.959482306826e+001
    1863,-3.072488802616e+000,-9.588982826977e+001,2.882669189671e+001
    1864,-3.118532546506e+000,-9.600290014109e+001,2.797865286179e+001
    1865,-3.269750902077e+000,-9.609515598513e+001,2.728673403149e+001
    1866,-3.088756142928e+000,-9.618688719575e+001,2.659874995184e+001
    1867,-3.059453022124e+000,-9.628345053147e+001,2.587452493401e+001
    1868,-3.058987269869e+000,-9.639982027674e+001,2.500175184442e+001
    1869,-3.094050214216e+000,-9.650595651106e+001,2.420573008706e+001
    1870,-3.118364471661e+000,-9.661075025380e+001,2.341977701652e+001
    1871,-3.243434979757e+000,-9.670450832285e+001,2.271659149861e+001
    1872,-3.112178020066e+000,-9.680359437995e+001,2.197344607039e+001
    1873,-3.091796433182e+000,-9.690813820181e+001,2.118936740646e+001
    1874,-3.078243792343e+000,-9.700828336146e+001,2.043827870907e+001
    1875,-3.224966242616e+000,-9.710477779943e+001,1.971457042429e+001
    1876,-3.054573881173e+000,-9.721193385582e+001,1.891090000134e+001
    1877,-3.246880856418e+000,-9.731696179838e+001,1.812319043215e+001
    1878,-3.066775929658e+000,-9.741395800425e+001,1.739571888815e+001
    1879,-3.038428771398e+000,-9.751857155494e+001,1.661111725796e+001
    1880,-3.097328848929e+000,-9.763037832571e+001,1.577256647716e+001
    1881,-3.121673825633e+000,-9.773860181349e+001,1.496089031881e+001
    1882,-3.107091254106e+000,-9.785049274280e+001,1.412170834902e+001
    1883,-3.135144908479e+000,-9.796146901123e+001,1.328938633581e+001
    1884,-3.285980548012e+000,-9.805250138425e+001,1.260664353811e+001
    1885,-3.137014451159e+000,-9.814376186694e+001,1.192218991798e+001
    1886,-3.077948041228e+000,-9.824518044119e+001,1.116155061110e+001
    1887,-3.115381545854e+000,-9.835154136816e+001,1.036384365877e+001
    1888,-3.102666103570e+000,-9.845775410229e+001,9.567248152811e+000
    1889,-3.094120355223e+000,-9.856506550476e+001,8.762412634319e+000
    1890,-3.099942299761e+000,-9.867667482973e+001,7.925342697027e+000
    1891,-3.279228333117e+000,-9.877144702942e+001,7.214551199379e+000
    1892,-3.137966153131e+000,-9.886586870833e+001,6.506388607504e+000
    1893,-3.093429825633e+000,-9.897000758924e+001,5.725347000716e+000
    1894,-3.110195797533e+000,-9.909071895643e+001,4.820011746771e+000
    1895,-3.064058724919e+000,-9.921127992156e+001,3.915804508263e+000
    1896,-3.382855636035e+000,-9.929642738051e+001,3.277198566172e+000
    1897,-2.550410080534e+000,-9.354928053137e+001,4.638079993471e+001
    1898,-2.752580011313e+000,-9.933555289196e+001,2.983757230275e+000
    1899,-2.614902915884e+000,-9.361086296326e+001,4.591893169557e+001
    1900,-2.949061294268e+000,-8.950004833000e+001,2.435002043812e+000
    1901,-2.745242882371e+000,-8.950004833000e+001,4.561776483044e+001
    1902,-2.849752672616e+000,-8.950004833000e+001,4.493281816386e+001
    1903,-2.780313685784e+000,-8.950004833000e+001,4.418649115501e+001
    1904,-2.850832939155e+000,-8.950004833000e+001,4.339476044538e+001
    1905,-2.769342444006e+000,-8.950004833000e+001,4.267946290787e+001
    1906,-2.754160614648e+000,-8.950004833000e+001,4.199256866000e+001
    1907,-2.757845794183e+000,-8.950004833000e+001,4.127585684360e+001
    1908,-2.853280273237e+000,-8.950004833000e+001,4.052871824111e+001
    1909,-2.788227657601e+000,-8.950004833000e+001,3.974261595392e+001
    1910,-2.844944716818e+000,-8.950004833000e+001,3.897166086978e+001
    1911,-2.785364475983e+000,-8.950004833000e+001,3.819964493141e+001
    1912,-2.773380338576e+000,-8.950004833000e+001,3.746627518416e+001
    1913,-2.840370685115e+000,-8.950004833000e+001,3.671889681580e+001
    1914,-2.780523130457e+000,-8.950004833000e+001,3.593369035805e+001
    1915,-2.845562027100e+000,-8.950004833000e+001,3.513580334258e+001
    1916,-2.781783717589e+000,-8.950004833000e+001,3.433566587406e+001
    1917,-2.778921444055e+000,-8.950004833000e+001,3.366520744279e+001
    1918,-2.856704939548e+000,-8.950004833000e+001,3.290796373629e+001
    1919,-2.773542650680e+000,-8.950004833000e+001,3.217072892416e+001
    1920,-2.763500307659e+000,-8.950004833000e+001,3.147043931590e+001
    1921,-2.780850734676e+000,-8.950004833000e+001,3.081458709568e+001
    1922,-2.853047097192e+000,-8.950004833000e+001,3.003117876984e+001
    1923,-2.786716734956e+000,-8.950004833000e+001,2.925009319450e+001
    1924,-2.845443476553e+000,-8.950004833000e+001,2.848996122191e+001
    1925,-2.769931849148e+000,-8.950004833000e+001,2.774940848508e+001
    1926,-2.777300676182e+000,-8.950004833000e+001,2.702708159967e+001
    1927,-2.849751975593e+000,-8.950004833000e+001,2.627866075573e+001
    1928,-2.770695714097e+000,-8.950004833000e+001,2.550716808635e+001
    1929,-2.771443102302e+000,-8.950004833000e+001,2.483418713332e+001
    1930,-2.847887161137e+000,-8.950004833000e+001,2.406707217986e+001
    1931,-2.768475988058e+000,-8.950004833000e+001,2.327502861045e+001
    1932,-2.774823639167e+000,-8.950004833000e+001,2.259444895924e+001
    1933,-2.845329764405e+000,-8.950004833000e+001,2.186823147746e+001
    1934,-2.766099654638e+000,-8.950004833000e+001,2.110262204256e+001
    1935,-2.772752605654e+000,-8.950004833000e+001,2.038692758775e+001
    1936,-2.846566203397e+000,-8.950004833000e+001,1.960717323174e+001
    1937,-2.784561525282e+000,-8.950004833000e+001,1.885628821885e+001
    1938,-2.851829248850e+000,-8.950004833000e+001,1.809657153797e+001
    1939,-2.779299247541e+000,-8.950004833000e+001,1.734278779473e+001
    1940,-2.765987659118e+000,-8.950004833000e+001,1.662499063063e+001
    1941,-2.774215165090e+000,-8.950004833000e+001,1.594284906863e+001
    1942,-2.846759512197e+000,-8.950004833000e+001,1.521075273084e+001
    1943,-2.773133243405e+000,-8.950004833000e+001,1.449849695856e+001
    1944,-2.765489401580e+000,-8.950004833000e+001,1.378860970150e+001
    1945,-2.779586569350e+000,-8.950004833000e+001,1.306769002751e+001
    1946,-2.849025987431e+000,-8.950004833000e+001,1.233506080800e+001
    1947,-2.774785315685e+000,-8.950004833000e+001,1.159155761204e+001
    1948,-2.767015995032e+000,-8.950004833000e+001,1.089641238457e+001
    1949,-2.850283098418e+000,-8.950004833000e+001,1.010934195032e+001
    1950,-2.774567054785e+000,-8.950004833000e+001,9.317531508814e+000
    1951,-2.847742282886e+000,-8.950004833000e+001,8.554441560245e+000
    1952,-2.778656173078e+000,-8.950004833000e+001,7.805363727810e+000
    1953,-2.844364668746e+000,-8.950004833000e+001,7.032015856778e+000
    1954,-2.774868058372e+000,-8.950004833000e+001,6.293409951037e+000
    1955,-2.762241926837e+000,-8.950004833000e+001,5.619401189314e+000
    1956,-2.755590736835e+000,-8.950004833000e+001,4.959776790617e+000
    1957,-2.759790835231e+000,-8.950004833000e+001,4.287762681769e+000
    1958,-2.786152366163e+000,-8.950004833000e+001,3.563842643534e+000
    1959,-3.238165342609e+000,-8.950004833000e+001,4.618624894727e+001
    1960,-3.466783674614e+000,-8.950004833000e+001,2.531054848301e+000
    1961,-3.564231806928e+000,-8.950004833000e+001,3.023092301481e+000
    1962,-3.433439252236e+000,-8.950004833000e+001,3.485340579322e+000
    1963,-3.360201883614e+000,-8.950004833000e+001,4.063138113402e+000
    1964,-3.353578515851e+000,-8.950004833000e+001,4.652907775551e+000
    1965,-3.355156960506e+000,-8.950004833000e+001,5.245769993019e+000
    1966,-3.362050919414e+000,-8.950004833000e+001,5.841047507141e+000
    1967,-3.376502050026e+000,-8.950004833000e+001,6.419193160736e+000
    1968,-3.473361994349e+000,-8.950004833000e+001,6.923106323320e+000
    1969,-3.378616649436e+000,-8.950004833000e+001,7.445086851595e+000
    1970,-3.377489876827e+000,-8.950004833000e+001,8.010388758134e+000
    1971,-3.477702400706e+000,-8.950004833000e+001,8.522600682107e+000
    1972,-3.377057070188e+000,-8.950004833000e+001,9.042885844467e+000
    1973,-3.377686212906e+000,-8.950004833000e+001,9.612027792717e+000
    1974,-3.472524146024e+000,-8.950004833000e+001,1.013220100972e+001
    1975,-3.377403233840e+000,-8.950004833000e+001,1.065362024019e+001
    1976,-3.364547227893e+000,-8.950004833000e+001,1.124230173016e+001
    1977,-3.377744584524e+000,-8.950004833000e+001,1.183207531323e+001
    1978,-3.480794720061e+000,-8.950004833000e+001,1.236318969721e+001
    1979,-3.378842052520e+000,-8.950004833000e+001,1.288934396699e+001
    1980,-3.371175216350e+000,-8.950004833000e+001,1.347799762580e+001
    1981,-3.371411248848e+000,-8.950004833000e+001,1.407431165430e+001
    1982,-3.381509515974e+000,-8.950004833000e+001,1.466073803952e+001
    1983,-3.472828061519e+000,-8.950004833000e+001,1.517732168125e+001
    1984,-3.381144831999e+000,-8.950004833000e+001,1.570271773162e+001
    1985,-3.361397749725e+000,-8.950004833000e+001,1.629145284899e+001
    1986,-3.369521211637e+000,-8.950004833000e+001,1.689228131648e+001
    1987,-3.382720432404e+000,-8.950004833000e+001,1.748356766616e+001
    1988,-3.479375996170e+000,-8.950004833000e+001,1.800226802419e+001
    1989,-3.382440903592e+000,-8.950004833000e+001,1.853201349338e+001
    1990,-3.383653198633e+000,-8.950004833000e+001,1.910780521389e+001
    1991,-3.472341584762e+000,-8.950004833000e+001,1.963221280789e+001
    1992,-3.382414359381e+000,-8.950004833000e+001,2.015974278462e+001
    1993,-3.362938439217e+000,-8.950004833000e+001,2.074866213635e+001
    1994,-3.378117654595e+000,-8.950004833000e+001,2.132951605434e+001
    1995,-3.472083802646e+000,-8.950004833000e+001,2.184717827959e+001
    1996,-3.381363788972e+000,-8.950004833000e+001,2.237024829795e+001
    1997,-3.364206477083e+000,-8.950004833000e+001,2.295341361816e+001
    1998,-3.390181905074e+000,-8.950004833000e+001,2.353935287414e+001
    1999,-3.473851978808e+000,-8.950004833000e+001,2.406898621861e+001
    2000,-3.385354993410e+000,-8.950004833000e+001,2.459115637354e+001
    2001,-3.367595633354e+000,-8.950004833000e+001,2.517259149076e+001
    2002,-3.380352682489e+000,-8.950004833000e+001,2.575378950841e+001
    2003,-3.473252014654e+000,-8.950004833000e+001,2.627187878173e+001
    2004,-3.376297885414e+000,-8.950004833000e+001,2.678791836166e+001
    2005,-3.362534022406e+000,-8.950004833000e+001,2.736629402527e+001
    2006,-3.374030242256e+000,-8.950004833000e+001,2.794556978440e+001
    2007,-3.476314248020e+000,-8.950004833000e+001,2.846231989654e+001
    2008,-3.380952598034e+000,-8.950004833000e+001,2.898366843016e+001
    2009,-3.391455899427e+000,-8.950004833000e+001,2.955978512794e+001
    2010,-3.476435832372e+000,-8.950004833000e+001,3.008981832319e+001
    2011,-3.388363211905e+000,-8.950004833000e+001,3.060832151351e+001
    2012,-3.364816396170e+000,-8.950004833000e+001,3.118342770742e+001
    2013,-3.372148866470e+000,-8.950004833000e+001,3.176943858660e+001
    2014,-3.389558114098e+000,-8.950004833000e+001,3.234664331707e+001
    2015,-3.481551781529e+000,-8.950004833000e+001,3.286650583698e+001
    2016,-3.395200136103e+000,-8.950004833000e+001,3.340086377563e+001
    2017,-3.369013498061e+000,-8.950004833000e+001,3.398493907178e+001
    2018,-3.386720312127e+000,-8.950004833000e+001,3.456356727947e+001
    2019,-3.473007839095e+000,-8.950004833000e+001,3.508447174700e+001
    2020,-3.386623258244e+000,-8.950004833000e+001,3.561620912094e+001
    2021,-3.378399221048e+000,-8.950004833000e+001,3.619482614425e+001
    2022,-3.470523814230e+000,-8.950004833000e+001,3.671334096072e+001
    2023,-3.374249533289e+000,-8.950004833000e+001,3.723014260384e+001
    2024,-3.363942897994e+000,-8.950004833000e+001,3.781273540814e+001
    2025,-3.378212849499e+000,-8.950004833000e+001,3.840510037486e+001
    2026,-3.470813813595e+000,-8.950004833000e+001,3.892992942356e+001
    2027,-3.383453403080e+000,-8.950004833000e+001,3.945890791050e+001
    2028,-3.379551183556e+000,-8.950004833000e+001,4.003993204652e+001
    2029,-3.477034653972e+000,-8.950004833000e+001,4.056823372284e+001
    2030,-3.370201730046e+000,-8.950004833000e+001,4.108787947926e+001
    2031,-3.354229273123e+000,-8.950004833000e+001,4.167225123593e+001
    2032,-3.355431335369e+000,-8.950004833000e+001,4.226638209936e+001
    2033,-3.379150559077e+000,-8.950004833000e+001,4.284890253603e+001
    2034,-3.474318706798e+000,-8.950004833000e+001,4.336547993877e+001
    2035,-3.391975623700e+000,-8.950004833000e+001,4.389343420566e+001
    2036,-3.380884788401e+000,-8.950004833000e+001,4.446722695935e+001
    2037,-3.469558479671e+000,-8.950004833000e+001,4.498955318313e+001
    2038,-3.357157840880e+000,-8.950004833000e+001,4.551590498789e+001
    2039,-2.622830393186e+000,-8.950004833000e+001,2.903527178207e+000
    2040,-3.126949080217e+000,-8.950004833000e+001,2.992097489347e+000
    2041,-2.636855442384e+000,-8.925004819500e+001,4.561205548810e+001
    2042,-2.572607899249e+000,-8.925004819500e+001,4.424350197439e+001
    2043,-2.697049572021e+000,-8.925004819500e+001,4.281297418245e+001
    2044,-2.699551978617e+000,-8.925004819500e+001,4.116718626145e+001
    2045,-2.578172954489e+000,-8.925004819500e+001,3.971435554610e+001
    2046,-2.709706115874e+000,-8.925004819500e+001,3.820607235366e+001
    2047,-2.580559846994e+000,-8.925004819500e+001,3.672452096183e+001
    2048,-2.609854099118e+000,-8.925004819500e+001,3.528056606256e+001
    2049,-2.608780993224e+000,-8.925004819500e+001,3.369930862922e+001
    2050,-2.579485052999e+000,-8.925004819500e+001,3.216874707772e+001
    2051,-2.591021956059e+000,-8.925004819500e+001,3.077794727982e+001
    2052,-2.706010952709e+000,-8.925004819500e+001,2.925595478960e+001
    2053,-2.600759690719e+000,-8.925004819500e+001,2.780157598112e+001
    2054,-2.605659893647e+000,-8.925004819500e+001,2.623187424195e+001
    2055,-2.586023793956e+000,-8.925004819500e+001,2.481190051599e+001
    2056,-2.586387970144e+000,-8.925004819500e+001,2.323920230260e+001
    2057,-2.587619224111e+000,-8.925004819500e+001,2.185484025201e+001
    2058,-2.606990661399e+000,-8.925004819500e+001,2.031254823556e+001
    2059,-2.593491056800e+000,-8.925004819500e+001,1.889838014065e+001
    2060,-2.598729156723e+000,-8.925004819500e+001,1.739005524167e+001
    2061,-2.594322848426e+000,-8.925004819500e+001,1.594505356830e+001
    2062,-2.590857714942e+000,-8.925004819500e+001,1.446425803509e+001
    2063,-2.592519011635e+000,-8.925004819500e+001,1.300476896191e+001
    2064,-2.596884686585e+000,-8.925004819500e+001,1.150384383314e+001
    2065,-2.712006088329e+000,-8.925004819500e+001,9.965115927014e+000
    2066,-2.574934395197e+000,-8.925004819500e+001,8.506493851283e+000
    2067,-2.596686856239e+000,-8.925004819500e+001,7.134100204463e+000
    2068,-2.592302428609e+000,-8.925004819500e+001,5.610851633308e+000
    2069,-2.571930011739e+000,-8.925004819500e+001,4.238619376336e+000
    2070,-2.653414594103e+000,-8.925004819500e+001,2.819440571774e+000
    2071,-3.060188856465e+000,-8.925004819500e+001,2.407103458089e+000
    2072,-3.378046779086e+000,-8.925004819500e+001,2.174813716522e+000
    2073,-3.567630420883e+000,-8.925004819500e+001,2.438866011167e+000
    2074,-3.313772920260e+000,-8.925004819500e+001,3.329478037107e+000
    2075,-3.273955223740e+000,-8.925004819500e+001,4.568261826160e+000
    2076,-3.306221404084e+000,-8.925004819500e+001,5.790620065563e+000
    2077,-3.313117901850e+000,-8.925004819500e+001,6.887125363671e+000
    2078,-3.275254974815e+000,-8.925004819500e+001,8.126060913670e+000
    2079,-3.307085734132e+000,-8.925004819500e+001,9.352199720319e+000
    2080,-3.321254168625e+000,-8.925004819500e+001,1.046138085630e+001
    2081,-3.308626741442e+000,-8.925004819500e+001,1.169268011317e+001
    2082,-3.309329791929e+000,-8.925004819500e+001,1.278029463265e+001
    2083,-3.297845797853e+000,-8.925004819500e+001,1.402842470440e+001
    2084,-3.422060284453e+000,-8.925004819500e+001,1.518465246945e+001
    2085,-3.284251572012e+000,-8.925004819500e+001,1.633572362456e+001
    2086,-3.319437323743e+000,-8.925004819500e+001,1.758283390210e+001
    2087,-3.308640621482e+000,-8.925004819500e+001,1.868112781654e+001
    2088,-3.283334073385e+000,-8.925004819500e+001,1.990926674526e+001
    2089,-3.426450067012e+000,-8.925004819500e+001,2.107735674374e+001
    2090,-3.281216440639e+000,-8.925004819500e+001,2.224045925893e+001
    2091,-3.316272799085e+000,-8.925004819500e+001,2.346912068793e+001
    2092,-3.321445644791e+000,-8.925004819500e+001,2.457952011039e+001
    2093,-3.290023145946e+000,-8.925004819500e+001,2.581868088033e+001
    2094,-3.425833561145e+000,-8.925004819500e+001,2.697596328439e+001
    2095,-3.296658042293e+000,-8.925004819500e+001,2.814886028142e+001
    2096,-3.426270735246e+000,-8.925004819500e+001,2.931340066875e+001
    2097,-3.298142095759e+000,-8.925004819500e+001,3.047189918622e+001
    2098,-3.296026128939e+000,-8.925004819500e+001,3.173321216310e+001
    2099,-3.424387004175e+000,-8.925004819500e+001,3.289078493406e+001
    2100,-3.320726852203e+000,-8.925004819500e+001,3.403558815951e+001
    2101,-3.313443379002e+000,-8.925004819500e+001,3.513841393535e+001
    2102,-3.281593629032e+000,-8.925004819500e+001,3.639498156228e+001
    2103,-3.306321598176e+000,-8.925004819500e+001,3.763618082804e+001
    2104,-3.310634817671e+000,-8.925004819500e+001,3.874614963781e+001
    2105,-3.281200825332e+000,-8.925004819500e+001,3.999409456589e+001
    2106,-3.422217907325e+000,-8.925004819500e+001,4.114622372411e+001
    2107,-3.322512542898e+000,-8.925004819500e+001,4.231910033398e+001
    2108,-3.308760149539e+000,-8.925004819500e+001,4.341173822630e+001
    2109,-3.285333498255e+000,-8.925004819500e+001,4.463497777037e+001
    2110,-3.361914935123e+000,-8.925004819500e+001,4.591234648557e+001
    2111,-3.281511191286e+000,-8.925004819500e+001,4.639956104948e+001
    2112,-2.599711147527e+000,-8.925004819500e+001,4.491701967981e+001
    2113,-2.590275152658e+000,-8.925004819500e+001,4.353907073350e+001
    2114,-2.624329395356e+000,-8.925004819500e+001,4.203545680740e+001
    2115,-2.595619415619e+000,-8.925004819500e+001,4.041202544497e+001
    2116,-2.594915507761e+000,-8.925004819500e+001,3.900493280538e+001
    2117,-2.594426580382e+000,-8.925004819500e+001,3.742390315606e+001
    2118,-2.587772709972e+000,-8.925004819500e+001,3.601261719442e+001
    2119,-2.721857523573e+000,-8.925004819500e+001,3.449714083743e+001
    2120,-2.686918706636e+000,-8.925004819500e+001,3.291713217594e+001
    2121,-2.571068605941e+000,-8.925004819500e+001,3.146004718419e+001
    2122,-2.601810271470e+000,-8.925004819500e+001,3.001557654629e+001
    2123,-2.603081520964e+000,-8.925004819500e+001,2.850221312032e+001
    2124,-2.708496115407e+000,-8.925004819500e+001,2.698200782915e+001
    2125,-2.580416522489e+000,-8.925004819500e+001,2.550114229276e+001
    2126,-2.686559172888e+000,-8.925004819500e+001,2.404419225790e+001
    2127,-2.575469926022e+000,-8.925004819500e+001,2.254862941386e+001
    2128,-2.694863244500e+000,-8.925004819500e+001,2.109156302749e+001
    2129,-2.584837386567e+000,-8.925004819500e+001,1.959323771547e+001
    2130,-2.691969292463e+000,-8.925004819500e+001,1.815403121114e+001
    2131,-2.588622899041e+000,-8.925004819500e+001,1.664634402036e+001
    2132,-2.692038800775e+000,-8.925004819500e+001,1.519666914856e+001
    2133,-2.572701269310e+000,-8.925004819500e+001,1.375515585684e+001
    2134,-2.691680877816e+000,-8.925004819500e+001,1.225375995872e+001
    2135,-2.599729595273e+000,-8.925004819500e+001,1.078925967600e+001
    2136,-2.602641483167e+000,-8.925004819500e+001,9.192470983187e+000
    2137,-2.574135942710e+000,-8.925004819500e+001,7.825902873695e+000
    2138,-2.702460128887e+000,-8.925004819500e+001,6.366263092567e+000
    2139,-2.572298549643e+000,-8.925004819500e+001,4.917371653924e+000
    2140,-2.589233928879e+000,-8.925004819500e+001,3.556198760034e+000
    2141,-3.683327880582e+000,-8.925004819500e+001,2.149198946746e+000
    2142,-3.418724385983e+000,-8.925004819500e+001,2.825010963940e+000
    2143,-3.279430846282e+000,-8.925004819500e+001,3.952313217542e+000
    2144,-3.278672635394e+000,-8.925004819500e+001,5.185658985093e+000
    2145,-3.422824352178e+000,-8.925004819500e+001,6.331360024666e+000
    2146,-3.281425077258e+000,-8.925004819500e+001,7.504036814167e+000
    2147,-3.281162829301e+000,-8.925004819500e+001,8.745340538056e+000
    2148,-3.424916666143e+000,-8.925004819500e+001,9.893648596380e+000
    2149,-3.289836614168e+000,-8.925004819500e+001,1.108475553909e+001
    2150,-3.421457971577e+000,-8.925004819500e+001,1.223358489355e+001
    2151,-3.292075227705e+000,-8.925004819500e+001,1.339644809062e+001
    2152,-3.310266806834e+000,-8.925004819500e+001,1.464324455521e+001
    2153,-3.308633132996e+000,-8.925004819500e+001,1.572780258815e+001
    2154,-3.290317612102e+000,-8.925004819500e+001,1.696218963713e+001
    2155,-3.422099599388e+000,-8.925004819500e+001,1.813586371931e+001
    2156,-3.282903244324e+000,-8.925004819500e+001,1.928769417581e+001
    2157,-3.312263865117e+000,-8.925004819500e+001,2.052422432579e+001
    2158,-3.313996389367e+000,-8.925004819500e+001,2.163116710623e+001
    2159,-3.281570874128e+000,-8.925004819500e+001,2.285929062342e+001
    2160,-3.421382556153e+000,-8.925004819500e+001,2.402108216048e+001
    2161,-3.284507068874e+000,-8.925004819500e+001,2.519491461382e+001
    2162,-3.312834011094e+000,-8.925004819500e+001,2.643076889271e+001
    2163,-3.320442235778e+000,-8.925004819500e+001,2.753088521408e+001
    2164,-3.315206198845e+000,-8.925004819500e+001,2.876268979219e+001
    2165,-3.318094417117e+000,-8.925004819500e+001,2.985613626346e+001
    2166,-3.281979305802e+000,-8.925004819500e+001,3.110305526685e+001
    2167,-3.318301453958e+000,-8.925004819500e+001,3.234641672058e+001
    2168,-3.326223798557e+000,-8.925004819500e+001,3.343783459967e+001
    2169,-3.428766346032e+000,-8.925004819500e+001,3.459090749197e+001
    2170,-3.290996678263e+000,-8.925004819500e+001,3.576312696547e+001
    2171,-3.281312266411e+000,-8.925004819500e+001,3.702332369757e+001
    2172,-3.422645912351e+000,-8.925004819500e+001,3.818545202064e+001
    2173,-3.280984477634e+000,-8.925004819500e+001,3.937008935662e+001
    2174,-3.307295628921e+000,-8.925004819500e+001,4.060248312825e+001
    2175,-3.315063747394e+000,-8.925004819500e+001,4.170444967058e+001
    2176,-3.424019179689e+000,-8.925004819500e+001,4.287658317895e+001
    2177,-3.292953410210e+000,-8.925004819500e+001,4.401561872679e+001
    2178,-3.306261839493e+000,-8.925004819500e+001,4.526369247948e+001
    2179,-3.613622915945e+000,-8.925004819500e+001,4.634454031424e+001
    2180,-2.811979906246e+000,-8.925004819500e+001,4.626603137393e+001
    2181,-2.062780983603e+000,-9.578620371417e+001,9.510303293994e+000
    2182,-2.064465651210e+000,-9.079820521538e+001,1.702577771821e+001
    2183,-2.187501181250e+000,-9.335605041224e+001,4.675002524500e+001
    2184,-2.187501181250e+000,-9.303605023944e+001,4.675002524500e+001
    2185,-2.187501181250e+000,-9.261005000940e+001,4.675002524500e+001
    2186,-2.187501181250e+000,-9.207004971780e+001,4.675002524500e+001
    2187,-2.187501181250e+000,-9.149804940892e+001,4.675002524500e+001
    2188,-2.187501181250e+000,-9.093204910328e+001,4.675002524500e+001
    2189,-2.187501181250e+000,-9.035604879224e+001,4.675002524500e+001
    2190,-2.187501181250e+000,-8.978204848228e+001,4.675002524500e+001
    2191,-2.062501113750e+000,-9.350005049000e+001,4.675002524500e+001
    2192,-1.937501046250e+000,-9.337255042115e+001,4.675002524500e+001
    2193,-1.937501046250e+000,-9.308992526853e+001,4.675002524500e+001
    2194,-1.937501046250e+000,-9.273292507575e+001,4.675002524500e+001
    2195,-1.937501046250e+000,-9.226967482560e+001,4.675002524500e+001
    2196,-1.937501046250e+000,-9.173629953757e+001,4.675002524500e+001
    2197,-1.937501046250e+000,-9.118804924152e+001,4.675002524500e+001
    2198,-1.937501046250e+000,-9.063342394202e+001,4.675002524500e+001
    2199,-1.937501046250e+000,-9.007879864253e+001,4.675002524500e+001
    2200,-1.937501046250e+000,-8.952629834418e+001,4.675002524500e+001
    2201,-3.749836524911e+000,-8.925004819500e+001,4.675002524500e+001
    2202,-3.370418820025e+000,-8.925004819500e+001,4.675002524500e+001
    2203,-2.858944043829e+000,-8.925004819500e+001,4.675002524500e+001
    2204,-2.252861216544e+000,-8.925004819500e+001,4.675002524500e+001
    2205,-3.908502110590e+000,-8.937504826250e+001,4.675002524500e+001
    2206,-3.683050988846e+000,-8.950004833000e+001,4.675002524500e+001
    2207,-3.149540700751e+000,-8.950004833000e+001,4.675002524500e+001
    2208,-2.514491357825e+000,-8.950004833000e+001,4.675002524500e+001
    2209,-1.937501046250e+000,-9.193552676711e+001,9.750005265000e+000
    2210,-1.937501046250e+000,-9.240353324616e+001,9.750005265000e+000
    2211,-1.937501046250e+000,-9.295133806495e+001,9.750005265000e+000
    2212,-1.937501046250e+000,-9.350345630751e+001,9.750005265000e+000
    2213,-1.937501046250e+000,-9.406851482138e+001,9.750005265000e+000
    2214,-1.937501046250e+000,-9.463573004714e+001,9.750005265000e+000
    2215,-1.937501046250e+000,-9.517922144216e+001,9.750005265000e+000
    2216,-1.937501046250e+000,-9.561056381917e+001,9.750005265000e+000
    2217,-1.937501046250e+000,-9.592544375438e+001,9.750005265000e+000
    2218,-1.937501046250e+000,-9.620694240864e+001,9.763855395480e+000
    2219,-1.937501046250e+000,-9.649770027817e+001,9.888493158295e+000
    2220,-1.937501046250e+000,-9.672551589937e+001,1.014758514846e+001
    2221,-1.937501046250e+000,-9.681201020481e+001,1.045317478151e+001
    2222,-1.937501046250e+000,-9.678826129858e+001,1.073887858906e+001
    2223,-1.937501046250e+000,-9.674666127612e+001,1.105087875754e+001
    2224,-1.937501046250e+000,-9.669076124593e+001,1.147012898393e+001
    2225,-1.937501046250e+000,-9.662056120802e+001,1.199662926824e+001
    2226,-1.937501046250e+000,-9.654516116731e+001,1.256212957361e+001
    2227,-1.937501046250e+000,-9.646976112659e+001,1.312762987898e+001
    2228,-1.937501046250e+000,-9.639609442014e+001,1.368013017733e+001
    2229,-1.937501046250e+000,-9.632112771300e+001,1.424238048095e+001
    2230,-1.937501046250e+000,-9.624529433871e+001,1.481113078807e+001
    2231,-1.937501046250e+000,-9.617206096583e+001,1.536038108467e+001
    2232,-1.937501046250e+000,-9.609492759085e+001,1.593888139706e+001
    2233,-1.937501046250e+000,-9.601996088370e+001,1.650113170067e+001
    2234,-1.937501046250e+000,-9.596319418638e+001,1.692688193058e+001
    2235,-1.937501046250e+000,-9.590341714831e+001,1.725140835951e+001
    2236,-1.937501046250e+000,-9.570449782349e+001,1.755205066666e+001
    2237,-1.937501046250e+000,-9.537050094750e+001,1.772961916853e+001
    2238,-1.937501046250e+000,-9.506410604989e+001,1.775000958500e+001
    2239,-1.937501046250e+000,-9.476768497925e+001,1.775000958500e+001
    2240,-1.937501046250e+000,-9.438681837104e+001,1.775000958500e+001
    2241,-1.937501046250e+000,-9.391805946864e+001,1.775000958500e+001
    2242,-1.937501046250e+000,-9.338553556847e+001,1.775000958500e+001
    2243,-1.937501046250e+000,-9.286162855990e+001,1.775000958500e+001
    2244,-1.937501046250e+000,-9.235150857787e+001,1.775000958500e+001
    2245,-1.937501046250e+000,-9.191721724181e+001,1.775000958500e+001
    2246,-1.937501046250e+000,-9.162226336397e+001,1.773904321131e+001
    2247,-1.937501046250e+000,-9.135968323659e+001,1.764041120432e+001
    2248,-1.937501046250e+000,-9.112514104631e+001,1.741472592159e+001
    2249,-1.937501046250e+000,-9.101172922024e+001,1.713185646115e+001
    2250,-1.937501046250e+000,-9.100004914000e+001,1.685050909927e+001
    2251,-1.937501046250e+000,-9.100004914000e+001,1.645075888341e+001
    2252,-1.937501046250e+000,-9.100004914000e+001,1.593725860612e+001
    2253,-1.937501046250e+000,-9.100004914000e+001,1.540425831829e+001
    2254,-1.937501046250e+000,-9.100004914000e+001,1.486800802872e+001
    2255,-1.937501046250e+000,-9.100004914000e+001,1.432525773563e+001
    2256,-1.937501046250e+000,-9.100004914000e+001,1.378575744430e+001
    2257,-1.937501046250e+000,-9.100004914000e+001,1.323975714947e+001
    2258,-1.937501046250e+000,-9.100004914000e+001,1.269050685287e+001
    2259,-1.937501046250e+000,-9.100004914000e+001,1.215750656505e+001
    2260,-1.937501046250e+000,-9.100004914000e+001,1.161475627197e+001
    2261,-1.937501046250e+000,-9.100004914000e+001,1.106875597712e+001
    2262,-1.937501046250e+000,-9.100004914000e+001,1.064950575073e+001
    2263,-1.937501046250e+000,-9.101172922024e+001,1.036815838885e+001
    2264,-1.937501046250e+000,-9.112449038199e+001,1.008627104361e+001
    2265,-1.937501046250e+000,-9.135968323659e+001,9.859603645677e+000
    2266,-1.937501046250e+000,-9.162342439309e+001,9.760771824452e+000
    2267,-1.937501046250e+000,-9.545082724303e+001,2.076963400566e+001
    2268,-1.937501046250e+000,-9.539326054528e+001,2.120138423881e+001
    2269,-1.937501046250e+000,-9.532066050608e+001,2.174588453284e+001
    2270,-1.937501046250e+000,-9.524586046569e+001,2.230688483578e+001
    2271,-1.937501046250e+000,-9.516959375783e+001,2.287888514466e+001
    2272,-1.937501046250e+000,-9.509259371625e+001,2.345638545651e+001
    2273,-1.937501046250e+000,-9.501816034273e+001,2.401463575796e+001
    2274,-1.937501046250e+000,-9.494446030293e+001,2.456738605645e+001
    2275,-1.937501046250e+000,-9.486892692881e+001,2.513388636236e+001
    2276,-1.937501046250e+000,-9.480402689376e+001,2.562063662520e+001
    2277,-1.937501046250e+000,-9.475892686941e+001,2.595888680786e+001
    2278,-1.937501046250e+000,-9.469782888736e+001,2.626659772898e+001
    2279,-1.937501046250e+000,-9.448186038490e+001,2.657204760328e+001
    2280,-1.937501046250e+000,-9.415682908369e+001,2.673274391555e+001
    2281,-1.937501046250e+000,-9.384402612521e+001,2.675001444500e+001
    2282,-1.937501046250e+000,-9.348679192322e+001,2.675001444500e+001
    2283,-1.937501046250e+000,-9.300710951992e+001,2.675001444500e+001
    2284,-1.937501046250e+000,-9.243418674315e+001,2.675001444500e+001
    2285,-1.937501046250e+000,-9.194327055991e+001,2.675001444500e+001
    2286,-1.937501046250e+000,-9.162052241238e+001,2.673874493107e+001
    2287,-1.937501046250e+000,-9.135466562238e+001,2.663733041452e+001
    2288,-1.937501046250e+000,-9.111965970909e+001,2.640635043054e+001
    2289,-1.937501046250e+000,-9.101071647630e+001,2.612605856001e+001
    2290,-1.937501046250e+000,-9.100004914000e+001,2.585426396130e+001
    2291,-1.937501046250e+000,-9.100004914000e+001,2.551601377864e+001
    2292,-1.937501046250e+000,-9.100004914000e+001,2.507326353956e+001
    2293,-1.937501046250e+000,-9.100004914000e+001,2.455901326186e+001
    2294,-1.937501046250e+000,-9.100004914000e+001,2.402551297377e+001
    2295,-1.937501046250e+000,-9.100004914000e+001,2.348926268419e+001
    2296,-1.937501046250e+000,-9.100004914000e+001,2.295851239759e+001
    2297,-1.937501046250e+000,-9.100004914000e+001,2.241951210653e+001
    2298,-1.937501046250e+000,-9.100004914000e+001,2.188601181844e+001
    2299,-1.937501046250e+000,-9.100004914000e+001,2.139101155114e+001
    2300,-1.937501046250e+000,-9.100004914000e+001,2.096751132245e+001
    2301,-1.937501046250e+000,-9.100004914000e+001,2.064026114574e+001
    2302,-1.937501046250e+000,-9.101081569945e+001,2.037338591809e+001
    2303,-1.937501046250e+000,-9.112158151653e+001,2.009070856000e+001
    2304,-1.937501046250e+000,-9.135867777745e+001,1.986022302145e+001
    2305,-1.937501046250e+000,-9.162226336397e+001,1.976097703869e+001
    2306,-1.937501046250e+000,-9.194077528687e+001,1.975001066500e+001
    2307,-1.937501046250e+000,-9.242354982097e+001,1.975001066500e+001
    2308,-1.937501046250e+000,-9.299423700172e+001,1.975001066500e+001
    2309,-1.937501046250e+000,-9.356343413760e+001,1.975001066500e+001
    2310,-1.937501046250e+000,-9.412369100434e+001,1.975001066500e+001
    2311,-1.937501046250e+000,-9.456176419269e+001,1.975001066500e+001
    2312,-1.937501046250e+000,-9.487172700907e+001,1.976349663206e+001
    2313,-1.937501046250e+000,-9.516436622484e+001,1.988849855830e+001
    2314,-1.937501046250e+000,-9.539574897685e+001,2.015437496862e+001
    2315,-1.937501046250e+000,-9.547901312041e+001,2.045891908524e+001
    2316,-1.937501046250e+000,-9.425492659725e+001,2.973888884906e+001
    2317,-1.937501046250e+000,-9.420899323911e+001,3.008338903509e+001
    2318,-1.937501046250e+000,-9.414182653617e+001,3.058713930711e+001
    2319,-1.937501046250e+000,-9.406512649476e+001,3.116238961775e+001
    2320,-1.937501046250e+000,-9.399102645474e+001,3.171813991785e+001
    2321,-1.937501046250e+000,-9.391432641332e+001,3.229339022849e+001
    2322,-1.937501046250e+000,-9.383849303904e+001,3.286214053561e+001
    2323,-1.937501046250e+000,-9.376439299903e+001,3.341789083572e+001
    2324,-1.937501046250e+000,-9.368769295761e+001,3.399314114635e+001
    2325,-1.937501046250e+000,-9.361185958333e+001,3.456189145348e+001
    2326,-1.937501046250e+000,-9.353689287618e+001,3.512414175709e+001
    2327,-1.937501046250e+000,-9.347232617464e+001,3.560839201859e+001
    2328,-1.937501046250e+000,-9.342639281651e+001,3.595289220462e+001
    2329,-1.937501046250e+000,-9.338230039730e+001,3.621399512493e+001
    2330,-1.937501046250e+000,-9.325644887652e+001,3.645923443708e+001
    2331,-1.937501046250e+000,-9.302715542909e+001,3.665594214273e+001
    2332,-1.937501046250e+000,-9.278056704404e+001,3.674082254215e+001
    2333,-1.937501046250e+000,-9.243420257358e+001,3.675001984500e+001
    2334,-1.937501046250e+000,-9.197749160657e+001,3.675001984500e+001
    2335,-1.937501046250e+000,-9.162284383930e+001,3.673915360640e+001
    2336,-1.937501046250e+000,-9.135717140015e+001,3.663888356546e+001
    2337,-1.937501046250e+000,-9.112222522248e+001,3.641030863990e+001
    2338,-1.937501046250e+000,-9.101142061214e+001,3.613012673049e+001
    2339,-1.937501046250e+000,-9.100004914000e+001,3.584401935576e+001
    2340,-1.937501046250e+000,-9.100004914000e+001,3.543451913463e+001
    2341,-1.937501046250e+000,-9.100004914000e+001,3.490151884681e+001
    2342,-1.937501046250e+000,-9.100004914000e+001,3.435876855372e+001
    2343,-1.937501046250e+000,-9.100004914000e+001,3.382576826591e+001
    2344,-1.937501046250e+000,-9.100004914000e+001,3.327651796931e+001
    2345,-1.937501046250e+000,-9.100004914000e+001,3.273701767798e+001
    2346,-1.937501046250e+000,-9.100004914000e+001,3.220076738840e+001
    2347,-1.937501046250e+000,-9.100004914000e+001,3.166126709707e+001
    2348,-1.937501046250e+000,-9.100004914000e+001,3.112826680926e+001
    2349,-1.937501046250e+000,-9.100004914000e+001,3.058551651617e+001
    2350,-1.937501046250e+000,-9.100004914000e+001,3.004601622484e+001
    2351,-1.937501046250e+000,-9.100004914000e+001,2.963976600547e+001
    2352,-1.937501046250e+000,-9.101204192724e+001,2.936642939017e+001
    2353,-1.937501046250e+000,-9.112710228421e+001,2.908235899210e+001
    2354,-1.937501046250e+000,-9.136169704195e+001,2.885839069602e+001
    2355,-1.937501046250e+000,-9.162284383930e+001,2.876088176360e+001
    2356,-1.937501046250e+000,-9.192805845187e+001,2.875001552500e+001
    2357,-1.937501046250e+000,-9.236596036276e+001,2.875001552500e+001
    2358,-1.937501046250e+000,-9.290176717244e+001,2.875001552500e+001
    2359,-1.937501046250e+000,-9.335390979588e+001,2.875001552500e+001
    2360,-1.937501046250e+000,-9.366293472258e+001,2.876186567364e+001
    2361,-1.937501046250e+000,-9.393525524260e+001,2.886884152900e+001
    2362,-1.937501046250e+000,-9.417364432205e+001,2.911478741237e+001
    2363,-1.937501046250e+000,-9.427771825324e+001,2.943980554869e+001
    2364,-1.937501046250e+000,-9.981459470040e+001,2.228335064867e+000
    2365,-1.937501046250e+000,-9.971888726532e+001,2.946140827958e+000
    2366,-1.937501046250e+000,-9.959626211413e+001,3.865829461918e+000
    2367,-1.937501046250e+000,-9.946765524824e+001,4.830380956072e+000
    2368,-1.937501046250e+000,-9.933306666766e+001,5.839795310419e+000
    2369,-1.937501046250e+000,-9.920146894443e+001,6.826778234669e+000
    2370,-1.937501046250e+000,-9.907585293589e+001,7.768898298726e+000
    2371,-1.937501046250e+000,-9.893528264062e+001,8.823175513265e+000
    2372,-1.937501046250e+000,-9.879770320269e+001,9.855021297709e+000
    2373,-1.937501046250e+000,-9.868105976619e+001,1.072984707148e+001
    2374,-1.937501046250e+000,-9.857039804438e+001,1.155980998505e+001
    2375,-1.937501046250e+000,-9.844478203584e+001,1.250193004911e+001
    2376,-1.937501046250e+000,-9.831019345526e+001,1.351134440345e+001
    2377,-1.937501046250e+000,-9.818457744672e+001,1.445346446751e+001
    2378,-1.937501046250e+000,-9.806494315287e+001,1.535072167137e+001
    2379,-1.937501046250e+000,-9.793334542964e+001,1.633770459562e+001
    2380,-1.937501046250e+000,-9.779875684906e+001,1.734711894997e+001
    2381,-1.937501046250e+000,-9.767014998317e+001,1.831167044412e+001
    2382,-1.937501046250e+000,-9.753556140259e+001,1.932108479847e+001
    2383,-1.937501046250e+000,-9.740695453670e+001,2.028563629262e+001
    2384,-1.937501046250e+000,-9.727834767082e+001,2.125018778678e+001
    2385,-1.937501046250e+000,-9.714674994758e+001,2.223717071103e+001
    2386,-1.937501046250e+000,-9.701515222435e+001,2.322415363528e+001
    2387,-1.937501046250e+000,-9.688654535846e+001,2.418870512943e+001
    2388,-1.937501046250e+000,-9.675793849257e+001,2.515325662359e+001
    2389,-1.937501046250e+000,-9.662334991200e+001,2.616267097793e+001
    2390,-1.937501046250e+000,-9.649474304611e+001,2.712722247209e+001
    2391,-1.937501046250e+000,-9.636314532287e+001,2.811420539634e+001
    2392,-1.937501046250e+000,-9.623453845699e+001,2.907875689049e+001
    2393,-1.937501046250e+000,-9.610593159110e+001,3.004330838464e+001
    2394,-1.937501046250e+000,-9.597134301052e+001,3.105272273899e+001
    2395,-1.937501046250e+000,-9.583974528729e+001,3.203970566324e+001
    2396,-1.937501046250e+000,-9.570515670671e+001,3.304912001759e+001
    2397,-1.937501046250e+000,-9.557355898347e+001,3.403610294184e+001
    2398,-1.937501046250e+000,-9.544196126024e+001,3.502308586609e+001
    2399,-1.937501046250e+000,-9.531933610905e+001,3.594277450005e+001
    2400,-1.937501046250e+000,-9.519671095785e+001,3.686246313401e+001
    2401,-1.937501046250e+000,-9.506810409196e+001,3.782701462816e+001
    2402,-1.937501046250e+000,-9.494248808342e+001,3.876913469222e+001
    2403,-1.937501046250e+000,-9.481089036019e+001,3.975611761647e+001
    2404,-1.937501046250e+000,-9.467630177961e+001,4.076553197081e+001
    2405,-1.937501046250e+000,-9.454470405638e+001,4.175251489506e+001
    2406,-1.937501046250e+000,-9.441609719049e+001,4.271706638922e+001
    2407,-1.937501046250e+000,-9.427552689522e+001,4.377134360376e+001
    2408,-1.937501046250e+000,-9.414392917199e+001,4.475832652801e+001
    2409,-1.937501046250e+000,-9.404224002221e+001,4.552099515129e+001
    2410,-1.937501046250e+000,-9.395849601652e+001,4.614907519400e+001
    2411,-1.937501046250e+000,-9.389568801225e+001,4.662013522602e+001
    2412,-1.937501046250e+000,-8.952573731392e+001,1.936726473612e+000
    2413,-1.937501046250e+000,-9.008771897942e+001,1.936726473612e+000
    2414,-1.937501046250e+000,-9.064970064492e+001,1.936726473612e+000
    2415,-1.937501046250e+000,-9.120638059659e+001,1.936726473612e+000
    2416,-1.937501046250e+000,-9.176306054826e+001,1.936726473612e+000
    2417,-1.937501046250e+000,-9.231974049994e+001,1.936726473612e+000
    2418,-1.937501046250e+000,-9.287642045161e+001,1.936726473612e+000
    2419,-1.937501046250e+000,-9.343840211711e+001,1.936726473612e+000
    2420,-1.937501046250e+000,-9.400038378261e+001,1.936726473612e+000
    2421,-1.937501046250e+000,-9.455706373428e+001,1.936726473612e+000
    2422,-1.937501046250e+000,-9.510844197212e+001,1.936726473612e+000
    2423,-1.937501046250e+000,-9.567572535145e+001,1.936726473612e+000
    2424,-1.937501046250e+000,-9.624831044460e+001,1.936726473612e+000
    2425,-1.937501046250e+000,-9.679438696862e+001,1.936726473612e+000
    2426,-1.937501046250e+000,-9.734046349264e+001,1.936726473612e+000
    2427,-1.937501046250e+000,-9.790774687196e+001,1.936726473612e+000
    2428,-1.937501046250e+000,-9.847503025129e+001,1.936726473612e+000
    2429,-1.937501046250e+000,-9.902110677531e+001,1.936726473612e+000
    2430,-1.937501046250e+000,-9.957248501316e+001,1.936726473612e+000
    2431,-1.937501046250e+000,-8.925004819500e+001,4.639151885483e+001
    2432,-1.937501046250e+000,-8.925004819500e+001,4.567450607449e+001
    2433,-1.937501046250e+000,-8.925004819500e+001,4.491267999537e+001
    2434,-1.937501046250e+000,-8.925004819500e+001,4.415085391626e+001
    2435,-1.937501046250e+000,-8.925004819500e+001,4.345624778530e+001
    2436,-1.937501046250e+000,-8.925004819500e+001,4.276164165435e+001
    2437,-1.937501046250e+000,-8.925004819500e+001,4.202222222462e+001
    2438,-1.937501046250e+000,-8.925004819500e+001,4.121558284673e+001
    2439,-1.937501046250e+000,-8.925004819500e+001,4.045375676762e+001
    2440,-1.937501046250e+000,-8.925004819500e+001,3.975915063666e+001
    2441,-1.937501046250e+000,-8.925004819500e+001,3.904213785632e+001
    2442,-1.937501046250e+000,-8.925004819500e+001,3.823549847844e+001
    2443,-1.937501046250e+000,-8.925004819500e+001,3.742885910055e+001
    2444,-1.937501046250e+000,-8.925004819500e+001,3.671184632021e+001
    2445,-1.937501046250e+000,-8.925004819500e+001,3.595002024110e+001
    2446,-1.937501046250e+000,-8.925004819500e+001,3.516578751260e+001
    2447,-1.937501046250e+000,-8.925004819500e+001,3.438155478410e+001
    2448,-1.937501046250e+000,-8.925004819500e+001,3.361972870498e+001
    2449,-1.937501046250e+000,-8.925004819500e+001,3.292512257403e+001
    2450,-1.937501046250e+000,-8.925004819500e+001,3.223051644307e+001
    2451,-1.937501046250e+000,-8.925004819500e+001,3.151350366273e+001
    2452,-1.937501046250e+000,-8.925004819500e+001,3.072927093423e+001
    2453,-1.937501046250e+000,-8.925004819500e+001,2.994503820573e+001
    2454,-1.937501046250e+000,-8.925004819500e+001,2.920561877600e+001
    2455,-1.937501046250e+000,-8.925004819500e+001,2.848860599566e+001
    2456,-1.937501046250e+000,-8.925004819500e+001,2.779399986470e+001
    2457,-1.937501046250e+000,-8.925004819500e+001,2.703217378559e+001
    2458,-1.937501046250e+000,-8.925004819500e+001,2.624794105709e+001
    2459,-1.937501046250e+000,-8.925004819500e+001,2.550852162736e+001
    2460,-1.937501046250e+000,-8.925004819500e+001,2.479150884702e+001
    2461,-1.937501046250e+000,-8.925004819500e+001,2.405208941729e+001
    2462,-1.937501046250e+000,-8.925004819500e+001,2.329026333818e+001
    2463,-1.937501046250e+000,-8.925004819500e+001,2.255084390845e+001
    2464,-1.937501046250e+000,-8.925004819500e+001,2.183383112811e+001
    2465,-1.937501046250e+000,-8.925004819500e+001,2.111681834777e+001
    2466,-1.937501046250e+000,-8.925004819500e+001,2.035499226865e+001
    2467,-1.937501046250e+000,-8.925004819500e+001,1.959316618954e+001
    2468,-1.937501046250e+000,-8.925004819500e+001,1.887615340920e+001
    2469,-1.937501046250e+000,-8.925004819500e+001,1.818154727824e+001
    2470,-1.937501046250e+000,-8.925004819500e+001,1.744212784851e+001
    2471,-1.937501046250e+000,-8.925004819500e+001,1.665789512001e+001
    2472,-1.937501046250e+000,-8.925004819500e+001,1.591847569028e+001
    2473,-1.937501046250e+000,-8.925004819500e+001,1.520146290994e+001
    2474,-1.937501046250e+000,-8.925004819500e+001,1.450685677899e+001
    2475,-1.937501046250e+000,-8.925004819500e+001,1.378984399864e+001
    2476,-1.937501046250e+000,-8.925004819500e+001,1.302801791953e+001
    2477,-1.937501046250e+000,-8.925004819500e+001,1.228859848980e+001
    2478,-1.937501046250e+000,-8.925004819500e+001,1.157158570946e+001
    2479,-1.937501046250e+000,-8.925004819500e+001,1.085457292912e+001
    2480,-1.937501046250e+000,-8.925004819500e+001,1.007034020062e+001
    2481,-1.937501046250e+000,-8.925004819500e+001,9.286107472119e+000
    2482,-1.937501046250e+000,-8.925004819500e+001,8.569094691777e+000
    2483,-1.937501046250e+000,-8.925004819500e+001,7.852081911435e+000
    2484,-1.937501046250e+000,-8.925004819500e+001,7.157475780478e+000
    2485,-1.937501046250e+000,-8.925004819500e+001,6.418056350750e+000
    2486,-1.937501046250e+000,-8.925004819500e+001,5.656230271637e+000
    2487,-1.937501046250e+000,-8.925004819500e+001,4.939217491295e+000
    2488,-1.937501046250e+000,-8.925004819500e+001,4.222204710952e+000
    2489,-1.937501046250e+000,-8.925004819500e+001,3.527598579996e+000
    2490,-1.937501046250e+000,-8.925004819500e+001,2.832992449039e+000
    2491,-1.937501046250e+000,-8.925004819500e+001,2.205606266240e+000
    2492,-1.937501046250e+000,-9.368590582174e+001,4.677480595590e+001
    2493,-2.187501181250e+000,-9.918089128730e+001,1.936726473612e+000
    2494,-2.187501181250e+000,-9.859235987619e+001,1.936726473612e+000
    2495,-2.187501181250e+000,-9.800382846508e+001,1.936726473612e+000
    2496,-2.187501181250e+000,-9.741529705397e+001,1.936726473612e+000
    2497,-2.187501181250e+000,-9.682676564286e+001,1.936726473612e+000
    2498,-2.187501181250e+000,-9.623823423176e+001,1.936726473612e+000
    2499,-2.187501181250e+000,-9.565469037498e+001,1.936726473612e+000
    2500,-2.187501181250e+000,-9.507114651820e+001,1.936726473612e+000
    2501,-2.187501181250e+000,-9.448261510709e+001,1.936726473612e+000
    2502,-2.187501181250e+000,-9.389408369599e+001,1.936726473612e+000
    2503,-2.187501181250e+000,-9.330555228488e+001,1.936726473612e+000
    2504,-2.187501181250e+000,-9.271702087377e+001,1.936726473612e+000
    2505,-2.187501181250e+000,-9.213347701699e+001,1.936726473612e+000
    2506,-2.187501181250e+000,-9.154993316022e+001,1.936726473612e+000
    2507,-2.187501181250e+000,-9.096140174911e+001,1.936726473612e+000
    2508,-2.187501181250e+000,-9.037287033800e+001,1.936726473612e+000
    2509,-2.187501181250e+000,-8.978932648122e+001,1.936726473612e+000
    2510,-2.187501181250e+000,-9.943631880058e+001,2.228012915626e+000
    2511,-2.187501181250e+000,-9.934669220304e+001,2.900212397196e+000
    2512,-2.187501181250e+000,-9.922719007298e+001,3.796478372624e+000
    2513,-2.187501181250e+000,-9.909872528317e+001,4.759964296209e+000
    2514,-2.187501181250e+000,-9.896727294011e+001,5.745856869180e+000
    2515,-2.187501181250e+000,-9.883880815030e+001,6.709342792764e+000
    2516,-2.187501181250e+000,-9.871034336049e+001,7.672828716349e+000
    2517,-2.187501181250e+000,-9.857889101742e+001,8.658721289320e+000
    2518,-2.187501181250e+000,-9.845341378086e+001,9.599800563519e+000
    2519,-2.187501181250e+000,-9.833391165081e+001,1.049606653895e+001
    2520,-2.187501181250e+000,-9.822934728701e+001,1.128029926745e+001
    2521,-2.187501181250e+000,-9.811880781670e+001,1.210934529472e+001
    2522,-2.187501181250e+000,-9.799930568665e+001,1.300561127014e+001
    2523,-2.187501181250e+000,-9.787681600334e+001,1.392428389496e+001
    2524,-2.187501181250e+000,-9.775432632003e+001,1.484295651977e+001
    2525,-2.187501181250e+000,-9.762884908347e+001,1.578403579397e+001
    2526,-2.187501181250e+000,-9.750635940016e+001,1.670270841878e+001
    2527,-2.187501181250e+000,-9.738984482336e+001,1.757656774483e+001
    2528,-2.187501181250e+000,-9.726735514005e+001,1.849524036964e+001
    2529,-2.187501181250e+000,-9.713590279699e+001,1.948113294261e+001
    2530,-2.187501181250e+000,-9.701341311368e+001,2.039980556742e+001
    2531,-2.187501181250e+000,-9.689689853687e+001,2.127366489347e+001
    2532,-2.187501181250e+000,-9.677440885356e+001,2.219233751828e+001
    2533,-2.187501181250e+000,-9.664893161700e+001,2.313341679248e+001
    2534,-2.187501181250e+000,-9.652345438044e+001,2.407449606668e+001
    2535,-2.187501181250e+000,-9.639498959063e+001,2.503798199026e+001
    2536,-2.187501181250e+000,-9.627249990732e+001,2.595665461508e+001
    2537,-2.187501181250e+000,-9.616196043702e+001,2.678570064235e+001
    2538,-2.187501181250e+000,-9.604544586021e+001,2.765955996839e+001
    2539,-2.187501181250e+000,-9.591996862365e+001,2.860063924259e+001
    2540,-2.187501181250e+000,-9.580046649360e+001,2.949690521802e+001
    2541,-2.187501181250e+000,-9.568992702330e+001,3.032595124529e+001
    2542,-2.187501181250e+000,-9.557042489324e+001,3.122221722071e+001
    2543,-2.187501181250e+000,-9.544494765668e+001,3.216329649491e+001
    2544,-2.187501181250e+000,-9.532245797337e+001,3.308196911973e+001
    2545,-2.187501181250e+000,-9.519996829006e+001,3.400064174454e+001
    2546,-2.187501181250e+000,-9.506851594700e+001,3.498653431751e+001
    2547,-2.187501181250e+000,-9.494602626369e+001,3.590520694232e+001
    2548,-2.187501181250e+000,-9.483249924014e+001,3.675665961898e+001
    2549,-2.187501181250e+000,-9.471598466333e+001,3.763051894502e+001
    2550,-2.187501181250e+000,-9.458751987352e+001,3.859400486861e+001
    2551,-2.187501181250e+000,-9.445606753046e+001,3.957989744158e+001
    2552,-2.187501181250e+000,-9.432760274065e+001,4.054338336516e+001
    2553,-2.187501181250e+000,-9.419615039758e+001,4.152927593813e+001
    2554,-2.187501181250e+000,-9.406768560777e+001,4.249276186172e+001
    2555,-2.187501181250e+000,-9.393324571146e+001,4.350106108407e+001
    2556,-2.187501181250e+000,-9.380478092165e+001,4.446454700766e+001
    2557,-2.187501181250e+000,-9.369722900459e+001,4.527118638554e+001
    2558,-2.187501181250e+000,-9.361656506681e+001,4.587616591896e+001
    2559,-2.187501181250e+000,-9.355980155503e+001,4.630189225729e+001
    2560,-2.187501181250e+000,-9.351797580951e+001,4.661558534869e+001
    2561,-2.187501181250e+000,-8.950004833000e+001,4.639151885483e+001
    2562,-2.187501181250e+000,-8.950004833000e+001,4.567450607449e+001
    2563,-2.187501181250e+000,-8.950004833000e+001,4.491267999537e+001
    2564,-2.187501181250e+000,-8.950004833000e+001,4.415085391626e+001
    2565,-2.187501181250e+000,-8.950004833000e+001,4.345624778530e+001
    2566,-2.187501181250e+000,-8.950004833000e+001,4.276164165435e+001
    2567,-2.187501181250e+000,-8.950004833000e+001,4.202222222462e+001
    2568,-2.187501181250e+000,-8.950004833000e+001,4.121558284673e+001
    2569,-2.187501181250e+000,-8.950004833000e+001,4.045375676762e+001
    2570,-2.187501181250e+000,-8.950004833000e+001,3.975915063666e+001
    2571,-2.187501181250e+000,-8.950004833000e+001,3.904213785632e+001
    2572,-2.187501181250e+000,-8.950004833000e+001,3.823549847844e+001
    2573,-2.187501181250e+000,-8.950004833000e+001,3.745126574994e+001
    2574,-2.187501181250e+000,-8.950004833000e+001,3.673425296959e+001
    2575,-2.187501181250e+000,-8.950004833000e+001,3.595002024110e+001
    2576,-2.187501181250e+000,-8.950004833000e+001,3.516578751260e+001
    2577,-2.187501181250e+000,-8.950004833000e+001,3.438155478410e+001
    2578,-2.187501181250e+000,-8.950004833000e+001,3.364213535437e+001
    2579,-2.187501181250e+000,-8.950004833000e+001,3.294752922341e+001
    2580,-2.187501181250e+000,-8.950004833000e+001,3.223051644307e+001
    2581,-2.187501181250e+000,-8.950004833000e+001,3.151350366273e+001
    2582,-2.187501181250e+000,-8.950004833000e+001,3.075167758361e+001
    2583,-2.187501181250e+000,-8.950004833000e+001,2.998985150450e+001
    2584,-2.187501181250e+000,-8.950004833000e+001,2.925043207477e+001
    2585,-2.187501181250e+000,-8.950004833000e+001,2.851101264504e+001
    2586,-2.187501181250e+000,-8.950004833000e+001,2.779399986470e+001
    2587,-2.187501181250e+000,-8.950004833000e+001,2.703217378559e+001
    2588,-2.187501181250e+000,-8.950004833000e+001,2.624794105709e+001
    2589,-2.187501181250e+000,-8.950004833000e+001,2.550852162736e+001
    2590,-2.187501181250e+000,-8.950004833000e+001,2.479150884702e+001
    2591,-2.187501181250e+000,-8.950004833000e+001,2.405208941729e+001
    2592,-2.187501181250e+000,-8.950004833000e+001,2.329026333818e+001
    2593,-2.187501181250e+000,-8.950004833000e+001,2.257325055784e+001
    2594,-2.187501181250e+000,-8.950004833000e+001,2.187864442688e+001
    2595,-2.187501181250e+000,-8.950004833000e+001,2.113922499715e+001
    2596,-2.187501181250e+000,-8.950004833000e+001,2.035499226865e+001
    2597,-2.187501181250e+000,-8.950004833000e+001,1.959316618954e+001
    2598,-2.187501181250e+000,-8.950004833000e+001,1.889856005858e+001
    2599,-2.187501181250e+000,-8.950004833000e+001,1.820395392763e+001
    2600,-2.187501181250e+000,-8.950004833000e+001,1.746453449790e+001
    2601,-2.187501181250e+000,-8.950004833000e+001,1.668030176940e+001
    2602,-2.187501181250e+000,-8.950004833000e+001,1.594088233967e+001
    2603,-2.187501181250e+000,-8.950004833000e+001,1.524627620871e+001
    2604,-2.187501181250e+000,-8.950004833000e+001,1.452926342837e+001
    2605,-2.187501181250e+000,-8.950004833000e+001,1.381225064803e+001
    2606,-2.187501181250e+000,-8.950004833000e+001,1.305042456892e+001
    2607,-2.187501181250e+000,-8.950004833000e+001,1.228859848980e+001
    2608,-2.187501181250e+000,-8.950004833000e+001,1.159399235885e+001
    2609,-2.187501181250e+000,-8.950004833000e+001,1.087697957850e+001
    2610,-2.187501181250e+000,-8.950004833000e+001,1.009274685000e+001
    2611,-2.187501181250e+000,-8.950004833000e+001,9.308514121505e+000
    2612,-2.187501181250e+000,-8.950004833000e+001,8.591501341163e+000
    2613,-2.187501181250e+000,-8.950004833000e+001,7.896895210206e+000
    2614,-2.187501181250e+000,-8.950004833000e+001,7.179882429864e+000
    2615,-2.187501181250e+000,-8.950004833000e+001,6.418056350750e+000
    2616,-2.187501181250e+000,-8.950004833000e+001,5.678636921022e+000
    2617,-2.187501181250e+000,-8.950004833000e+001,4.984030790066e+000
    2618,-2.187501181250e+000,-8.950004833000e+001,4.267018009724e+000
    2619,-2.187501181250e+000,-8.950004833000e+001,3.550005229382e+000
    2620,-2.187501181250e+000,-8.950004833000e+001,2.832992449039e+000
    2621,-2.187501181250e+000,-8.950004833000e+001,2.205606266240e+000
    2622,-2.187501181250e+000,-9.620756931652e+001,9.763977851334e+000
    2623,-2.187501181250e+000,-9.649822092989e+001,9.888863199814e+000
    2624,-2.187501181250e+000,-9.672521551193e+001,1.014702143193e+001
    2625,-2.187501181250e+000,-9.681197004870e+001,1.045253728921e+001
    2626,-2.187501181250e+000,-9.192042978392e+001,9.750005265000e+000
    2627,-2.187501181250e+000,-9.232157819453e+001,9.750005265000e+000
    2628,-2.187501181250e+000,-9.281115179242e+001,9.750005265000e+000
    2629,-2.187501181250e+000,-9.337189688253e+001,9.750005265000e+000
    2630,-2.187501181250e+000,-9.397793292221e+001,9.750005265000e+000
    2631,-2.187501181250e+000,-9.459043909756e+001,9.750005265000e+000
    2632,-2.187501181250e+000,-9.515981103520e+001,9.750005265000e+000
    2633,-2.187501181250e+000,-9.560193697163e+001,9.750005265000e+000
    2634,-2.187501181250e+000,-9.592328704249e+001,9.750005265000e+000
    2635,-2.187501181250e+000,-9.101172922024e+001,1.036815838885e+001
    2636,-2.187501181250e+000,-9.112449038199e+001,1.008627104361e+001
    2637,-2.187501181250e+000,-9.135968323659e+001,9.859603645677e+000
    2638,-2.187501181250e+000,-9.162342439309e+001,9.760771824452e+000
    2639,-2.187501181250e+000,-9.100004914000e+001,1.685375910103e+001
    2640,-2.187501181250e+000,-9.100004914000e+001,1.650275891148e+001
    2641,-2.187501181250e+000,-9.100004914000e+001,1.604450866403e+001
    2642,-2.187501181250e+000,-9.100004914000e+001,1.550175837095e+001
    2643,-2.187501181250e+000,-9.100004914000e+001,1.492325805856e+001
    2644,-2.187501181250e+000,-9.100004914000e+001,1.434150774441e+001
    2645,-2.187501181250e+000,-9.100004914000e+001,1.375975743027e+001
    2646,-2.187501181250e+000,-9.100004914000e+001,1.318125711788e+001
    2647,-2.187501181250e+000,-9.100004914000e+001,1.260275680549e+001
    2648,-2.187501181250e+000,-9.100004914000e+001,1.201450648783e+001
    2649,-2.187501181250e+000,-9.100004914000e+001,1.145875618773e+001
    2650,-2.187501181250e+000,-9.100004914000e+001,1.099725593851e+001
    2651,-2.187501181250e+000,-9.100004914000e+001,1.064625574898e+001
    2652,-2.187501181250e+000,-9.162226336397e+001,1.773904321131e+001
    2653,-2.187501181250e+000,-9.135968323659e+001,1.764041120432e+001
    2654,-2.187501181250e+000,-9.112514104631e+001,1.741472592159e+001
    2655,-2.187501181250e+000,-9.101172922024e+001,1.713185646115e+001
    2656,-2.187501181250e+000,-9.506065929325e+001,1.775000958500e+001
    2657,-2.187501181250e+000,-9.475389795271e+001,1.775000958500e+001
    2658,-2.187501181250e+000,-9.434373391310e+001,1.775000958500e+001
    2659,-2.187501181250e+000,-9.383189055275e+001,1.775000958500e+001
    2660,-2.187501181250e+000,-9.327696273446e+001,1.775000958500e+001
    2661,-2.187501181250e+000,-9.274616221262e+001,1.775000958500e+001
    2662,-2.187501181250e+000,-9.228257344516e+001,1.775000958500e+001
    2663,-2.187501181250e+000,-9.190860035023e+001,1.775000958500e+001
    2664,-2.187501181250e+000,-9.590341714831e+001,1.725140835951e+001
    2665,-2.187501181250e+000,-9.570489467758e+001,1.755168543152e+001
    2666,-2.187501181250e+000,-9.537102558142e+001,1.772949407209e+001
    2667,-2.187501181250e+000,-9.678869463215e+001,1.073562858730e+001
    2668,-2.187501181250e+000,-9.674839461039e+001,1.103787875052e+001
    2669,-2.187501181250e+000,-9.669552791517e+001,1.143437896463e+001
    2670,-2.187501181250e+000,-9.662532787726e+001,1.196087924894e+001
    2671,-2.187501181250e+000,-9.654732783514e+001,1.254587956484e+001
    2672,-2.187501181250e+000,-9.647062779373e+001,1.312112987547e+001
    2673,-2.187501181250e+000,-9.639392775231e+001,1.369638018611e+001
    2674,-2.187501181250e+000,-9.631679437732e+001,1.427488049850e+001
    2675,-2.187501181250e+000,-9.623966100234e+001,1.485338081089e+001
    2676,-2.187501181250e+000,-9.616296096092e+001,1.542863112152e+001
    2677,-2.187501181250e+000,-9.608582758593e+001,1.600713143391e+001
    2678,-2.187501181250e+000,-9.601562754803e+001,1.653363171822e+001
    2679,-2.187501181250e+000,-9.596232751924e+001,1.693338193409e+001
    2680,-2.187501181250e+000,-9.469763699981e+001,2.626710178160e+001
    2681,-2.187501181250e+000,-9.448144889737e+001,2.657239626915e+001
    2682,-2.187501181250e+000,-9.415682908369e+001,2.673274391555e+001
    2683,-2.187501181250e+000,-9.545229391049e+001,2.075863399972e+001
    2684,-2.187501181250e+000,-9.540206055003e+001,2.113538420317e+001
    2685,-2.187501181250e+000,-9.533679384812e+001,2.162488446750e+001
    2686,-2.187501181250e+000,-9.526052714027e+001,2.219688477638e+001
    2687,-2.187501181250e+000,-9.518022709691e+001,2.279913510159e+001
    2688,-2.187501181250e+000,-9.509992705355e+001,2.340138542681e+001
    2689,-2.187501181250e+000,-9.501999367705e+001,2.400088575054e+001
    2690,-2.187501181250e+000,-9.494299363547e+001,2.457838606239e+001
    2691,-2.187501181250e+000,-9.486819359508e+001,2.513938636533e+001
    2692,-2.187501181250e+000,-9.480402689376e+001,2.562063662520e+001
    2693,-2.187501181250e+000,-9.475892686941e+001,2.595888680786e+001
    2694,-2.187501181250e+000,-9.487172700907e+001,1.976349663206e+001
    2695,-2.187501181250e+000,-9.516436622484e+001,1.988849855830e+001
    2696,-2.187501181250e+000,-9.539574897685e+001,2.015437496862e+001
    2697,-2.187501181250e+000,-9.547901312041e+001,2.045891908524e+001
    2698,-2.187501181250e+000,-9.190948434484e+001,1.975001066500e+001
    2699,-2.187501181250e+000,-9.228050551457e+001,1.975001066500e+001
    2700,-2.187501181250e+000,-9.273645924122e+001,1.975001066500e+001
    2701,-2.187501181250e+000,-9.325946498650e+001,1.975001066500e+001
    2702,-2.187501181250e+000,-9.378694086635e+001,1.975001066500e+001
    2703,-2.187501181250e+000,-9.423842445843e+001,1.975001066500e+001
    2704,-2.187501181250e+000,-9.458560491043e+001,1.975001066500e+001
    2705,-2.187501181250e+000,-9.101101551369e+001,2.037222488897e+001
    2706,-2.187501181250e+000,-9.112222522248e+001,2.008972187010e+001
    2707,-2.187501181250e+000,-9.135867777745e+001,1.986022302145e+001
    2708,-2.187501181250e+000,-9.162226336397e+001,1.976097703869e+001
    2709,-2.187501181250e+000,-9.100004914000e+001,2.584326395536e+001
    2710,-2.187501181250e+000,-9.100004914000e+001,2.547476375636e+001
    2711,-2.187501181250e+000,-9.100004914000e+001,2.501001350540e+001
    2712,-2.187501181250e+000,-9.100004914000e+001,2.446826321286e+001
    2713,-2.187501181250e+000,-9.100004914000e+001,2.387426289209e+001
    2714,-2.187501181250e+000,-9.100004914000e+001,2.326376256242e+001
    2715,-2.187501181250e+000,-9.100004914000e+001,2.265326223275e+001
    2716,-2.187501181250e+000,-9.100004914000e+001,2.204001190160e+001
    2717,-2.187501181250e+000,-9.100004914000e+001,2.147351159569e+001
    2718,-2.187501181250e+000,-9.100004914000e+001,2.100601134324e+001
    2719,-2.187501181250e+000,-9.100004914000e+001,2.064851115019e+001
    2720,-2.187501181250e+000,-9.162110265016e+001,2.673884643359e+001
    2721,-2.187501181250e+000,-9.135616835983e+001,2.663826024600e+001
    2722,-2.187501181250e+000,-9.112093936125e+001,2.640832885017e+001
    2723,-2.187501181250e+000,-9.101091537860e+001,2.612721974570e+001
    2724,-2.187501181250e+000,-9.386087679512e+001,2.675001444500e+001
    2725,-2.187501181250e+000,-9.355644135883e+001,2.675001444500e+001
    2726,-2.187501181250e+000,-9.316325906104e+001,2.675001444500e+001
    2727,-2.187501181250e+000,-9.270155070564e+001,2.675001444500e+001
    2728,-2.187501181250e+000,-9.226006315413e+001,2.675001444500e+001
    2729,-2.187501181250e+000,-9.190282895214e+001,2.675001444500e+001
    2730,-2.187501181250e+000,-9.338214633674e+001,3.621451199553e+001
    2731,-2.187501181250e+000,-9.325578779987e+001,3.646008680849e+001
    2732,-2.187501181250e+000,-9.302668364639e+001,3.665620350638e+001
    2733,-2.187501181250e+000,-9.278056704404e+001,3.674082254215e+001
    2734,-2.187501181250e+000,-9.425535993082e+001,2.973563884730e+001
    2735,-2.187501181250e+000,-9.421115990695e+001,3.006713902631e+001
    2736,-2.187501181250e+000,-9.414919320682e+001,3.053188927728e+001
    2737,-2.187501181250e+000,-9.407422649967e+001,3.109413958089e+001
    2738,-2.187501181250e+000,-9.399622645755e+001,3.167913989679e+001
    2739,-2.187501181250e+000,-9.391822641543e+001,3.226414021269e+001
    2740,-2.187501181250e+000,-9.384065970688e+001,3.284589052684e+001
    2741,-2.187501181250e+000,-9.376309299832e+001,3.342764084098e+001
    2742,-2.187501181250e+000,-9.368509295620e+001,3.401264115688e+001
    2743,-2.187501181250e+000,-9.360752624765e+001,3.459439147103e+001
    2744,-2.187501181250e+000,-9.353212620694e+001,3.515989177640e+001
    2745,-2.187501181250e+000,-9.347015950681e+001,3.562464202736e+001
    2746,-2.187501181250e+000,-9.342595948294e+001,3.595614220637e+001
    2747,-2.187501181250e+000,-9.366230601117e+001,2.876175284238e+001
    2748,-2.187501181250e+000,-9.393364125768e+001,2.886780850851e+001
    2749,-2.187501181250e+000,-9.417199804702e+001,2.911205062828e+001
    2750,-2.187501181250e+000,-9.427756197442e+001,2.943789566504e+001
    2751,-2.187501181250e+000,-9.193161863001e+001,2.875001552500e+001
    2752,-2.187501181250e+000,-9.237842098625e+001,2.875001552500e+001
    2753,-2.187501181250e+000,-9.290710743964e+001,2.875001552500e+001
    2754,-2.187501181250e+000,-9.335034961775e+001,2.875001552500e+001
    2755,-2.187501181250e+000,-9.101204192724e+001,2.936642939017e+001
    2756,-2.187501181250e+000,-9.112710228421e+001,2.908235899210e+001
    2757,-2.187501181250e+000,-9.136169704195e+001,2.885839069602e+001
    2758,-2.187501181250e+000,-9.162284383930e+001,2.876088176360e+001
    2759,-2.187501181250e+000,-9.100004914000e+001,3.585051935927e+001
    2760,-2.187501181250e+000,-9.100004914000e+001,3.549301916622e+001
    2761,-2.187501181250e+000,-9.100004914000e+001,3.500876890473e+001
    2762,-2.187501181250e+000,-9.100004914000e+001,3.444651860111e+001
    2763,-2.187501181250e+000,-9.100004914000e+001,3.387451829223e+001
    2764,-2.187501181250e+000,-9.100004914000e+001,3.329926798159e+001
    2765,-2.187501181250e+000,-9.100004914000e+001,3.272076766920e+001
    2766,-2.187501181250e+000,-9.100004914000e+001,3.214226735681e+001
    2767,-2.187501181250e+000,-9.100004914000e+001,3.156376704443e+001
    2768,-2.187501181250e+000,-9.100004914000e+001,3.097876672852e+001
    2769,-2.187501181250e+000,-9.100004914000e+001,3.043276643368e+001
    2770,-2.187501181250e+000,-9.100004914000e+001,2.998101618974e+001
    2771,-2.187501181250e+000,-9.100004914000e+001,2.963976600547e+001
    2772,-2.187501181250e+000,-9.162284383930e+001,3.673915360640e+001
    2773,-2.187501181250e+000,-9.135717140015e+001,3.663888356546e+001
    2774,-2.187501181250e+000,-9.112222522248e+001,3.641030863990e+001
    2775,-2.187501181250e+000,-9.101142061214e+001,3.613012673049e+001
    2776,-2.187501181250e+000,-9.251960752441e+001,3.675001984500e+001
    2777,-2.187501181250e+000,-9.220539037911e+001,3.675001984500e+001
    2778,-2.187501181250e+000,-9.189254336671e+001,3.675001984500e+001
    2779,-2.062501113750e+000,-9.340689280598e+001,3.609914228359e+001
    2780,-2.062501113750e+000,-9.266347147902e+001,3.675001984500e+001
    2781,-2.062501113750e+000,-9.427355994064e+001,2.959913877359e+001
    2782,-2.062501113750e+000,-9.353013861368e+001,2.875001552500e+001
    2783,-2.062501113750e+000,-9.175004954500e+001,2.875001552500e+001
    2784,-2.062501113750e+000,-9.100004914000e+001,2.950001593000e+001
    2785,-2.062501113750e+000,-9.100004914000e+001,3.600001944000e+001
    2786,-2.062501113750e+000,-9.175004954500e+001,3.675001984500e+001
    2787,-2.062501113750e+000,-9.474022685931e+001,2.609913688359e+001
    2788,-2.062501113750e+000,-9.399680553235e+001,2.675001444500e+001
    2789,-2.062501113750e+000,-9.547356058864e+001,2.059913391359e+001
    2790,-2.062501113750e+000,-9.473013926168e+001,1.975001066500e+001
    2791,-2.062501113750e+000,-9.175004954500e+001,1.975001066500e+001
    2792,-2.062501113750e+000,-9.100004914000e+001,2.050001107000e+001
    2793,-2.062501113750e+000,-9.100004914000e+001,2.600001404000e+001
    2794,-2.062501113750e+000,-9.175004954500e+001,2.675001444500e+001
    2795,-2.062501113750e+000,-9.606347331502e+001,9.750005265000e+000
    2796,-2.062501113750e+000,-9.680689464198e+001,1.059912851359e+001
    2797,-2.062501113750e+000,-9.175004954500e+001,9.750005265000e+000
    2798,-2.062501113750e+000,-9.100004914000e+001,1.050000567000e+001
    2799,-2.062501113750e+000,-9.100004914000e+001,1.700000918000e+001
    2800,-2.062501113750e+000,-9.175004954500e+001,1.775000958500e+001
    2801,-2.062501113750e+000,-9.519680618035e+001,1.775000958500e+001
    2802,-2.062501113750e+000,-9.594022750731e+001,1.709913202359e+001
    2803,-2.317436751415e+000,-9.350005049000e+001,4.675002524500e+001
    2804,-2.635821923343e+000,-9.350005049000e+001,4.675002524500e+001
    2805,-3.091887169618e+000,-9.350005049000e+001,4.675002524500e+001
    2806,-3.634002462360e+000,-9.350005049000e+001,4.675002524500e+001
    2807,-3.908502110590e+000,-9.368590582174e+001,4.677480595590e+001
    2808,-2.129673650023e+000,-9.387176115348e+001,4.679958666680e+001
    2809,-2.550482377260e+000,-9.387176115348e+001,4.679958666680e+001
    2810,-3.096449672082e+000,-9.387176115348e+001,4.679958666680e+001
    2811,-3.661141477015e+000,-9.387176115348e+001,4.679958666680e+001
    2812,-3.908502110590e+000,-9.353590112902e+001,4.648114545237e+001
    2813,-3.908502110590e+000,-9.361955262006e+001,4.585375926957e+001
    2814,-3.908502110590e+000,-9.372710453711e+001,4.504711989169e+001
    2815,-3.908502110590e+000,-9.383465645416e+001,4.424048051380e+001
    2816,-3.908502110590e+000,-9.393324571146e+001,4.350106108407e+001
