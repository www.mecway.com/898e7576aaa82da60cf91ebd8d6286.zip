   11265,-3.060841475763e+000,-8.937504826250e+001,3.687111025669e+001
   11266,-3.027346302494e+000,-8.937504826250e+001,3.724479944087e+001
   11267,-3.346146910057e+000,-8.937504826250e+001,1.889446651521e+001
   11268,-2.062501113750e+000,-9.583074096027e+001,2.762126234612e+001
   11269,-3.259838266947e+000,-8.937504826250e+001,4.629290499837e+001
   11270,-2.396580537448e+000,-8.937504826250e+001,2.643036416930e+001
   11271,-2.739213982278e+000,-8.937504826250e+001,2.736570815711e+001
   11272,-2.555962060632e+000,-9.392401162925e+001,4.498901239956e+001
   11273,-2.387423705424e+000,-9.387747345743e+001,4.533804868826e+001
   11274,-2.802339319675e+000,-9.385235846299e+001,4.552641114653e+001
   11275,-2.062501113750e+000,-8.999676998969e+001,4.598003096678e+001
   11276,-2.062501113750e+000,-9.013578899910e+001,4.566719893332e+001
   11277,-2.062501113750e+000,-9.032664578454e+001,4.590834893507e+001
   11278,-2.062501113750e+000,-9.037781460210e+001,4.492193459839e+001
   11279,-3.348079398440e+000,-8.937504826250e+001,2.887317911117e+001
   11280,-3.403611666640e+000,-8.937504826250e+001,2.914853454945e+001
   11281,-2.062501113750e+000,-8.974163252009e+001,3.798079961350e+001
   11282,-3.643357480044e+000,-8.937504826250e+001,3.843233267357e+001
   11283,-3.400429380925e+000,-8.937504826250e+001,3.829527619775e+001
   11284,-3.344423833585e+000,-8.937504826250e+001,3.857562500633e+001
   11285,-3.350367886619e+000,-8.937504826250e+001,4.365258621598e+001
   11286,-2.062501113750e+000,-9.078654202920e+001,1.739803155649e+001
   11287,-3.045927493452e+000,-8.937504826250e+001,4.249928162093e+001
   11288,-2.062501113750e+000,-8.967159468258e+001,2.974211519551e+001
   11289,-2.062501113750e+000,-8.993322294133e+001,2.955999210109e+001
   11290,-2.062501113750e+000,-8.937504826250e+001,2.884711238583e+001
   11291,-2.062501113750e+000,-8.937504826250e+001,2.922802542539e+001
   11292,-2.062501113750e+000,-9.017530613266e+001,2.935876721839e+001
   11293,-2.062501113750e+000,-9.356446734790e+001,1.951186774183e+001
   11294,-2.689245005002e+000,-8.937504826250e+001,4.201401273370e+001
   11295,-2.696835919681e+000,-8.937504826250e+001,4.235745985764e+001
   11296,-2.442275376636e+000,-8.937504826250e+001,4.260805472331e+001
   11297,-2.062501113750e+000,-9.180542611565e+001,9.550745278268e+000
   11298,-2.062501113750e+000,-8.963368347931e+001,1.977727554589e+001
   11299,-2.062501113750e+000,-9.007033854315e+001,2.020812696407e+001
   11300,-2.062501113750e+000,-8.937504826250e+001,2.832992449039e+000
   11301,-3.038336578773e+000,-8.937504826250e+001,4.215583449699e+001
   11302,-2.675929812396e+000,-8.937504826250e+001,2.516766471304e+001
   11303,-2.062501113750e+000,-8.973811584916e+001,2.169490056967e+001
   11304,-2.062501113750e+000,-9.239647855928e+001,9.293983109001e+000
   11305,-2.062501113750e+000,-9.821752453428e+001,1.278766561188e+001
   11306,-2.062501113750e+000,-8.996631703374e+001,5.314801614490e+000
   11307,-2.302141299738e+000,-9.375767581094e+001,4.623653103691e+001
   11308,-2.062501113750e+000,-9.029447664665e+001,4.338442702690e+000
   11309,-2.594455810836e+000,-9.824028058211e+001,1.261699525315e+001
   11310,-2.716955477546e+000,-8.937504826250e+001,2.443948634793e+001
   11311,-2.386762487603e+000,-8.937504826250e+001,2.462245148642e+001
   11312,-2.062501113750e+000,-9.507385719885e+001,2.992216301660e+000
   11313,-2.062501113750e+000,-9.550140992608e+001,9.566910156983e+000
   11314,-2.062501113750e+000,-9.534956710412e+001,9.369443806000e+000
   11315,-2.062501113750e+000,-9.527540048698e+001,9.552538914017e+000
   11316,-2.062501113750e+000,-8.968450816856e+001,3.313050340488e+001
   11317,-2.062501113750e+000,-8.968372715078e+001,3.345779689687e+001
   11318,-2.062501113750e+000,-8.937504826250e+001,2.550852162736e+001
   11319,-2.062501113750e+000,-9.551202893847e+001,3.298760204285e+000
   11320,-2.062501113750e+000,-9.680925128171e+001,1.360785601812e+001
   11321,-2.000983348730e+000,-9.076027589164e+001,1.712771994056e+001
   11322,-2.125983416230e+000,-9.089912717769e+001,1.701289344910e+001
   11323,-2.125983416230e+000,-9.074458819482e+001,1.710939852346e+001
   11324,-2.062501113750e+000,-9.215251541994e+001,1.854172115805e+001
   11325,-2.383958851869e+000,-8.937504826250e+001,2.568408515514e+001
   11326,-2.062501113750e+000,-9.010474763194e+001,3.372104143500e+001
   11327,-2.062501113750e+000,-9.720783950028e+001,3.186172975670e+000
   11328,-2.062501113750e+000,-9.689107963182e+001,3.105060815736e+000
   11329,-2.062501113750e+000,-8.998933470005e+001,1.083629359374e+001
   11330,-2.062501113750e+000,-9.008666993784e+001,1.271862800478e+001
   11331,-2.062501113750e+000,-9.232635541273e+001,3.708917855808e+001
   11332,-2.387035070516e+000,-9.699890547584e+001,2.192730855014e+001
   11333,-2.062501113750e+000,-9.498535601190e+001,2.622681746651e+001
   11334,-2.062501113750e+000,-9.515522746472e+001,2.620214953777e+001
   11335,-2.062501113750e+000,-9.495422047786e+001,2.576779731258e+001
   11336,-2.062501113750e+000,-9.243173096775e+001,3.725186977562e+001
   11337,-2.062501113750e+000,-9.250779281508e+001,3.708119243901e+001
   11338,-2.062501113750e+000,-9.516326628757e+001,2.508564704598e+001
   11339,-3.027864942043e+000,-8.937504826250e+001,9.031436023435e+000
   11340,-2.062501113750e+000,-9.509137407255e+001,2.589293893376e+001
   11341,-2.062501113750e+000,-9.504685511502e+001,2.605018126578e+001
   11342,-2.583287602501e+000,-9.678006440948e+001,2.356861654785e+001
   11343,-2.562710907852e+000,-9.672202160396e+001,2.400393758927e+001
   11344,-2.062501113750e+000,-9.555174921148e+001,2.245374208680e+001
   11345,-3.019163806575e+000,-9.530140189750e+001,3.465858538769e+001
   11346,-2.408629831174e+000,-9.535379733378e+001,3.426561961562e+001
   11347,-2.725191883027e+000,-8.937504826250e+001,8.873456271716e+000
   11348,-2.826730720322e+000,-8.937504826250e+001,4.650802830946e+001
   11349,-3.101218265924e+000,-9.591747146740e+001,3.003806361347e+001
   11350,-3.694648415325e+000,-8.937504826250e+001,1.243792734043e+001
   11351,-3.393040096007e+000,-8.937504826250e+001,2.173917269291e+001
   11352,-2.062501113750e+000,-9.038809430397e+001,3.535783193065e+001
   11353,-2.062501113750e+000,-9.053471403799e+001,3.671902682357e+001
   11354,-2.062501113750e+000,-9.031182313881e+001,3.651957365451e+001
   11355,-2.062501113750e+000,-9.061238836162e+001,3.649729857424e+001
   11356,-3.080287951079e+000,-8.937504826250e+001,4.056560068468e+001
   11357,-2.062501113750e+000,-9.078439544427e+001,3.063551961408e+001
   11358,-2.062501113750e+000,-9.702530033143e+001,1.426630393409e+001
   11359,-2.062501113750e+000,-9.750004275434e+001,1.410170276919e+001
   11360,-2.062501113750e+000,-9.761481173029e+001,1.445894597248e+001
   11361,-2.062501113750e+000,-9.772364863686e+001,4.035492537730e+000
   11362,-2.062501113750e+000,-9.047196142381e+001,3.357355763279e+001
   11363,-2.062501113750e+000,-9.382656273528e+001,2.193940789321e+000
   11364,-2.062501113750e+000,-9.009154210225e+001,3.520893500062e+001
   11365,-2.062501113750e+000,-8.968495580512e+001,3.499651332863e+001
   11366,-2.062501113750e+000,-9.014438527907e+001,3.248386661220e+001
   11367,-2.062501113750e+000,-9.687876526831e+001,1.181391390321e+001
   11368,-2.062501113750e+000,-9.685726603769e+001,1.157677602548e+001
   11369,-2.062501113750e+000,-9.409876606193e+001,3.613755010163e+001
   11370,-2.062501113750e+000,-9.615782317705e+001,9.433603165780e+000
   11371,-2.062501113750e+000,-8.970297858890e+001,2.530405960376e+001
   11372,-2.062501113750e+000,-9.044334414746e+001,3.216187951618e+001
   11373,-2.062501113750e+000,-9.078198011310e+001,3.230461155731e+001
   11374,-2.062501113750e+000,-8.937504826250e+001,4.961624140680e+000
   11375,-2.062501113750e+000,-9.241294905849e+001,3.693456083187e+001
   11376,-2.062501113750e+000,-9.426445125460e+001,2.821183000685e+001
   11377,-2.062501113750e+000,-9.413272401396e+001,2.842749740739e+001
   11378,-2.062501113750e+000,-9.647892910882e+001,1.500773391434e+001
   11379,-3.338971939134e+000,-8.937504826250e+001,4.229274121667e+001
   11380,-3.631365691857e+000,-8.937504826250e+001,4.154474696357e+001
   11381,-2.062501113750e+000,-8.970585872474e+001,4.062672879218e+001
   11382,-2.062501113750e+000,-8.968393496147e+001,4.099684820877e+001
   11383,-2.062501113750e+000,-9.004382739649e+001,4.082779424728e+001
   11384,-2.062501113750e+000,-8.971038199414e+001,1.212208737622e+001
   11385,-2.062501113750e+000,-8.971038199414e+001,1.248059376639e+001
   11386,-2.964582353012e+000,-9.379659854741e+001,4.594461051340e+001
   11387,-3.243268883431e+000,-9.378175693122e+001,4.605592263479e+001
   11388,-3.515539867798e+000,-9.429303376384e+001,4.222134639014e+001
   11389,-2.616917824218e+000,-9.466223932212e+001,3.945230470304e+001
   11390,-2.062501113750e+000,-9.667132781661e+001,9.827743518965e+000
   11391,-2.062501113750e+000,-9.653042446768e+001,9.727689910687e+000
   11392,-2.062501113750e+000,-9.695071911753e+001,1.036238035473e+001
   11393,-3.028782314643e+000,-8.937504826250e+001,1.359252889606e+001
   11394,-2.062501113750e+000,-9.385030427338e+001,4.234498537626e+001
   11395,-2.062501113750e+000,-9.346956181833e+001,4.192730869233e+001
   11396,-2.062501113750e+000,-9.391618584592e+001,4.183195700203e+001
   11397,-2.062501113750e+000,-9.132748035875e+001,9.553086968858e+000
   11398,-2.384030514122e+000,-8.937504826250e+001,3.691984348549e+001
   11399,-3.607411854383e+000,-8.937504826250e+001,3.757733326307e+001
   11400,-2.062501113750e+000,-9.292167652140e+001,3.889654666429e+001
   11401,-2.062501113750e+000,-9.339309338952e+001,3.889384317302e+001
   11402,-2.663944643239e+000,-8.937504826250e+001,4.938574222270e+000
   11403,-2.435469637651e+000,-9.412329987357e+001,4.349435056717e+001
   11404,-2.062501113750e+000,-9.410741515777e+001,4.361348593564e+001
   11405,-2.062501113750e+000,-9.343614589443e+001,3.743168554410e+001
   11406,-2.062501113750e+000,-9.235937333827e+001,2.196573300154e+000
   11407,-2.062501113750e+000,-9.250088908463e+001,2.448824964596e+000
   11408,-2.062501113750e+000,-8.937504826250e+001,2.960893846494e+001
   11409,-2.446756066980e+000,-8.937504826250e+001,2.944364995196e+001
   11410,-2.446756066980e+000,-8.937504826250e+001,2.906273691241e+001
   11411,-2.062501113750e+000,-9.085510803233e+001,1.678074901306e+001
   11412,-2.062501113750e+000,-9.080181319414e+001,1.634927843723e+001
   11413,-2.062501113750e+000,-9.053819439638e+001,1.649958141256e+001
   11414,-2.062501113750e+000,-9.019729913729e+001,1.873728664223e+001
   11415,-2.062501113750e+000,-9.018266711195e+001,1.906276524258e+001
   11416,-2.062501113750e+000,-9.136352740072e+001,2.961744937696e+000
   11417,-2.062501113750e+000,-9.139752978970e+001,3.256543468406e+000
   11418,-3.163554036677e+000,-8.937504826250e+001,2.304907880167e+000
   11419,-3.417823323095e+000,-8.937504826250e+001,2.055770095067e+000
   11420,-3.422415226850e+000,-8.937504826250e+001,2.352934282412e+000
   11421,-3.015069818574e+000,-9.955377093075e+001,2.765817638317e+000
   11422,-2.062501113750e+000,-9.783295336600e+001,2.194533662781e+000
   11423,-2.062501113750e+000,-9.537110630091e+001,2.433316639647e+000
   11424,-2.062501113750e+000,-9.353441447981e+001,2.199436489075e+000
   11425,-2.062501113750e+000,-9.337702992653e+001,2.451752434617e+000
   11426,-2.062501113750e+000,-9.369872088803e+001,2.456650804785e+000
   11427,-2.062501113750e+000,-9.702280139136e+001,1.662064213114e+001
   11428,-2.062501113750e+000,-9.276900940301e+001,2.450539257174e+000
   11429,-2.062501113750e+000,-9.263064408642e+001,2.734975458793e+000
   11430,-3.014772980287e+000,-8.937504826250e+001,4.764019308389e+000
   11431,-2.062501113750e+000,-9.649886732723e+001,1.631020495471e+001
   11432,-2.062501113750e+000,-9.090918238706e+001,2.831387152395e+001
   11433,-2.062501113750e+000,-9.365633106669e+001,4.432483141500e+001
   11434,-2.062501113750e+000,-9.010551506266e+001,3.778630595528e+001
   11435,-2.062501113750e+000,-9.005481682984e+001,4.044125902208e+001
   11436,-2.062501113750e+000,-9.037435917310e+001,4.064283591256e+001
   11437,-2.062501113750e+000,-9.082332016802e+001,3.799539730748e+001
   11438,-2.062501113750e+000,-9.443320053826e+001,4.117009558203e+001
   11439,-2.062501113750e+000,-9.450199025722e+001,4.065417268981e+001
   11440,-2.531670431339e+000,-9.443132750302e+001,4.118414334628e+001
   11441,-2.062501113750e+000,-9.586279964934e+001,2.007147580247e+001
   11442,-2.062501113750e+000,-9.130466695679e+001,3.894718568481e+001
   11443,-2.062501113750e+000,-9.126909622443e+001,3.852838538265e+001
   11444,-2.062501113750e+000,-9.461904784913e+001,3.521555801197e+001
   11445,-2.062501113750e+000,-9.403264372412e+001,4.417427168806e+001
   11446,-2.062501113750e+000,-9.550928801307e+001,3.309943952091e+001
   11447,-2.062501113750e+000,-9.492400676690e+001,3.291350736707e+001
   11448,-2.062501113750e+000,-9.378000117292e+001,3.531257901557e+001
   11449,-3.055295448827e+000,-9.503037497617e+001,3.669128729769e+001
   11450,-2.062501113750e+000,-9.068198138754e+001,2.893044322425e+001
   11451,-2.062501113750e+000,-9.244122011428e+001,1.904467618130e+001
   11452,-3.576871942657e+000,-9.424002299045e+001,4.261892719060e+001
   11453,-2.437030177069e+000,-8.937504826250e+001,2.423859735738e+001
   11454,-2.062501113750e+000,-9.020865127457e+001,3.051770928981e+001
   11455,-2.062501113750e+000,-8.999791550113e+001,3.027391242405e+001
   11456,-2.062501113750e+000,-8.976018370686e+001,3.882249505226e+001
   11457,-2.062501113750e+000,-8.937504826250e+001,3.904213785632e+001
   11458,-2.062501113750e+000,-8.997370709566e+001,2.221909708160e+001
   11459,-3.340285565733e+000,-8.937504826250e+001,3.743316171594e+001
   11460,-3.039850968376e+000,-8.937504826250e+001,3.755122800610e+001
   11461,-2.062501113750e+000,-9.099260687847e+001,2.801069974652e+001
   11462,-3.667386422918e+000,-8.937504826250e+001,2.929311969646e+001
   11463,-2.062501113750e+000,-9.002425142608e+001,2.152355426378e+001
   11464,-2.062501113750e+000,-9.079381863283e+001,2.560726496554e+001
   11465,-2.062501113750e+000,-9.070631655823e+001,1.688687561732e+001
   11466,-2.062501113750e+000,-9.065302172004e+001,1.670565517662e+001
   11467,-2.062501113750e+000,-9.080181319414e+001,1.659952857236e+001
   11468,-2.062501113750e+000,-9.693303904786e+001,1.113654295685e+001
   11469,-2.062501113750e+000,-9.688803272097e+001,1.134602590087e+001
   11470,-2.540499743026e+000,-9.548529654021e+001,3.327937556740e+001
   11471,-2.062501113750e+000,-9.073651018675e+001,1.417122259035e+001
   11472,-2.062501113750e+000,-8.968333840407e+001,8.442879191848e+000
   11473,-2.062501113750e+000,-9.011984837426e+001,1.414936454866e+001
   11474,-2.062501113750e+000,-9.007801103019e+001,1.450710919947e+001
   11475,-2.062501113750e+000,-9.407739072143e+001,8.726885571067e+000
   11476,-2.062501113750e+000,-9.431446485051e+001,8.399996803616e+000
   11477,-2.062501113750e+000,-9.436026439324e+001,8.737144713412e+000
   11478,-2.062501113750e+000,-8.966318828450e+001,5.131402553847e+000
   11479,-2.062501113750e+000,-9.032318474166e+001,5.893274352991e+000
   11480,-2.062501113750e+000,-9.073551523171e+001,3.286760078844e+001
   11481,-2.554238904438e+000,-9.812440023428e+001,1.348609786184e+001
   11482,-2.062501113750e+000,-9.411269784113e+001,1.808390663775e+001
   11483,-2.062501113750e+000,-9.410796316680e+001,1.832484285516e+001
   11484,-2.062501113750e+000,-9.418564602012e+001,8.048383301870e+000
   11485,-2.062501113750e+000,-9.394857189104e+001,8.375272069321e+000
   11486,-2.062501113750e+000,-9.635017253120e+001,1.992540081929e+001
   11487,-2.062501113750e+000,-9.661463418920e+001,1.966068184493e+001
   11488,-2.062501113750e+000,-9.297793886021e+001,1.848586638453e+001
   11489,-2.062501113750e+000,-9.574450164168e+001,1.771216182554e+001
   11490,-3.570463873842e+000,-8.937504826250e+001,2.042962710179e+000
   11491,-2.062501113750e+000,-9.245084314564e+001,1.797902082647e+001
   11492,-2.062501113750e+000,-8.968602450129e+001,1.282537000203e+001
   11493,-2.062501113750e+000,-9.414263805016e+001,1.862644887811e+001
   11494,-2.062501113750e+000,-9.064402730300e+001,1.151659218786e+001
   11495,-2.062501113750e+000,-9.428247854979e+001,2.683087971204e+001
   11496,-2.062501113750e+000,-9.450915101245e+001,2.676084184651e+001
   11497,-2.062501113750e+000,-9.845368001312e+001,1.101649952055e+001
   11498,-2.062501113750e+000,-9.850751544535e+001,1.061273377881e+001
   11499,-2.062501113750e+000,-9.372077322984e+001,2.834899537058e+001
   11500,-2.062501113750e+000,-9.491019053589e+001,2.937557589332e+001
   11501,-2.062501113750e+000,-9.512482978136e+001,2.942390986426e+001
   11502,-2.062501113750e+000,-9.031021395813e+001,1.091761518615e+001
   11503,-2.062501113750e+000,-9.015630070757e+001,1.122696829662e+001
   11504,-2.062501113750e+000,-9.519649753700e+001,2.570858127717e+001
   11505,-2.062501113750e+000,-9.154976533547e+001,2.700848610367e+001
   11506,-2.062501113750e+000,-9.136108268047e+001,2.693638151184e+001
   11507,-2.062501113750e+000,-9.151942312583e+001,2.685121456336e+001
   11508,-2.062501113750e+000,-9.040719107180e+001,1.137737669292e+001
   11509,-3.052572621306e+000,-8.937504826250e+001,3.355152102123e+001
   11510,-2.062501113750e+000,-9.400143827901e+001,1.792951497905e+001
   11511,-2.062501113750e+000,-9.044992135056e+001,3.076530891097e+001
   11512,-2.062501113750e+000,-9.014921727074e+001,3.078957831595e+001
   11513,-3.039181759877e+000,-8.937504826250e+001,2.081342318418e+001
   11514,-2.062501113750e+000,-9.489100151024e+001,2.606528972033e+001
   11515,-2.062501113750e+000,-9.414453841988e+001,4.035564186200e+001
   11516,-2.062501113750e+000,-9.376128930237e+001,4.049146125699e+001
   11517,-2.062501113750e+000,-9.638163649963e+001,1.714774417804e+001
   11518,-2.062501113750e+000,-9.634836491996e+001,1.731774792568e+001
   11519,-2.062501113750e+000,-9.615846503600e+001,1.736027987279e+001
   11520,-2.062501113750e+000,-9.653554517586e+001,1.697512111242e+001
   11521,-2.062501113750e+000,-9.396233000471e+001,3.446776993752e+001
   11522,-2.062501113750e+000,-9.390633702991e+001,1.844077590637e+001
   11523,-2.062501113750e+000,-9.691830466734e+001,1.080266243006e+001
   11524,-2.062501113750e+000,-8.972838521832e+001,1.398479448599e+001
   11525,-3.497043896121e+000,-9.613058153434e+001,2.843973811138e+001
   11526,-2.717398632749e+000,-8.937504826250e+001,3.707139998593e+001
   11527,-2.683903459479e+000,-8.937504826250e+001,3.744508917011e+001
   11528,-3.204207996056e+000,-9.601477723176e+001,2.930827038075e+001
   11529,-3.091050410112e+000,-9.596938099857e+001,2.964874212967e+001
   11530,-2.554238904438e+000,-9.818415129931e+001,1.303796487413e+001
   11531,-3.068277674451e+000,-9.819148671188e+001,1.298294927984e+001
   11532,-2.062501113750e+000,-9.288803870789e+001,3.947036847239e+001
   11533,-2.062501113750e+000,-9.343474855644e+001,3.936927517124e+001
   11534,-3.501311232907e+000,-9.872176092790e+001,9.005892659710e+000
   11535,-2.062501113750e+000,-9.056218435746e+001,2.501460174789e+001
   11536,-2.062501113750e+000,-9.670503291040e+001,2.413135279095e+001
   11537,-2.062501113750e+000,-9.078887145958e+001,2.537205248795e+001
   11538,-2.062501113750e+000,-9.082274344571e+001,2.514955336394e+001
   11539,-2.062501113750e+000,-9.058264095241e+001,2.547430368078e+001
   11540,-2.062501113750e+000,-9.321844675342e+001,2.760940476847e+000
   11541,-2.062501113750e+000,-9.419429535919e+001,9.520564257606e+000
   11542,-3.224818188304e+000,-9.406601300609e+001,4.392400207330e+001
   11543,-3.631829535548e+000,-8.937504826250e+001,5.338966885399e+000
   11544,-2.062501113750e+000,-9.104942038326e+001,4.196918492718e+001
   11545,-2.062501113750e+000,-8.968393496147e+001,4.142257454710e+001
   11546,-2.062501113750e+000,-8.937504826250e+001,4.121558284673e+001
   11547,-2.062501113750e+000,-9.042411144189e+001,4.183313357768e+001
   11548,-2.062501113750e+000,-8.937504826250e+001,2.662885409665e+001
   11549,-2.062501113750e+000,-9.366632825337e+001,9.011311605552e+000
   11550,-2.062501113750e+000,-9.007702069504e+001,4.204781584253e+001
   11551,-2.062501113750e+000,-8.972079448811e+001,4.222565104773e+001
   11552,-2.062501113750e+000,-8.970841309705e+001,4.258019543118e+001
   11553,-2.062501113750e+000,-9.556683219979e+001,8.648705217636e+000
   11554,-2.062501113750e+000,-9.078181129280e+001,1.506148517882e+001
   11555,-2.062501113750e+000,-9.613370305314e+001,2.572854129668e+001
   11556,-2.062501113750e+000,-9.523866939751e+001,8.556804424213e+000
   11557,-2.062501113750e+000,-9.485130468053e+001,9.307901306285e+000
   11558,-2.062501113750e+000,-9.512456599961e+001,9.338838453625e+000
   11559,-2.062501113750e+000,-9.464493767133e+001,6.659612961319e+000
   11560,-2.062501113750e+000,-9.367011161529e+001,3.571227440274e+001
   11561,-2.062501113750e+000,-9.358634863734e+001,3.590311107417e+001
   11562,-2.062501113750e+000,-9.401077529976e+001,3.650443137491e+001
   11563,-2.062501113750e+000,-9.402682668809e+001,3.629271376483e+001
   11564,-2.062501113750e+000,-9.380842915665e+001,3.630665669255e+001
   11565,-2.062501113750e+000,-9.385067111785e+001,3.616281774577e+001
   11566,-2.062501113750e+000,-9.059409552175e+001,2.910397145025e+001
   11567,-2.062501113750e+000,-9.115410696387e+001,2.795803399866e+001
   11568,-2.062501113750e+000,-9.096662039491e+001,2.776033918135e+001
   11569,-2.062501113750e+000,-9.125387710131e+001,2.772908915077e+001
   11570,-2.062501113750e+000,-9.003963997441e+001,2.815117116030e+001
   11571,-2.062501113750e+000,-9.388448548275e+001,3.588225914437e+001
   11572,-2.062501113750e+000,-9.392261049170e+001,3.600765408256e+001
   11573,-2.062501113750e+000,-8.967986074062e+001,3.652522611694e+001
   11574,-2.062501113750e+000,-8.966386245587e+001,1.760523769827e+001
   11575,-2.062501113750e+000,-9.045614983603e+001,3.411439591267e+001
   11576,-2.062501113750e+000,-9.040605398009e+001,3.383745988473e+001
   11577,-2.062501113750e+000,-9.096425687326e+001,1.927153718500e+001
   11578,-2.062501113750e+000,-9.186175517300e+001,1.896344522625e+001
   11579,-3.795914995586e+000,-8.937504826250e+001,2.042962710179e+000
   11580,-3.795914995586e+000,-8.937504826250e+001,2.222215905264e+000
   11581,-2.741543227225e+000,-8.937504826250e+001,3.783617376891e+001
   11582,-2.062501113750e+000,-9.618525474382e+001,3.895046797837e+000
   11583,-2.062501113750e+000,-9.653105386966e+001,3.766439342458e+000
   11584,-2.062501113750e+000,-9.625719989926e+001,3.596159441877e+000
   11585,-2.062501113750e+000,-9.182843476951e+001,3.747485499482e+001
   11586,-2.062501113750e+000,-9.042813899716e+001,3.754438372931e+001
   11587,-2.062501113750e+000,-9.039934324298e+001,3.720157246295e+001
   11588,-2.062501113750e+000,-9.376459718851e+001,2.790736125488e+001
   11589,-2.062501113750e+000,-9.385323089809e+001,2.750575457414e+001
   11590,-2.062501113750e+000,-9.396630604465e+001,2.734602421155e+001
   11591,-3.490339725567e+000,-9.578362473804e+001,3.104191408363e+001
   11592,-3.340839027841e+000,-8.937504826250e+001,1.435877810476e+001
   11593,-3.639838663470e+000,-8.937504826250e+001,1.357790418876e+001
   11594,-2.062501113750e+000,-9.247683266654e+001,3.014003842810e+000
   11595,-2.062501113750e+000,-9.219837697545e+001,3.004229205074e+000
   11596,-2.062501113750e+000,-9.401256951417e+001,3.057097716487e+000
   11597,-2.062501113750e+000,-9.748025229266e+001,1.094292495757e+001
   11598,-2.062501113750e+000,-8.937504826250e+001,2.779399986470e+001
   11599,-2.062501113750e+000,-9.438366774895e+001,1.920914439393e+001
   11600,-2.062501113750e+000,-9.044291515158e+001,2.083096208675e+001
   11601,-2.062501113750e+000,-9.495360518805e+001,3.277307237672e+000
   11602,-2.062501113750e+000,-8.968654787426e+001,1.434253913681e+001
   11603,-2.062501113750e+000,-8.967015976667e+001,1.689751296921e+001
   11604,-2.062501113750e+000,-9.264596154456e+001,2.834265797074e+001
   11605,-2.062501113750e+000,-8.966386245587e+001,1.722432465871e+001
   11606,-2.062501113750e+000,-9.017221033604e+001,2.093522996481e+001
   11607,-2.062501113750e+000,-9.034284909846e+001,2.106887591935e+001
   11608,-3.263486265539e+000,-8.937504826250e+001,2.469079153195e+000
   11609,-3.442754030298e+000,-8.937504826250e+001,2.678032906121e+000
   11610,-2.062501113750e+000,-9.078198011310e+001,3.201536140111e+001
   11611,-2.062501113750e+000,-9.060462479976e+001,3.951712302079e+001
   11612,-2.062501113750e+000,-9.008234011933e+001,3.934541382677e+001
   11613,-2.062501113750e+000,-9.072121528983e+001,3.915348673436e+001
   11614,-2.062501113750e+000,-9.019893060940e+001,3.898177754033e+001
   11615,-2.062501113750e+000,-9.387319157307e+001,3.865691762641e+001
   11616,-3.032823592020e+000,-8.937504826250e+001,4.441073446269e+001
   11617,-2.062501113750e+000,-9.635465438408e+001,1.946925132399e+001
   11618,-2.062501113750e+000,-9.355856661620e+001,2.733231033234e+000
   11619,-3.500149271886e+000,-9.707081150621e+001,2.138801332234e+001
   11620,-3.500149271886e+000,-9.711866522375e+001,2.102911044080e+001
   11621,-2.062501113750e+000,-9.677068459422e+001,1.389710617432e+001
   11622,-3.199149157960e+000,-9.658003659467e+001,2.506882515891e+001
   11623,-2.998453952162e+000,-9.663032901959e+001,2.469163197200e+001
   11624,-2.062501113750e+000,-9.527937317549e+001,5.554064405607e+000
   11625,-2.062501113750e+000,-9.513627775709e+001,5.006603629106e+000
   11626,-2.062501113750e+000,-9.383008436523e+001,3.740011380601e+001
   11627,-2.062501113750e+000,-9.498062049212e+001,2.556979720566e+001
   11628,-2.062501113750e+000,-9.657729318850e+001,1.415787274163e+001
   11629,-3.575055777598e+000,-8.937504826250e+001,2.340126897524e+000
   11630,-2.062501113750e+000,-9.162763173434e+001,3.007725747366e+000
   11631,-2.062501113750e+000,-9.264864951729e+001,2.781961008285e+001
   11632,-2.062501113750e+000,-8.963368347931e+001,1.941876915572e+001
   11633,-2.062501113750e+000,-9.201459958593e+001,3.314848708053e+000
   11634,-2.062501113750e+000,-9.087584355694e+001,2.764097294838e+000
   11635,-2.062501113750e+000,-9.107386163574e+001,2.437587649574e+000
   11636,-2.062501113750e+000,-9.124552166528e+001,2.663131098892e+000
   11637,-2.062501113750e+000,-9.799576247655e+001,9.271279697304e+000
   11638,-2.062501113750e+000,-9.833969744292e+001,8.953120012596e+000
   11639,-2.062501113750e+000,-9.409080283179e+001,2.701481673739e+001
   11640,-2.062501113750e+000,-9.173689259438e+001,2.781185229168e+001
   11641,-2.062501113750e+000,-9.152007805270e+001,2.784959619785e+001
   11642,-2.062501113750e+000,-9.094353512450e+001,2.173998824840e+000
   11643,-2.062501113750e+000,-9.122085512049e+001,2.200315298345e+000
   11644,-2.062501113750e+000,-9.004037489906e+001,2.045868348069e+001
   11645,-2.062501113750e+000,-9.436080656336e+001,3.019270991430e+001
   11646,-2.062501113750e+000,-9.315322697433e+001,3.707156031024e+001
   11647,-2.062501113750e+000,-9.299421299624e+001,3.713565432450e+001
   11648,-2.062501113750e+000,-9.314041716183e+001,3.725973666659e+001
   11649,-2.062501113750e+000,-9.683357369439e+001,2.316729691101e+001
   11650,-2.062501113750e+000,-9.689929986592e+001,2.267435062452e+001
   11651,-2.062501113750e+000,-9.551374888289e+001,2.305551829947e+001
   11652,-2.390963880816e+000,-8.937504826250e+001,3.726953458261e+001
   11653,-2.062501113750e+000,-9.425278596794e+001,2.442810266058e+000
   11654,-2.062501113750e+000,-9.138831529831e+001,2.434050028484e+000
   11655,-2.390963880816e+000,-8.937504826250e+001,3.760563432339e+001
   11656,-2.062501113750e+000,-8.970585872474e+001,4.029062905140e+001
   11657,-2.062501113750e+000,-8.972079448811e+001,4.184473800817e+001
   11658,-2.062501113750e+000,-9.430798923578e+001,1.901036243224e+001
   11659,-3.670970681413e+000,-8.937504826250e+001,3.584892852509e+000
   11660,-3.388223590224e+000,-8.937504826250e+001,4.140923748002e+001
   11661,-2.733126982933e+000,-8.937504826250e+001,1.556975910860e+001
   11662,-2.387560202681e+000,-8.937504826250e+001,2.168748914436e+001
   11663,-2.062501113750e+000,-9.265325899681e+001,2.188978138054e+000
   11664,-2.381217788223e+000,-8.937504826250e+001,8.717047466616e+000
   11665,-2.062501113750e+000,-9.115205468174e+001,2.750974421438e+001
   11666,-3.026955573947e+000,-8.937504826250e+001,7.965712320740e+000
   11667,-2.062501113750e+000,-9.333912346114e+001,8.985811471233e+000
   11668,-2.062501113750e+000,-9.039511607404e+001,2.938561911943e+001
   11669,-2.062501113750e+000,-9.058252946398e+001,2.945563476653e+001
   11670,-2.062501113750e+000,-9.059178559430e+001,2.929399739280e+001
   11671,-2.062501113750e+000,-9.433520717128e+001,1.809937273247e+001
   11672,-2.062501113750e+000,-9.446533374513e+001,1.790440124370e+001
   11673,-2.062501113750e+000,-9.007822647985e+001,1.780526947825e+001
   11674,-2.062501113750e+000,-8.970112986671e+001,4.438386296908e+001
   11675,-2.062501113750e+000,-9.474254820985e+001,2.684174059248e+001
   11676,-2.062501113750e+000,-9.604472012028e+001,8.979627703501e+000
   11677,-2.062501113750e+000,-9.583268354531e+001,8.992370602529e+000
   11678,-2.388888166954e+000,-8.937504826250e+001,4.332960938901e+001
   11679,-2.442275376636e+000,-8.937504826250e+001,4.296656111348e+001
   11680,-2.062501113750e+000,-9.092543178899e+001,1.823084263360e+001
   11681,-3.522758280874e+000,-9.830773080945e+001,1.211111854811e+001
   11682,-2.062501113750e+000,-8.968709648732e+001,2.274960122559e+001
   11683,-2.062501113750e+000,-9.465837385089e+001,2.707350293645e+001
   11684,-2.062501113750e+000,-9.486040954136e+001,2.729244583553e+001
   11685,-2.062501113750e+000,-9.591908815862e+001,2.685792773702e+001
   11686,-2.062501113750e+000,-8.968249901382e+001,2.309157370098e+001
   11687,-2.062501113750e+000,-9.254938818171e+001,2.720238041458e+001
   11688,-2.062501113750e+000,-8.937504826250e+001,4.491267999537e+001
   11689,-2.062501113750e+000,-8.966503897865e+001,4.514358929352e+001
   11690,-2.062501113750e+000,-9.164700398240e+001,2.687358425539e+001
   11691,-2.062501113750e+000,-8.974163252009e+001,3.842893260122e+001
   11692,-2.062501113750e+000,-9.021437375943e+001,3.855860381839e+001
   11693,-2.062501113750e+000,-9.220228205542e+001,3.731892396275e+001
   11694,-2.062501113750e+000,-9.210888454658e+001,3.751705101960e+001
   11695,-2.062501113750e+000,-8.937504826250e+001,3.940064424649e+001
   11696,-2.062501113750e+000,-8.976018370686e+001,3.918100144243e+001
   11697,-2.062501113750e+000,-8.971610725835e+001,2.421385171016e+001
   11698,-2.062501113750e+000,-8.967168949991e+001,2.603167987894e+001
   11699,-3.333109143328e+000,-8.937504826250e+001,4.455110236486e+001
   11700,-2.062501113750e+000,-9.133710145438e+001,2.679064197784e+001
   11701,-2.062501113750e+000,-9.055195099335e+001,2.617205311902e+001
   11702,-2.062501113750e+000,-8.965129841168e+001,4.639151885483e+001
   11703,-2.062501113750e+000,-9.065276434575e+001,2.588121777438e+001
   11704,-2.062501113750e+000,-9.005757595280e+001,9.377376953943e+000
   11705,-2.062501113750e+000,-9.000212943515e+001,8.989417332121e+000
   11706,-2.062501113750e+000,-9.032341132093e+001,9.150464257797e+000
   11707,-2.062501113750e+000,-9.411455907139e+001,2.685988034756e+000
   11708,-2.062501113750e+000,-9.386842437952e+001,2.763672015484e+000
   11709,-2.062501113750e+000,-9.470062447952e+001,2.946567574770e+001
   11710,-2.062501113750e+000,-8.968333840407e+001,8.778978932633e+000
   11711,-2.062501113750e+000,-9.754458362556e+001,1.327638579276e+001
   11712,-2.062501113750e+000,-9.679105353465e+001,1.325307867878e+001
   11713,-2.062501113750e+000,-9.669422294318e+001,3.474310525329e+000
   11714,-2.062501113750e+000,-9.642036897278e+001,3.304030624748e+000
   11715,-3.108903656278e+000,-8.937504826250e+001,2.055770095067e+000
   11716,-2.062501113750e+000,-8.973369095945e+001,3.089577937093e+001
   11717,-2.062501113750e+000,-9.114240345556e+001,3.710670407420e+001
   11718,-3.357253740893e+000,-9.962357298120e+001,2.242302259985e+000
   11719,-3.343423406238e+000,-8.937504826250e+001,4.032120758738e+001
   11720,-2.062501113750e+000,-9.324915907396e+001,4.061124730998e+001
   11721,-2.062501113750e+000,-8.937504826250e+001,4.345624778530e+001
   11722,-2.062501113750e+000,-9.063249562993e+001,5.279539509810e+000
   11723,-3.032570711552e+000,-8.937504826250e+001,4.093916998592e+001
   11724,-3.090031850754e+000,-8.937504826250e+001,4.121104028386e+001
   11725,-2.728698886400e+000,-8.937504826250e+001,4.122152155253e+001
   11726,-2.062501113750e+000,-9.060622758942e+001,2.569976148495e+001
   11727,-2.441182212875e+000,-8.937504826250e+001,2.130585053210e+001
   11728,-2.062501113750e+000,-8.970297858890e+001,2.566256599394e+001
   11729,-2.546224099490e+000,-9.784604870208e+001,1.557373435336e+001
   11730,-2.062501113750e+000,-9.036840222015e+001,4.649870319556e+001
   11731,-2.062501113750e+000,-9.575997947257e+001,8.739895118599e+000
   11732,-2.062501113750e+000,-9.451404424290e+001,8.113834418904e+000
   11733,-2.062501113750e+000,-9.487217823992e+001,8.197363075956e+000
   11734,-2.062501113750e+000,-9.299110641050e+001,6.083171975713e+000
   11735,-2.062501113750e+000,-9.286902783631e+001,6.809178347841e+000
   11736,-2.062501113750e+000,-8.999393197672e+001,1.559021746151e+001
   11737,-2.062501113750e+000,-9.028176559203e+001,1.572023038669e+001
   11738,-2.062501113750e+000,-9.274226480159e+001,7.255120892812e+000
   11739,-2.062501113750e+000,-9.193246205972e+001,3.949869445253e+000
   11740,-2.062501113750e+000,-9.529779744071e+001,1.899000516799e+001
   11741,-2.062501113750e+000,-9.533268538415e+001,1.867735629839e+001
   11742,-2.062501113750e+000,-9.509709180502e+001,1.882763317641e+001
   11743,-2.062501113750e+000,-9.511242706184e+001,1.808046866852e+001
   11744,-2.062501113750e+000,-9.502090848455e+001,9.552538914017e+000
   11745,-2.062501113750e+000,-9.557856409259e+001,1.871022045729e+001
   11746,-2.062501113750e+000,-9.029968230382e+001,5.102228207843e+000
   11747,-2.062501113750e+000,-9.067813381150e+001,4.904912033653e+000
   11748,-2.062501113750e+000,-9.510532767872e+001,1.862128915361e+001
   11749,-2.062501113750e+000,-9.518218229953e+001,1.841338486219e+001
   11750,-2.062501113750e+000,-8.937504826250e+001,2.257325055784e+001
   11751,-2.062501113750e+000,-8.937504826250e+001,2.290935029862e+001
   11752,-2.062501113750e+000,-9.618401367844e+001,2.062497015127e+001
   11753,-2.388062040145e+000,-8.937504826250e+001,1.686498273935e+001
   11754,-2.062501113750e+000,-8.937504826250e+001,1.706121480896e+001
   11755,-2.393115168986e+000,-8.937504826250e+001,1.723683835001e+001
   11756,-2.062501113750e+000,-9.029074789719e+001,4.706200850120e+000
   11757,-3.609568464131e+000,-8.937504826250e+001,3.869248390259e+001
   11758,-2.062501113750e+000,-9.337488918487e+001,3.720138277749e+001
   11759,-2.062501113750e+000,-9.330011949184e+001,3.661423428379e+001
   11760,-3.641375821940e+000,-8.937504826250e+001,3.726228090404e+001
   11761,-2.062501113750e+000,-8.937504826250e+001,2.329026333818e+001
   11762,-2.062501113750e+000,-9.152473930942e+001,2.758931675019e+001
   11763,-2.062501113750e+000,-9.174155385110e+001,2.755157284402e+001
   11764,-2.062501113750e+000,-9.490970152034e+001,2.592503964460e+001
   11765,-3.376058721631e+000,-8.937504826250e+001,3.655416126150e+001
   11766,-3.649030112344e+000,-8.937504826250e+001,3.217654663314e+001
   11767,-3.597241329301e+000,-9.821125599322e+001,1.283467966981e+001
   11768,-3.143695494218e+000,-9.823700289839e+001,1.264157788099e+001
   11769,-3.597241329301e+000,-9.826210056810e+001,1.245334535817e+001
   11770,-2.725279202787e+000,-8.937504826250e+001,1.774331338982e+001
   11771,-2.393115168986e+000,-8.937504826250e+001,1.761775138956e+001
   11772,-2.062501113750e+000,-9.551840700556e+001,2.704079925711e+000
   11773,-2.062501113750e+000,-9.261892265536e+001,3.349120245524e+000
   11774,-2.062501113750e+000,-9.289662342543e+001,2.727727444916e+000
   11775,-2.062501113750e+000,-9.275825810883e+001,3.012163646535e+000
   11776,-2.062501113750e+000,-9.596896167308e+001,5.368682578846e+000
   11777,-2.062501113750e+000,-9.581013359532e+001,5.985023240739e+000
   11778,-3.499788968742e+000,-9.500751840550e+001,3.686271157769e+001
   11779,-2.062501113750e+000,-9.270281586959e+001,1.797831129631e+001
   11780,-2.062501113750e+000,-9.433047249694e+001,1.834030894987e+001
   11781,-2.062501113750e+000,-8.937504826250e+001,1.923465979937e+001
   11782,-2.386169283909e+000,-8.937504826250e+001,1.941394875742e+001
   11783,-2.062501113750e+000,-9.620689584164e+001,1.643876907535e+001
   11784,-2.062501113750e+000,-9.584439153646e+001,2.704060953573e+000
   11785,-2.062501113750e+000,-9.599997619567e+001,2.990417056308e+000
   11786,-2.062501113750e+000,-9.534453727331e+001,2.989582597187e+000
   11787,-3.040371367068e+000,-9.950745874965e+001,3.113158996543e+000
   11788,-2.062501113750e+000,-9.292622019265e+001,3.339193286742e+000
   11789,-3.583311755411e+000,-9.440111173753e+001,4.141076158749e+001
   11790,-3.583311755411e+000,-9.444896545507e+001,4.105185870595e+001
   11791,-3.066980540830e+000,-9.442316556106e+001,4.124535791097e+001
   11792,-2.062501113750e+000,-9.274229328268e+001,4.030842294527e+001
   11793,-2.062501113750e+000,-9.407582469509e+001,4.087099479787e+001
   11794,-2.062501113750e+000,-9.358897754489e+001,4.090182162052e+001
   11795,-2.062501113750e+000,-9.540946167698e+001,2.335105729117e+001
   11796,-2.062501113750e+000,-9.567221277405e+001,2.376834531851e+001
   11797,-2.394655726360e+000,-8.937504826250e+001,2.982346083031e+001
   11798,-2.062501113750e+000,-9.074226020599e+001,2.751394341992e+001
   11799,-2.062501113750e+000,-9.536949498874e+001,2.365080745304e+001
   11800,-2.062501113750e+000,-9.208203640125e+001,5.623421939461e+000
   11801,-3.692768382281e+000,-8.937504826250e+001,4.041016532300e+001
   11802,-3.639011661113e+000,-8.937504826250e+001,1.705517133557e+001
   11803,-3.645611271497e+000,-8.937504826250e+001,1.735081451041e+001
   11804,-2.062501113750e+000,-9.021278826212e+001,1.840096993185e+001
   11805,-2.062501113750e+000,-9.087185936842e+001,9.400069331766e+000
   11806,-2.388062040145e+000,-8.937504826250e+001,1.646166305041e+001
   11807,-2.062501113750e+000,-9.031963636772e+001,5.481326655354e+000
   11808,-2.062501113750e+000,-9.454301396184e+001,1.806890759729e+001
   11809,-2.062501113750e+000,-9.540954000496e+001,1.846945200696e+001
   11810,-2.062501113750e+000,-9.526094269853e+001,1.824666824115e+001
   11811,-2.578973045665e+000,-9.510654871538e+001,3.611998425356e+001
   11812,-2.062501113750e+000,-9.605421401817e+001,1.755753306287e+001
   11813,-2.062501113750e+000,-9.589453268139e+001,1.757398468761e+001
   11814,-2.062501113750e+000,-9.503366666285e+001,1.824718528956e+001
   11815,-2.062501113750e+000,-9.052931193267e+001,3.630333514213e+001
   11816,-2.062501113750e+000,-9.531302296790e+001,1.804428929640e+001
   11817,-2.062501113750e+000,-8.937504826250e+001,6.418056350750e+000
   11818,-2.062501113750e+000,-9.412514538068e+001,3.752900777732e+000
   11819,-2.062501113750e+000,-9.502760775125e+001,2.843706881238e+001
   11820,-2.062501113750e+000,-9.471953001522e+001,2.816935498418e+001
   11821,-2.062501113750e+000,-9.180201230289e+001,2.737329769941e+001
   11822,-2.062501113750e+000,-9.163874239040e+001,2.738221123751e+001
   11823,-2.062501113750e+000,-9.194205267808e+001,2.761088226905e+001
   11824,-2.062501113750e+000,-9.802923598935e+001,1.419982969882e+001
   11825,-2.062501113750e+000,-9.042995412453e+001,2.909632071483e+001
   11826,-2.062501113750e+000,-9.021014418315e+001,2.906946881379e+001
   11827,-2.062501113750e+000,-9.505516238933e+001,2.964343854014e+001
   11828,-2.062501113750e+000,-9.099544398334e+001,2.858035962245e+001
   11829,-3.347618648309e+000,-8.937504826250e+001,3.371138683572e+001
   11830,-2.062501113750e+000,-9.484047365881e+001,1.825677442030e+001
   11831,-2.062501113750e+000,-9.170607818520e+001,2.702160758719e+001
   11832,-2.062501113750e+000,-9.160608102932e+001,2.717248957959e+001
   11833,-2.569219973761e+000,-9.560289711182e+001,3.239737128031e+001
   11834,-2.062501113750e+000,-9.172710304802e+001,9.154508931530e+000
   11835,-3.048719247707e+000,-9.679383681364e+001,2.346532351663e+001
   11836,-2.576832475699e+000,-9.925503543354e+001,5.006333867402e+000
   11837,-2.062501113750e+000,-9.048829594240e+001,4.622710929742e+001
   11838,-2.062501113750e+000,-9.062144259306e+001,4.647843134686e+001
   11839,-3.607381975042e+000,-8.937504826250e+001,4.526743943251e+001
   11840,-3.028020039903e+000,-8.937504826250e+001,2.241745410909e+001
   11841,-2.062501113750e+000,-9.198045537800e+001,1.913291233190e+001
   11842,-3.603322103174e+000,-8.937504826250e+001,3.043253518983e+001
   11843,-2.062501113750e+000,-9.653872650101e+001,1.444712289783e+001
   11844,-2.062501113750e+000,-9.178932867173e+001,2.721998798958e+001
   11845,-2.062501113750e+000,-9.210657948861e+001,2.776906478354e+001
   11846,-2.062501113750e+000,-9.196814807044e+001,2.784131470379e+001
   11847,-3.034231665460e+000,-8.937504826250e+001,5.705010627439e+000
   11848,-3.332429875681e+000,-8.937504826250e+001,2.547435206112e+001
   11849,-3.326051351114e+000,-8.937504826250e+001,2.518375305229e+001
   11850,-2.062501113750e+000,-9.612857809810e+001,1.998329558495e+001
   11851,-2.062501113750e+000,-9.372827010769e+001,3.040252243934e+000
   11852,-2.062501113750e+000,-9.346770815682e+001,4.129057719079e+000
   11853,-2.439591029533e+000,-8.937504826250e+001,1.245043241935e+001
   11854,-2.062501113750e+000,-9.667863697011e+001,2.213975483379e+000
   11855,-2.062501113750e+000,-9.654908543476e+001,2.470380012923e+000
   11856,-2.062501113750e+000,-8.937504826250e+001,1.746453449790e+001
   11857,-3.345540762537e+000,-8.937504826250e+001,1.860657065496e+001
   11858,-2.000983348730e+000,-9.089912717769e+001,1.701289344910e+001
   11859,-2.062501113750e+000,-9.041306038543e+001,1.816313130975e+001
   11860,-2.062501113750e+000,-9.290498551354e+001,8.396238717447e+000
   11861,-2.062501113750e+000,-9.077563358355e+001,3.678379415437e+001
   11862,-2.722034526625e+000,-8.937504826250e+001,3.040456302483e+001
   11863,-2.062501113750e+000,-9.656187361207e+001,9.259502943305e+000
   11864,-2.062501113750e+000,-9.653041268291e+001,9.550271573254e+000
   11865,-2.062501113750e+000,-9.046606822185e+001,1.678029183560e+001
   11866,-2.062501113750e+000,-9.297354251094e+001,3.734080619258e+001
   11867,-2.685835001135e+000,-8.937504826250e+001,1.154770072259e+001
   11868,-2.062501113750e+000,-9.424192774417e+001,4.260464153765e+001
   11869,-2.062501113750e+000,-9.639869821506e+001,2.193131003155e+000
   11870,-2.062501113750e+000,-9.542039571707e+001,6.122593345646e+000
   11871,-2.062501113750e+000,-9.393026825216e+001,4.334859744783e+000
   11872,-2.062501113750e+000,-9.377812324443e+001,3.818937582670e+000
   11873,-2.062501113750e+000,-9.073629539232e+001,3.509453693994e+001
   11874,-3.626017254758e+000,-9.866051663622e+001,9.465224847268e+000
   11875,-3.079134464475e+000,-9.457361236842e+001,4.011700685578e+001
   11876,-3.477418288888e+000,-9.459950070384e+001,3.992284434014e+001
   11877,-2.062501113750e+000,-9.397191741137e+001,2.445851053567e+000
   11878,-2.062501113750e+000,-9.069671868302e+001,1.705314077789e+001
   11879,-2.062501113750e+000,-9.082563005592e+001,4.362424435977e+001
   11880,-2.062501113750e+000,-8.937504826250e+001,4.240313526418e+001
   11881,-2.062501113750e+000,-9.570350955438e+001,2.903924987363e+001
   11882,-2.062501113750e+000,-9.607429902802e+001,2.886185690881e+001
   11883,-2.062501113750e+000,-8.937504826250e+001,4.276164165435e+001
   11884,-3.037749019162e+000,-9.714639727992e+001,2.082112001952e+001
   11885,-2.062501113750e+000,-8.968495580512e+001,3.537742636818e+001
   11886,-2.062501113750e+000,-9.682918688857e+001,1.296707852434e+001
   11887,-2.062501113750e+000,-9.695535235375e+001,1.264446585983e+001
   11888,-2.062501113750e+000,-9.760433469058e+001,1.282825280504e+001
   11889,-2.062501113750e+000,-9.651749579631e+001,1.471848375814e+001
   11890,-2.062501113750e+000,-9.077879862851e+001,4.319925866741e+001
   11891,-2.062501113750e+000,-9.652069451910e+001,1.746530325843e+001
   11892,-2.652553260863e+000,-9.829163925319e+001,1.223180522004e+001
   11893,-2.062501113750e+000,-9.796034969213e+001,1.154441341411e+001
   11894,-2.062501113750e+000,-9.840289160785e+001,1.139741256011e+001
   11895,-2.062501113750e+000,-9.568257372442e+001,9.566910156983e+000
   11896,-3.486280417754e+000,-9.940975273254e+001,3.845954124897e+000
   11897,-2.908476501682e+000,-9.415587243555e+001,4.325005635233e+001
   11898,-2.062501113750e+000,-9.272354869127e+001,4.590241218306e+001
   11899,-2.062501113750e+000,-9.278533923887e+001,4.569890805093e+001
   11900,-2.062501113750e+000,-9.302635529101e+001,4.597918495089e+001
   11901,-2.062501113750e+000,-8.937504826250e+001,9.667020511676e+000
   11902,-2.578973045665e+000,-9.516032467391e+001,3.571666456462e+001
   11903,-2.062501113750e+000,-9.319905335313e+001,4.597659452493e+001
   11904,-3.285587471933e+000,-9.753412429175e+001,1.791316743084e+001
   11905,-2.062501113750e+000,-8.968372715078e+001,3.379389663766e+001
   11906,-2.062501113750e+000,-9.614184984468e+001,1.796972092093e+001
   11907,-2.062501113750e+000,-9.635739469880e+001,1.790020783457e+001
   11908,-2.062501113750e+000,-9.618198177746e+001,1.770566792409e+001
   11909,-3.690292956618e+000,-8.937504826250e+001,2.190772465201e+001
   11910,-2.062501113750e+000,-9.876459701333e+001,8.684622018942e+000
   11911,-2.724731910072e+000,-8.937504826250e+001,4.492491892183e+001
   11912,-2.691087594770e+000,-8.937504826250e+001,4.165565682550e+001
   11913,-3.595240708196e+000,-8.937504826250e+001,3.101699302277e+001
   11914,-2.062501113750e+000,-9.007004385302e+001,2.438752562549e+001
   11915,-2.711180285933e+000,-8.937504826250e+001,4.458816006912e+001
   11916,-2.062501113750e+000,-9.729539102609e+001,1.157207685180e+001
   11917,-2.062501113750e+000,-9.617309582338e+001,1.669226921224e+001
   11918,-2.062501113750e+000,-9.572605882306e+001,2.095930900356e+001
   11919,-2.439735236857e+000,-8.937504826250e+001,1.799973937430e+001
   11920,-3.080234935166e+000,-8.937504826250e+001,1.838884967725e+001
   11921,-3.106493735101e+000,-8.937504826250e+001,2.928174693163e+001
   11922,-3.025023431093e+000,-8.937504826250e+001,2.306715961694e+001
   11923,-2.395291351107e+000,-8.937504826250e+001,2.868586607777e+001
   11924,-2.062501113750e+000,-9.053200106909e+001,2.960280875550e+001
   11925,-3.638757804325e+000,-8.937504826250e+001,3.386955383654e+001
   11926,-2.553853265790e+000,-9.944324785056e+001,3.594740739755e+000
   11927,-2.397499511429e+000,-9.951284919826e+001,3.072730632009e+000
   11928,-2.836392680821e+000,-9.946307239766e+001,3.446056636516e+000
   11929,-3.644693449496e+000,-8.937504826250e+001,4.442107368473e+001
   11930,-2.062501113750e+000,-9.077942977559e+001,6.851575437347e+000
   11931,-2.949974694967e+000,-8.937504826250e+001,2.171914965850e+000
   11932,-3.641266176423e+000,-8.937504826250e+001,2.789219147394e+001
   11933,-2.062501113750e+000,-8.937504826250e+001,7.874488560821e+000
   11934,-2.062501113750e+000,-9.038445227562e+001,1.405531734751e+001
   11935,-2.974155126692e+000,-9.580742482093e+001,3.086341346201e+001
   11936,-3.665300854989e+000,-8.937504826250e+001,1.819231547286e+001
   11937,-3.402270251490e+000,-8.937504826250e+001,1.833393860635e+001
   11938,-2.062501113750e+000,-9.073292439684e+001,1.250593810202e+001
   11939,-2.531670431339e+000,-9.436858888474e+001,4.165468298338e+001
   11940,-3.608571366036e+000,-8.937504826250e+001,1.873382731410e+001
   11941,-2.062501113750e+000,-9.039288128445e+001,3.505688632151e+001
   11942,-2.062501113750e+000,-9.179144469807e+001,8.871506692968e+000
   11943,-2.062501113750e+000,-9.608095729372e+001,7.754401039233e+000
   11944,-2.390496119025e+000,-8.937504826250e+001,1.906651997001e+001
   11945,-2.062501113750e+000,-9.003226789644e+001,3.596054662569e+001
   11946,-2.062501113750e+000,-9.437046191998e+001,4.164063521913e+001
   11947,-3.645005813282e+000,-8.937504826250e+001,1.448296748702e+001
   11948,-2.062501113750e+000,-9.474822106240e+001,2.901673919306e+001
   11949,-2.062501113750e+000,-9.386381837011e+001,3.445787211956e+000
   11950,-3.392165141446e+000,-8.937504826250e+001,4.058535842554e+001
   11951,-3.338748679483e+000,-8.937504826250e+001,4.084518130375e+001
   11952,-2.062501113750e+000,-9.242910948905e+001,3.870177801915e+001
   11953,-2.062501113750e+000,-9.239547167554e+001,3.927559982725e+001
   11954,-2.062501113750e+000,-9.109073009014e+001,7.463292232964e+000
   11955,-2.062501113750e+000,-9.126244190932e+001,9.057684984827e+000
   11956,-2.062501113750e+000,-9.394393441801e+001,7.695203857056e+000
   11957,-2.062501113750e+000,-9.253598795079e+001,8.991949551559e+000
   11958,-2.062501113750e+000,-9.039657249509e+001,9.426823041331e+000
   11959,-2.372895915941e+000,-9.731352052416e+001,1.956769568776e+001
   11960,-2.062501113750e+000,-9.691596686428e+001,1.963976330237e+001
   11961,-2.062501113750e+000,-9.733270775484e+001,1.675231263425e+001
   11962,-2.062501113750e+000,-9.479065569626e+001,3.561646667604e+001
   11963,-3.535611391524e+000,-8.937504826250e+001,4.654728277962e+001
   11964,-2.062501113750e+000,-9.389387936064e+001,2.771267004993e+001
   11965,-2.062501113750e+000,-8.937504826250e+001,3.516578751260e+001
   11966,-2.062501113750e+000,-8.937504826250e+001,1.381225064803e+001
   11967,-2.062501113750e+000,-8.968151507045e+001,2.867411835866e+001
   11968,-3.600727760400e+000,-8.937504826250e+001,4.410564297091e+001
   11969,-2.062501113750e+000,-9.234707766476e+001,2.727853348613e+000
   11970,-3.336919099306e+000,-8.937504826250e+001,4.424142284307e+001
   11971,-3.566734176603e+000,-9.732166502968e+001,1.950661189633e+001
   11972,-2.062501113750e+000,-9.440342773879e+001,7.256047325475e+000
   11973,-2.062501113750e+000,-9.602755946378e+001,9.056311561162e+000
   11974,-2.062501113750e+000,-9.589271066914e+001,9.216638806960e+000
   11975,-2.062501113750e+000,-9.041010617397e+001,3.680610085979e+001
   11976,-2.062501113750e+000,-9.288031000143e+001,3.685601353484e+001
   11977,-2.062501113750e+000,-8.937504826250e+001,4.078985650841e+001
   11978,-2.062501113750e+000,-9.659637580236e+001,7.964035482103e+000
   11979,-2.125983416230e+000,-9.075418607002e+001,1.694313336289e+001
   11980,-2.662411557954e+000,-9.594902087599e+001,2.980144304902e+001
   11981,-2.062501113750e+000,-9.230765761043e+001,3.748161518030e+001
   11982,-2.062501113750e+000,-9.569529197529e+001,2.022438263569e+001
   11983,-2.062501113750e+000,-9.348254798344e+001,3.632006744955e+001
   11984,-2.062501113750e+000,-9.301812601201e+001,3.694986951085e+001
   11985,-2.062501113750e+000,-9.176065029646e+001,3.258648468975e+000
   11986,-3.611381950365e+000,-9.377704294979e+001,4.609127749549e+001
   11987,-2.062501113750e+000,-8.937504826250e+001,3.328362896420e+001
   11988,-2.062501113750e+000,-9.712964703020e+001,1.094013643448e+001
   11989,-2.062501113750e+000,-9.695513905979e+001,1.097079286734e+001
   11990,-2.062501113750e+000,-9.763566409323e+001,1.181195551210e+001
   11991,-2.062501113750e+000,-9.071508521610e+001,2.942317120212e+001
   11992,-2.062501113750e+000,-9.555408223800e+001,2.275301813612e+001
   11993,-2.000983348730e+000,-9.075033570359e+001,1.696951997263e+001
   11994,-2.062501113750e+000,-9.695905093095e+001,2.222621763681e+001
   11995,-2.062501113750e+000,-9.406145848732e+001,2.846927025074e+001
   11996,-2.062501113750e+000,-9.759277236659e+001,1.747330686956e+001
   11997,-2.062501113750e+000,-9.191589967059e+001,2.981745766831e+000
   11998,-2.062501113750e+000,-9.179355295841e+001,2.707556420896e+000
   11999,-2.062501113750e+000,-9.439542762796e+001,2.682947247247e+000
   12000,-2.393606164389e+000,-8.937504826250e+001,4.511650968206e+001
   12001,-2.720028630099e+000,-8.937504826250e+001,1.925277668619e+001
   12002,-2.062501113750e+000,-9.230303634211e+001,3.775020340442e+001
   12003,-2.062501113750e+000,-9.196070763492e+001,3.771455064289e+001
   12004,-2.062501113750e+000,-9.547634026770e+001,9.140575749803e+000
   12005,-2.062501113750e+000,-9.539960169447e+001,8.865542753551e+000
   12006,-2.062501113750e+000,-9.789203460980e+001,2.722786774539e+000
   12007,-2.062501113750e+000,-9.783432119137e+001,3.094008855283e+000
   12008,-2.550219232609e+000,-9.398864896785e+001,4.450423236008e+001
   12009,-2.062501113750e+000,-9.559274896726e+001,8.956732654514e+000
   12010,-2.062501113750e+000,-9.595921361142e+001,3.554591111604e+000
   12011,-2.062501113750e+000,-9.584148332993e+001,3.299613635545e+000
   12012,-2.062501113750e+000,-9.612483451003e+001,3.259447980062e+000
   12013,-2.062501113750e+000,-9.169818656308e+001,3.931229581595e+001
   12014,-2.062501113750e+000,-9.393763636428e+001,3.703836425101e+001
   12015,-2.062501113750e+000,-9.097259345727e+001,2.006625767119e+001
   12016,-2.062501113750e+000,-9.073150841183e+001,3.539548254908e+001
   12017,-2.062501113750e+000,-9.001705686244e+001,3.557986413426e+001
   12018,-2.062501113750e+000,-9.017983288446e+001,2.571617861534e+001
   12019,-3.041706028564e+000,-8.937504826250e+001,1.164211886260e+001
   12020,-2.062501113750e+000,-8.937504826250e+001,3.823549847844e+001
   12021,-2.062501113750e+000,-9.436005613029e+001,3.041443011474e+001
   12022,-2.062501113750e+000,-9.432018944209e+001,3.071343027620e+001
   12023,-2.062501113750e+000,-9.258754907469e+001,3.743080969407e+001
   12024,-2.062501113750e+000,-9.223998335239e+001,2.855761405664e+001
   12025,-2.062501113750e+000,-9.567051115371e+001,2.000944048796e+001
   12026,-2.779124045500e+000,-8.937504826250e+001,2.663033429244e+001
   12027,-2.062501113750e+000,-9.476286972428e+001,2.929494193294e+001
   12028,-3.277706366162e+000,-9.744962918585e+001,1.854688072511e+001
   12029,-2.062501113750e+000,-9.726550692880e+001,1.717831612780e+001
   12030,-2.062501113750e+000,-9.541236068580e+001,2.930450944050e+001
   12031,-2.062501113750e+000,-9.695560056531e+001,1.704664562469e+001
   12032,-2.062501113750e+000,-9.085109166885e+001,2.968499144322e+001
   12033,-2.062501113750e+000,-9.802867673587e+001,4.756131482099e+000
   12034,-2.062501113750e+000,-9.783510209842e+001,8.911879625691e+000
   12035,-2.062501113750e+000,-9.738920973989e+001,8.666474620876e+000
   12036,-2.062501113750e+000,-9.085478655693e+001,2.953958313810e+001
   12037,-2.062501113750e+000,-9.070582908578e+001,2.958480857585e+001
   12038,-2.062501113750e+000,-8.937504826250e+001,3.292512257403e+001
   12039,-2.062501113750e+000,-9.634226571901e+001,1.614506745718e+001
   12040,-2.062501113750e+000,-9.628623279529e+001,1.750841473401e+001
   12041,-2.062501113750e+000,-9.619972496021e+001,2.095456788753e+001
   12042,-2.062501113750e+000,-8.992254052975e+001,1.924804126878e+001
   12043,-2.062501113750e+000,-9.152944862479e+001,2.661575611226e+000
   12044,-2.062501113750e+000,-9.265682092305e+001,9.279873452201e+000
   12045,-2.062501113750e+000,-9.748223274490e+001,3.096924630013e+000
   12046,-2.062501113750e+000,-9.756299408202e+001,3.496279240140e+000
   12047,-2.062501113750e+000,-9.073277785971e+001,1.531029492096e+001
   12048,-2.540499743026e+000,-9.554504760523e+001,3.283124257969e+001
   12049,-2.062501113750e+000,-8.937504826250e+001,1.193009209963e+001
   12050,-2.062501113750e+000,-9.567052180421e+001,2.989563625049e+000
   12051,-2.062501113750e+000,-9.177777174107e+001,1.920624660720e+001
   12052,-2.387035070516e+000,-9.693915441081e+001,2.237544153786e+001
   12053,-2.660665249066e+000,-9.689601090136e+001,2.269901785878e+001
   12054,-2.062501113750e+000,-9.026927872256e+001,3.619164421268e+001
   12055,-2.062501113750e+000,-8.937504826250e+001,4.567450607449e+001
   12056,-2.412178311817e+000,-8.937504826250e+001,4.546402758621e+001
   12057,-2.062501113750e+000,-8.937504826250e+001,4.531599968432e+001
   12058,-2.062501113750e+000,-9.058733491460e+001,4.592706024611e+001
   12059,-2.062501113750e+000,-9.029105173538e+001,2.833247742454e+001
   12060,-2.062501113750e+000,-8.959573486246e+001,4.582840106587e+001
   12061,-2.062501113750e+000,-9.473317559973e+001,2.757796028193e+001
   12062,-2.439591029533e+000,-8.937504826250e+001,1.209192602917e+001
   12063,-2.062501113750e+000,-9.025638266050e+001,1.789511937917e+001
   12064,-2.478053476187e+000,-9.743617866823e+001,1.864775960720e+001
   12065,-2.062501113750e+000,-9.253017801263e+001,2.855369339180e+001
   12066,-2.062501113750e+000,-9.629267197169e+001,9.273275919982e+000
   12067,-2.062501113750e+000,-9.597548545087e+001,2.073578898665e+001
   12068,-2.062501113750e+000,-9.562234009053e+001,1.834179511814e+001
   12069,-2.062501113750e+000,-9.545070374760e+001,1.821452950141e+001
   12070,-2.062501113750e+000,-9.446010929502e+001,7.682909432672e+000
   12071,-2.062501113750e+000,-9.250407339338e+001,9.521553870355e+000
   12072,-2.062501113750e+000,-9.289484519599e+001,4.211092266450e+001
   12073,-2.062501113750e+000,-9.087377769005e+001,2.038350562091e+001
   12074,-2.062501113750e+000,-9.579136417816e+001,1.858256356847e+001
   12075,-2.062501113750e+000,-9.250310024484e+001,3.771556391256e+001
   12076,-2.062501113750e+000,-9.249847897652e+001,3.798415213669e+001
   12077,-2.062501113750e+000,-9.734838588503e+001,3.819649457452e+000
   12078,-2.062501113750e+000,-9.510238630984e+001,2.985305458649e+001
   12079,-2.062501113750e+000,-9.699323130330e+001,3.509543192983e+000
   12080,-3.608516993248e+000,-9.742631963331e+001,1.872170236916e+001
   12081,-2.062501113750e+000,-8.996836562585e+001,2.590685273279e+001
   12082,-2.062501113750e+000,-9.142030791526e+001,2.807854104575e+001
   12083,-2.733233096751e+000,-8.937504826250e+001,1.192265878538e+001
   12084,-2.392192933917e+000,-8.937504826250e+001,1.171696796639e+001
   12085,-3.616398099019e+000,-9.756160314448e+001,1.770707603533e+001
   12086,-2.062501113750e+000,-9.108101943826e+001,4.281175823016e+001
   12087,-2.062501113750e+000,-9.609903889554e+001,9.256352556071e+000
   12088,-2.062501113750e+000,-9.411827904397e+001,2.773390827856e+001
   12089,-2.062501113750e+000,-9.125438745272e+001,8.779295878449e+000
   12090,-2.062501113750e+000,-9.625425858126e+001,8.141169769286e+000
   12091,-3.069212445791e+000,-9.828263313974e+001,1.229935107092e+001
   12092,-3.151530493183e+000,-9.944350964193e+001,3.592777304464e+000
   12093,-2.062501113750e+000,-9.592659672853e+001,8.151763106075e+000
   12094,-2.062501113750e+000,-9.403344836333e+001,2.751540631390e+001
   12095,-2.062501113750e+000,-9.089555008904e+001,2.025758790690e+001
   12096,-2.062501113750e+000,-9.455984378562e+001,8.450982328700e+000
   12097,-3.607793922361e+000,-8.937504826250e+001,9.341560245605e+000
   12098,-3.643094161748e+000,-8.937504826250e+001,9.583507528732e+000
   12099,-2.062501113750e+000,-8.937504826250e+001,2.405208941729e+001
   12100,-2.062501113750e+000,-9.076651142779e+001,2.007089827486e+001
   12101,-3.493225075909e+000,-9.846312010369e+001,1.094569884129e+001
   12102,-2.062501113750e+000,-9.554750486364e+001,2.017509225904e+001
   12103,-3.665574011471e+000,-8.937504826250e+001,3.812084865199e+001
   12104,-2.062501113750e+000,-9.007481231268e+001,3.628847606752e+001
   12105,-2.062501113750e+000,-9.349207731400e+001,4.139224418759e+001
   12106,-2.062501113750e+000,-8.999244565596e+001,9.747185113736e+000
   12107,-2.062501113750e+000,-8.973878492172e+001,9.547851594011e+000
   12108,-2.062501113750e+000,-9.036767331631e+001,1.467711777550e+001
   12109,-2.062501113750e+000,-9.518648688175e+001,3.552044800584e+001
   12110,-2.062501113750e+000,-8.937504826250e+001,2.996744485511e+001
   12111,-2.062501113750e+000,-8.937504826250e+001,2.185623777749e+001
   12112,-2.062501113750e+000,-9.397892446420e+001,4.136141736493e+001
   12113,-2.062501113750e+000,-9.560603897435e+001,2.036943302884e+001
   12114,-2.583287602501e+000,-9.684579058101e+001,2.307567026136e+001
   12115,-2.062501113750e+000,-9.065850353637e+001,2.976126059297e+001
   12116,-2.062501113750e+000,-9.080746100751e+001,2.985578523068e+001
   12117,-2.062501113750e+000,-9.068564455747e+001,3.873468643220e+001
   12118,-2.062501113750e+000,-9.379053957153e+001,4.599005283247e+001
   12119,-2.062501113750e+000,-9.633834895574e+001,9.464077686365e+000
   12120,-2.062501113750e+000,-9.619754106635e+001,9.614051530853e+000
   12121,-2.062501113750e+000,-9.633836074051e+001,9.641496023798e+000
   12122,-3.646928552000e+000,-8.937504826250e+001,2.475855255843e+001
   12123,-2.062501113750e+000,-8.974677311583e+001,4.611399662779e+001
   12124,-2.062501113750e+000,-9.245566944167e+001,2.699397801815e+001
   12125,-2.062501113750e+000,-9.073771339770e+001,3.089796333690e+001
   12126,-3.611249249979e+000,-8.937504826250e+001,2.159805922086e+001
   12127,-2.062501113750e+000,-8.937504826250e+001,1.228859848980e+001
   12128,-3.646928552000e+000,-8.937504826250e+001,2.444485946704e+001
   12129,-3.648432661247e+000,-8.937504826250e+001,3.070240619795e+001
   12130,-3.689512962410e+000,-8.937504826250e+001,3.671259364046e+001
   12131,-2.062501113750e+000,-9.513265144952e+001,3.592421374758e+001
   12132,-2.062501113750e+000,-9.223322332405e+001,7.461431857074e+000
   12133,-2.443526579933e+000,-8.937504826250e+001,4.140424772326e+001
*ELEMENT, TYPE=C3D10, ELSET=Eall
     1,  1445,   923,  1167,  1454,  8736,  4009,  8735,  5109,  8738,  8737 
     2,  1426,  1454,  1167,  1587,  5761,  8737,  8739,  5480,  5762,  8740 
     3,   133,   479,  1445,  1446,  6615,  5077,  8741,  8742,  5078,  5497 
     4,  1940,  2085,  2061,  1941,  8744,  8658,  8743,  7565,  8746,  8745 
     5,  2078,  2147,  1951,  2066,  8497,  8748,  8747,  8681,  8678,  8749 
     6,   913,    41,  1465,  1455,  8751,  5136,  8750,  8752,  5111,  5137 
     7,  1151,  1121,   932,  1479,  4591,  3888,  4462,  8753,  8755,  8754 
     8,   518,   146,   147,   935,  6495,  2279,  6499,  8756,  3222,  3221 
     9,  1823,  1865,   689,  1780,  8757,  8758,  6844,  7057,  8759,  7058 
    10,   201,   200,  1141,  1600,  2344,  3811,  3810,  8760,  8762,  8761 
    11,  1122,  1297,  1508,   937,  4519,  8764,  8763,  3889,  4520,  8765 
    12,   386,  1822,  1863,  1864,  8766,  8767,  7373,  7372,  8768,  7221 
    13,   393,   964,  1519,   965,  8769,  8771,  5399,  8770,  3903,  8772 
    14,  1486,  1677,  1495,   952,  5911,  5910,  5535,  8773,  8775,  8774 
    15,   407,   263,     3,    32,  8777,  4265,  8776,  8778,  2411,  2492 
    16,    41,  1465,   503,  1111,  5136,  5135,  2663,  8779,  8781,  8780 
    17,  1154,  1018,  1565,   405,  3963,  8784,  8782,  8783,  8785,  5414 
    18,  1925,  2163,  2006,  2095,  8786,  8788,  7911,  8787,  8573,  8789 
    19,   407,  1396,  1397,  1092,  4964,  4968,  4967,  8790,  8792,  8791 
    20,  1717,  1260,  1004,  1553,  8794,  4474,  8793,  6337,  8796,  8795 
    21,   770,   849,   771,  2001,  8168,  8153,  2982,  7744,  8797,  7745 
    22,   262,   405,   261,  1809,  8798,  8799,  2409,  6945,  8800,  6946 
    23,   928,  1485,  1717,  1475,  8802,  6120,  8801,  8803,  5529,  6121 
    24,   959,  1675,  1717,  1485,  8805,  6134,  8804,  8806,  5907,  6120 
    25,   661,  1895,   719,   662,  7312,  8807,  6795,  2867,  7313,  6794 
    26,   928,   959,  1717,  1485,  3866,  8804,  8801,  8802,  8806,  6120 
    27,  1675,   959,  1717,  1260,  8805,  8804,  6134,  8808,  4309,  8794 
    28,   503,  1465,  1464,  1111,  5135,  5138,  5133,  8780,  8781,  8809 
    29,   971,  1539,   972,   193,  8810,  8811,  3802,  3293,  8812,  3296 
    30,  1090,  1592,  1156,  1271,  8813,  8814,  3964,  4476,  8815,  4349 
    31,  1994,  2089,   843,  2158,  8817,  8267,  8816,  8818,  8508,  8414 
    32,  2058,   442,   316,  2128,  8819,  8820,  8205,  8541,  8821,  8350 
    33,    89,   475,   474,  1440,  6605,  2630,  6606,  8822,  5061,  5060 
    34,  1162,  1549,  1469,  1435,  8824,  5686,  8823,  8825,  5954,  5496 
    35,  1592,  1271,  1239,  1635,  8815,  4491,  8826,  5773,  8828,  8827 
    36,  1239,  1271,  1203,  1635,  4491,  4348,  4758,  8827,  8828,  8829 
    37,  1676,  1293,  1257,  1677,  8831,  4666,  8830,  6109,  8833,  8832 
    38,  1233,  1589,  1427,  1083,  8835,  5611,  8834,  4235,  8837,  8836 
    39,  1090,  1239,  1592,  1271,  4254,  8826,  8813,  4476,  4491,  8815 
    40,    56,   578,  1526,   211,  2751,  5297,  5296,  6446,  6445,  8838 
    41,  1227,  1228,  1654,  1582,  4221,  8841,  8839,  8840,  8842,  6021 
    42,  1765,  1761,  1762,  1359,  6405,  6347,  6403,  8843,  8845,  8844 
    43,  1552,   376,  1002,  1384,  5375,  8847,  8846,  5639,  4935,  8848 
    44,  2027,  2173,  2105,  1909,  8850,  8583,  8849,  7883,  8852,  8851 
    45,  1610,  1316,  1728,  1727,  8853,  8854,  6155,  6153,  8855,  6157 
    46,  1331,  1760,  1332,  1360,  8856,  8857,  4681,  4831,  8858,  4829 
    47,  1332,  1634,  1749,  1760,  8860,  6283,  8859,  8857,  6343,  6353 
    48,  1431,  1271,  1592,  1635,  8861,  8815,  5636,  5772,  8828,  5773 
    49,   892,  1440,  1640,  1641,  8863,  5785,  8862,  8864,  5787,  5789 
    50,   323,   449,  2061,  2132,  8865,  8866,  8210,  8359,  8867,  8482 
    51,  1846,   671,  1771,  1813,  8869,  6827,  8868,  8870,  6958,  7072 
    52,   892,  1440,   474,  1439,  8863,  5060,  8871,  8872,  5062,  5058 
    53,  1115,   128,   488,   489,  3718,  6633,  8873,  8874,  6632,  2646 
    54,  1501,   948,   164,   551,  8876,  3248,  8875,  5234,  8877,  6553 
    55,  1585,   919,  1077,  1076,  8879,  4000,  8878,  8880,  4003,  3606 
    56,  1477,  1476,  1119,  1554,  5172,  8882,  8881,  5818,  5817,  8883 
    57,   375,   376,  1002,  1552,  2528,  8847,  8884,  5376,  5375,  8846 
    58,  1119,  1476,  1475,  1554,  8882,  5169,  8885,  8883,  5817,  5903 
    59,  1691,  1455,  1277,  1709,  5948,  8887,  8886,  6070,  6069,  8888 
    60,  1895,  1798,   360,  1795,  8889,  8891,  7325,  8890,  7022,  8892 
    61,  2146,  2067,  2137,  1952,  8682,  8550,  8683,  8893,  8895,  8894 
    62,   378,   379,  1826,   237,  2531,  8898,  8896,  8897,  8899,  7036 
    63,  1277,  1293,  1299,  1676,  4601,  4654,  4545,  8900,  8831,  8901 
    64,   123,   918,  1113,  1593,  3184,  3882,  3715,  8902,  8904,  8903 
    65,   113,  1461,   499,   498,  8905,  5125,  6653,  6654,  5124,  2658 
    66,  1463,   501,  1110,  1594,  5130,  8907,  8906,  5616,  5510,  8908 
    67,  1144,  1576,  1185,  1699,  8909,  8911,  4361,  8910,  6204,  8912 
    68,   953,  1487,  1488,   534,  8914,  5201,  8913,  8915,  5197,  5199 
    69,  1960,   729,   811,  2073,  7622,  8012,  8916,  8917,  8918,  8235 
    70,   461,  1590,  1085,  1428,  5488,  8920,  8919,  5033,  5612,  8921 
    71,   738,   819,  1969,  1968,  8101,  8922,  7648,  7646,  8923,  7650 
    72,  1673,  1672,  1251,  1300,  6076,  8926,  8924,  8925,  8927,  4548 
    73,   169,  1487,   953,   534,  8928,  8914,  3258,  6529,  5197,  8915 
    74,  1486,   533,  1487,  1131,  5195,  5196,  5198,  8929,  8931,  8930 
    75,  1632,  1630,  1234,  1428,  5766,  8933,  8932,  5765,  5750,  8934 
    76,   576,  1523,   215,  1524,  5291,  8935,  6442,  5292,  5560,  8936 
    77,   392,  1807,  1856,  1857,  8937,  8938,  7385,  7431,  8939,  7200 
    78,  1046,  1047,  1573,   420,  3517,  8942,  8940,  8941,  8943,  5435 
    79,   521,   520,   136,  1476,  2684,  6502,  6506,  5168,  5167,  8944 
    80,  1191,  1192,  1637,  1546,  4103,  8947,  8945,  8946,  8948,  5778 
    81,  1734,  1259,  1258,  1674,  8950,  4521,  8949,  6189,  8952,  8951 
    82,  1437,   471,   890,  1436,  5051,  8954,  8953,  5053,  5050,  8955 
    83,   531,  1483,   530,   174,  5189,  5188,  2695,  6522,  8956,  6523 
    84,   311,  1063,   436,   437,  3563,  8959,  8957,  8958,  8960,  2590 
    85,   943,   542,   155,    50,  8961,  6547,  3237,  8962,  2709,  6548 
    86,  1437,   471,   472,    86,  5051,  2627,  5052,  8963,  6600,  6602 
    87,  2091,  2126,  2160,  1930,  8639,  8718,  8510,  8964,  8966,  8965 
    88,   153,   940,   553,   152,  3231,  8967,  6573,  2287,  3232,  6570 
    89,  2050,  1919,  2098,  1920,  8968,  8970,  8622,  8969,  7502,  8971 
    90,  1125,  1579,  1062,   944,  8972,  8973,  4030,  3942,  8974,  4029 
    91,  1569,   409,  1035,  1402,  5425,  8976,  8975,  5593,  4982,  8977 
    92,  2053,  1924,  2123,  2095,  8978,  8979,  8536,  8623,  8980,  8624 
    93,  2124,   433,  1926,   434,  8982,  7518,  8981,  8983,  2587,  7519 
    94,  1078,  1586,  1115,   920,  8984,  8985,  4001,  4002,  8986,  3884 
    95,    83,     2,   408,   282,  3127,  2561,  8987,  8169,  8989,  8988 
    96,  1496,  1415,  1255,  1172,  5746,  8992,  8990,  8991,  8993,  4299 
    97,   462,   336,  1086,  1087,  8995,  3633,  8994,  8996,  3635,  3637 
    98,  1085,   461,   334,   335,  8919,  8997,  3629,  3630,  8998,  2484 
    99,  1254,  1061,  1255,  1415,  4490,  4539,  4495,  8999,  9000,  8992 
   100,  2021,   791,  2102,   868,  7805,  9003,  9001,  9002,  8023,  8294 
   101,  1451,  1423,  1114,   486,  5799,  9005,  9004,  5095,  5096,  9006 
   102,   310,  2055,   436,  2125,  8199,  9008,  9007,  8344,  8538,  9009 
   103,  1451,   486,  1114,   125,  5095,  9006,  9004,  9010,  6637,  3717 
   104,    30,   214,  1522,  1147,  2360,  9012,  9011,  3827,  3826,  9013 
   105,  1416,  1597,  1126,  1498,  6232,  9015,  9014,  6089,  5829,  9016 
   106,  1499,   945,  1126,  1597,  9018,  3941,  9017,  6090,  9019,  9015 
   107,  1509,  1508,  1173,  1657,  5253,  9021,  9020,  5841,  5840,  9022 
   108,  1122,   556,  1508,  1509,  9023,  5249,  8763,  9024,  5251,  5253 
   109,  1446,   134,  1447,   925,  9025,  9027,  5498,  9026,  3198,  9028 
   110,  1134,  1558,   961,  1599,  9029,  9031,  3783,  9030,  6095,  9032 
   111,   492,   131,  1453,   491,  6620,  9033,  5104,  2649,  6621,  5106 
   112,  1518,   960,  1683,  1517,  9034,  9035,  5927,  5275,  9036,  5926 
   113,  1969,  1953,  1968,  2077,  7963,  8008,  7650,  9037,  9039,  9038 
   114,   455,   922,   329,   328,  9041,  3617,  9040,  9042,  3616,  2478 
   115,  1427,  1669,  1233,  1232,  5891,  9044,  8834,  9043,  9045,  4237 
   116,  2146,  1953,  1969,  2077,  9047,  7963,  9046,  8496,  9039,  9037 
   117,   987,  1528,   213,  1146,  9048,  9049,  3326,  3960,  9050,  3824 
   118,  1146,   213,   579,  1528,  3824,  6451,  9051,  9050,  9049,  5301 
   119,  1245,  1468,   907,  1467,  9052,  9054,  4273,  9053,  5512,  9055 
   120,   782,  2012,   781,   860,  7778,  7777,  2993,  8141,  9056,  8119 
   121,   557,   556,   149,  1509,  2726,  6580,  6579,  5252,  5251,  9057 
   122,   908,    42,   505,  1468,  9059,  2666,  9058,  9060,  5144,  5143 
   123,   972,  1540,  1541,   597,  9062,  5577,  9061,  9063,  5340,  5341 
   124,   297,  2048,  2119,   423,  8184,  8469,  8332,  9064,  9066,  9065 
   125,   653,  1887,  1833,   654,  7288,  9068,  9067,  2859,  7289,  9069 
   126,  1437,  1700,  1158,  1638,  6017,  9071,  9070,  5779,  6018,  9072 
   127,   557,   149,   938,  1509,  6579,  3228,  9073,  5252,  9057,  9074 
   128,  1126,  1597,  1416,  1499,  9015,  6232,  9014,  9017,  6090,  5602 
   129,  1954,  2138,  2068,  2076,  9076,  8551,  9075,  9077,  8687,  8686 
   130,  1000,   372,  1550,  1149,  9079,  5370,  9078,  3915,  9081,  9080 
   131,   905,   517,  1595,  1471,  9083,  5518,  9082,  9084,  5157,  5615 
   132,   298,   424,  2119,  2049,  9085,  9086,  8331,  8187,  9087,  8534 
   133,  1580,  1417,   946,  1066,  5538,  9090,  9088,  9089,  9091,  4032 
   134,  1471,  1107,  1551,  1595,  9092,  9093,  5774,  5615,  9094,  5763 
   135,   373,   374,  1829,   232,  2526,  9097,  9095,  9096,  9098,  7140 
   136,     8,  1444,    93,   894,  9099,  9100,  2217,  3136,  9101,  3137 
   137,   149,   556,  1122,  1509,  6580,  9023,  3745,  9057,  5251,  9024 
   138,  1328,  1669,  1233,  1630,  9102,  9044,  4667,  9103,  5892,  9104 
   139,  1257,  1293,   952,  1677,  4666,  4499,  4302,  8832,  8833,  8775 
   140,  2172,  1911,  2103,  2046,  9105,  9106,  8522,  8703,  9107,  8704 
   141,   938,   149,  1122,  1509,  3228,  3745,  3937,  9074,  9057,  9024 
   142,   738,   739,  1969,   819,  2950,  7649,  7648,  8101,  8082,  8922 
   143,  2077,  1954,  2145,  2138,  9108,  9109,  8555,  8684,  9076,  8723 
   144,  1953,  2077,  1954,  1967,  9039,  9108,  7604,  7964,  9110,  7965 
   145,  1727,  1348,  1317,  1316,  9112,  4788,  9111,  8855,  4787,  4619 
   146,   254,  1011,   397,   398,  3409,  9115,  9113,  9114,  9116,  2550 
   147,  1954,  2077,  2145,  1967,  9108,  8555,  9109,  7965,  9110,  9117 
   148,  1097,  1096,    78,  1568,  3667,  3662,  3664,  9118,  9120,  9119 
   149,   626,   684,  1859,   625,  6740,  9121,  7205,  2831,  6741,  7204 
   150,   972,  1286,  1264,  1689,  4427,  4442,  4322,  9122,  9124,  9123 
   151,   294,   420,  1046,   293,  9125,  8941,  3513,  2443,  9126,  3512 
   152,  2138,  2077,  1954,  1953,  8684,  9108,  9076,  9127,  9039,  7604 
   153,  1224,  1286,  1664,  1689,  4611,  9130,  9128,  9129,  9124,  6107 
   154,  1064,  1417,   438,  1065,  9132,  5012,  9131,  3570,  9134,  9133 
   155,   983,   581,  1530,  1531,  9136,  5308,  9135,  9137,  5309,  5563 
   156,   396,  1853,  1816,  1852,  7392,  9139,  9138,  7393,  7188,  9140 
   157,  1929,  2055,  2092,  2161,  9142,  8637,  9141,  9143,  8634,  8511 
   158,  1065,  1127,  1064,  1417,  4037,  4027,  3570,  9134,  9144,  9132 
   159,  1992,  1935,  1936,  2088,  7931,  7550,  7932,  9145,  9147,  9146 
   160,   568,   391,   567,  1135,  5876,  4948,  2739,  9148,  9150,  9149 
   161,  1187,  1658,  1509,  1657,  9152,  5842,  9151,  9153,  5844,  5841 
   162,   443,  2129,  2058,   317,  9155,  8479,  9154,  9156,  8353,  8204 
   163,   213,    55,   580,  1529,  6447,  2754,  6448,  9157,  5305,  5304 
   164,   492,   493,  1453,   132,  2650,  5105,  5104,  6623,  6622,  9158 
   165,  1936,  1935,  2058,  2088,  7550,  9160,  9159,  9146,  9147,  8649 
   166,  1027,  1028,  1368,   273,  3461,  9162,  9161,  3457,  3459,  9163 
   167,   390,   567,  1135,   962,  4949,  9149,  9164,  9165,  9166,  3901 
   168,   249,   963,   392,   964,  3402,  9168,  9167,  3403,  3948,  9169 
   169,  1015,   259,  1016,   402,  3422,  3424,  3426,  9170,  9172,  9171 
   170,   246,   389,  1009,   388,  9173,  9175,  3395,  9174,  2541,  9176 
   171,   840,   761,  1991,  2088,  8017,  7715,  9177,  8266,  9179,  9178 
   172,  1117,   923,   493,  1454,  3995,  9182,  9180,  9181,  8738,  5107 
   173,   857,  2165,   858,   779,  8428,  8427,  3070,  8099,  9183,  8059 
   174,  1277,  1691,   914,  1455,  8886,  9184,  4382,  8887,  5948,  9185 
   175,   495,   915,  1456,   119,  9186,  9187,  5114,  6644,  3179,  9188 
   176,  1117,   493,  1453,  1454,  9180,  5105,  9189,  9181,  5107,  5110 
   177,  1310,  1626,  1620,  1695,  9191,  6248,  9190,  9192,  6247,  6001 
   178,   132,   493,  1453,  1117,  6622,  5105,  9158,  3722,  9180,  9189 
   179,   413,   288,   414,  2114,  9193,  9195,  2567,  9194,  8320,  9196 
   180,  1301,  1697,  1276,  1164,  9197,  9198,  4651,  4710,  9199,  4372 
   181,  1991,   761,  1992,  2088,  7715,  7717,  7719,  9178,  9179,  9145 
   182,   451,  2133,  1944,  2062,  9200,  9202,  7572,  9201,  8483,  9203 
   183,  2050,   427,   301,   300,  9204,  9205,  8188,  8189,  9206,  2450 
   184,  2099,  2015,  2014,  1918,  9208,  7788,  9207,  9209,  7994,  7898 
   185,  1723,  1320,  1319,  1724,  9211,  4631,  9210,  6145,  9213,  9212 
   186,   951,  1257,  1495,  1494,  4303,  9216,  9214,  9215,  9217,  5534 
   187,  1723,  1724,  1319,  1606,  6145,  9212,  9210,  6141,  6143,  9218 
   188,  1555,   931,   382,   381,  9219,  9220,  5384,  5385,  9221,  2534 
   189,  1011,   255,  1012,   398,  3410,  3412,  3414,  9116,  9223,  9222 
   190,  1944,  1980,  1981,  2083,  7949,  7686,  7947,  9224,  9226,  9225 
   191,  1321,  1320,  1211,  1723,  4634,  4630,  4632,  9227,  9211,  9228 
   192,  1724,  1351,  1756,  1755,  9229,  9230,  6321,  6319,  9231,  6323 
   193,  1514,   967,  1678,  1513,  9232,  9233,  5913,  5549,  9234,  5912 
   194,  1977,   827,   747,  2150,  9235,  8042,  7673,  9236,  8398,  9237 
   195,  1816,   619,  1852,  1853,  9238,  7184,  9140,  9139,  7186,  7188 
   196,  2016,  2099,  1918,  2015,  9239,  9209,  7897,  7791,  9208,  7994 
   197,  1785,   699,  1874,  1875,  6854,  9242,  9240,  9241,  9243,  7254 
   198,  1651,  1259,   958,  1282,  9245,  4307,  9244,  9246,  4406,  4405 
   199,  1688,  1199,  1339,  1220,  9248,  4728,  9247,  9249,  4609,  4818 
   200,   265,   356,  1376,   357,  7440,  4910,  9250,  8733,  2508,  4911 
   201,  1519,   186,  1520,   965,  9251,  9252,  5285,  8772,  3282,  9253 
   202,  1019,  1376,  1271,  1431,  9254,  9256,  4346,  9255,  5950,  8861 
   203,  1201,  1200,  1620,  1310,  4138,  9258,  9257,  4733,  4745,  9190 
   204,  1200,  1220,  1199,  1688,  4610,  4609,  4134,  9259,  9249,  9248 
   205,  1688,  1220,  1339,  1628,  9249,  4818,  9247,  6203,  9261,  9260 
   206,  1339,  1309,  1698,  1221,  4726,  9263,  9262,  4729,  4586,  9264 
   207,   601,   604,   605,  1897,  6694,  2809,  6697,  7319,  9266,  9265 
   208,   965,  1520,  1152,  1136,  9253,  9267,  4055,  3904,  9268,  4054 
   209,  1152,  1520,  1390,  1136,  9267,  5556,  9269,  4054,  9268,  9270 
   210,  1876,  1802,  1786,  1828,  9272,  7093,  9271,  9273,  7107,  7062 
   211,  1438,  1202,  1639,  1638,  9274,  9275,  5781,  5780,  9276,  5783 
   212,   866,  2019,   788,  2169,  9277,  7798,  8061,  8435,  9279,  9278 
   213,   263,   604,   407,  1810,  6947,  9280,  8777,  6951,  6949,  9281 
   214,  1394,   403,  1016,  1564,  4960,  9283,  9282,  5591,  5412,  9284 
   215,   367,  1887,   366,  1799,  7339,  7338,  2519,  9285,  9287,  9286 
   216,   359,   992,   360,   218,  9288,  9290,  2512,  9289,  3337,  9291 
   217,  1417,  1064,   438,  1499,  9132,  9131,  5012,  5457,  9292,  5458 
   218,   970,  1681,  1181,  1138,  9293,  9294,  4057,  3905,  9295,  4056 
   219,   719,  1795,  1895,  1894,  6874,  8890,  8807,  9296,  9297,  7314 
   220,  1458,  1274,  1421,  1248,  9298,  9300,  5753,  9299,  4388,  9301 
   221,  1643,   893,  1242,  1642,  9303,  4262,  9302,  5795,  9305,  9304 
   222,  2168,  2099,  1918,  2016,  8518,  9209,  9306,  9307,  9239,  7897 
   223,  1614,  1198,  1339,  1199,  9309,  4727,  9308,  9310,  4131,  4728 
   224,  1893,   659,   717,  1892,  7306,  6791,  9311,  7308,  7304,  9312 
   225,  1258,  1259,  1734,  1292,  4521,  8950,  8949,  4562,  4469,  9313 
   226,   255,  1773,  1815,   398,  6935,  7067,  7127,  9223,  9315,  9314 
   227,  1779,   629,   630,   688,  9317,  2835,  9316,  6842,  6747,  6746 
   228,  2099,  1918,  2014,  2167,  9209,  7898,  9207,  8577,  9319,  9318 
   229,   390,   962,  1135,   248,  9165,  3901,  9164,  9320,  3400,  4473 
   230,  2148,  1974,   824,   743,  9321,  9323,  8393,  9322,  7663,  8016 
   231,  1153,  1560,   396,  1391,  9325,  5400,  9324,  9326,  5404,  4955 
   232,  2120,  2167,  1918,  2099,  8620,  9319,  9327,  8716,  8577,  9209 
   233,  2116,   292,   418,  2046,  8325,  9329,  9328,  8324,  8181,  9330 
   234,  1324,  1718,   395,  1560,  9332,  5402,  9331,  9333,  5403,  5401 
   235,  1826,   236,   378,   237,  6993,  9334,  8896,  7036,  2384,  8897 
   236,   388,  1806,  1862,   387,  9335,  9336,  7376,  2540,  9337,  7375 
   237,  1685,  1524,   989,   988,  5931,  9340,  9338,  9339,  9341,  3828 
   238,  1445,    39,    14,   923,  5076,  2798,  9342,  8736,  9343,  3194 
   239,   419,  2046,  1911,   418,  9344,  9107,  7475,  2572,  9330,  7474 
   240,  1287,  1300,  1312,  1615,  4771,  4694,  4772,  9345,  9347,  9346 
   241,  1524,  1523,   215,   988,  5560,  8935,  8936,  9341,  9348,  3327 
   242,   261,  1017,   404,  1154,  3428,  9350,  9349,  3848,  3952,  9351 
   243,  1639,  1438,   891,  1202,  5781,  9353,  9352,  9275,  9274,  4139 
   244,   378,  1004,   377,  1553,  9354,  9355,  2530,  5377,  8795,  5378 
   245,   215,   214,   988,  1523,  2361,  3328,  3327,  8935,  9356,  9348 
   246,   777,   856,   778,  2008,  8022,  8057,  2989,  7765,  9357,  7766 
   247,   386,  1557,  1008,  1007,  5391,  9360,  9358,  9359,  9361,  3393 
   248,   378,   236,   377,  1004,  9334,  9362,  2530,  9354,  3373,  9355 
   249,  1269,  1686,  1188,  1008,  9363,  9364,  4370,  4599,  9365,  4115 
   250,  1583,   445,  1071,  1072,  5468,  9368,  9366,  9367,  9369,  3591 
   251,   990,  1517,    54,  1525,  9371,  5271,  9370,  9372,  5562,  5295 
   252,  1867,   633,   634,  1781,  7228,  2839,  7229,  9373,  9375,  9374 
   253,  1863,   630,  1779,   629,  7217,  9316,  9376,  7216,  2835,  9317 
   254,   686,  1861,   627,   685,  9377,  7210,  6743,  2893,  9378,  6799 
   255,  1182,  1754,  1664,  1687,  9380,  6386,  9379,  9381,  6305,  5936 
   256,  1702,  1634,  1332,  1760,  6046,  8860,  9382,  6344,  6343,  8857 
   257,  2126,  2056,   312,   438,  8539,  8201,  8346,  9383,  9385,  9384 
   258,  1832,   368,   227,  1791,  9386,  9387,  7105,  7080,  9388,  6895 
   259,  1145,  1526,    56,  1533,  9390,  5296,  9389,  9391,  5315,  5314 
   260,  2047,   295,   294,   421,  8182,  2444,  8183,  9392,  9394,  9393 
   261,  1562,  1392,  1012,   399,  5589,  9396,  9395,  5408,  4956,  9397 
   262,   683,  1858,  1859,   625,  9399,  7206,  9398,  6738,  7202,  7204 
   263,   404,  1017,  1564,  1395,  9350,  9400,  5411,  4963,  9401,  5624 
   264,  2120,  1918,  2168,  2099,  9327,  9306,  8617,  8716,  9209,  8518 
   265,    88,  1439,   474,   473,  9402,  5058,  6604,  6601,  5057,  2629 
   266,  2014,  1919,  2013,  2167,  7899,  7900,  7785,  9318,  9404,  9403 
   267,  1005,   236,   378,  1004,  3375,  9334,  9405,  3377,  3373,  9354 
   268,   364,  1379,  1548,   996,  4918,  5584,  5366,  9406,  9408,  9407 
   269,   378,  1785,   377,   236,  9409,  9410,  2530,  9334,  6907,  9362 
   270,   712,  1833,   653,   711,  7007,  9067,  6781,  2919,  6867,  6803 
   271,  1147,   214,  1522,  1523,  3826,  9012,  9013,  9411,  9356,  5559 
   272,   360,  1377,  1547,   993,  4914,  5359,  5358,  9412,  9414,  9413 
   273,  1526,  1289,  1720,  1714,  9415,  9416,  6129,  6103,  9417,  6133 
   274,  1145,   985,  1184,  1714,  3912,  4081,  4080,  9418,  9420,  9419 
   275,  1133,   537,   173,   172,  9421,  6538,  3776,  3777,  6535,  2310 
   276,  1617,  1197,  1562,  1392,  9422,  9423,  5705,  5706,  9424,  5589 
   277,  2038,  2110,   884,   808,  9426,  8310,  9425,  7856,  9427,  8027 
   278,  2179,  2110,  1959,   808,  8529,  9430,  9428,  9429,  9427,  7858 
   279,  1038,   412,   286,  1039,  9431,  9432,  3490,  3494,  9433,  3492 
   280,  1595,  1107,  1551,  1470,  9094,  9093,  5763,  5651,  9434,  5692 
   281,   429,  2051,  1921,   428,  9435,  9436,  7504,  2582,  9437,  7503 
   282,  1728,  1729,  1749,  1315,  6160,  6284,  6333,  9438,  9440,  9439 
   283,  1294,  1623,  1732,  1696,  9442,  6365,  9441,  9443,  6314,  6179 
   284,  1190,  1613,  1764,  1323,  9445,  6364,  9444,  4724,  9447,  9446 
   285,  1921,  2121,   428,  2051,  9448,  9449,  7503,  9436,  8335,  9437 
   286,   947,  1598,  1129,   163,  9450,  9451,  3895,  3245,  9452,  3765 
   287,  1343,  1622,  1620,  1626,  9454,  6338,  9453,  9455,  5731,  6248 
   288,   301,  2121,   428,   427,  8337,  9449,  9456,  9205,  9457,  2581 
   289,  1794,   717,  1893,  1836,  6872,  9311,  9458,  7065,  7015,  9459 
   290,  1218,  1403,  1038,  1219,  9460,  9461,  4186,  4190,  9462,  4188 
   291,  1100,  1642,  1441,  1641,  9464,  5790,  9463,  9465,  5792,  5788 
   292,  1640,  1737,  1639,  1231,  6209,  6208,  5786,  9466,  9468,  9467 
   293,   855,   776,   854,  2095,  8056,  8054,  3067,  8279,  9469,  8280 
   294,  1203,  1271,  1020,  1635,  4348,  4347,  4142,  8829,  8828,  9470 
   295,   389,   961,  1009,  1558,  9471,  4113,  9175,  5393,  9031,  9472 
   296,  1022,  1374,   267,   354,  9473,  9475,  3441,  9474,  4904,  6328 
   297,   141,   931,   526,  1555,  3213,  9477,  6516,  9476,  9219,  5525 
   298,  2104,  1910,  1911,  2046,  9479,  7476,  9478,  8705,  9480,  9107 
   299,  1381,   999,  1102,   900,  9482,  4369,  9481,  9483,  4368,  3926 
   300,   341,   887,    35,   467,  8230,  4795,  9484,  9485,  9486,  2621 
   301,   525,   526,  1555,   141,  2689,  5525,  5524,  6517,  6516,  9476 
   302,  1896,   662,   663,   720,  7315,  2868,  7316,  9487,  6797,  6796 
   303,  1892,  1835,   363,  1891,  9488,  9489,  7331,  7305,  9490,  7425 
   304,  1592,  1239,  1089,  1430,  8826,  4253,  9491,  5614,  9493,  9492 
   305,   819,   820,  1969,  2146,  3032,  9494,  8922,  8390,  8389,  9046 
   306,  2082,  1979,  1946,  1945,  9496,  7951,  9495,  9497,  7950,  7580 
   307,   724,  1837,   358,  1840,  7021,  9500,  9498,  9499,  9501,  7148 
   308,  1210,  1209,  1027,  1606,  4164,  4160,  4162,  9502,  9504,  9503 
   309,  1171,  1503,  1671,  1655,  9506,  5898,  9505,  9507,  5831,  6088 
   310,  1750,  1631,  1331,  1760,  6285,  9509,  9508,  6342,  6341,  8856 
   311,   829,   830,   749,  2151,  3042,  8089,  8044,  8400,  8399,  9510 
   312,  1332,  1331,  1702,  1760,  4681,  9511,  9382,  8857,  8856,  6344 
   313,   488,  1586,  1115,  1424,  5476,  8985,  8873,  5098,  5473,  9512 
   314,  1110,   501,   116,   115,  8907,  6656,  3702,  3703,  6658,  2243 
   315,  1170,  1227,   949,  1653,  4391,  4390,  4015,  9513,  9515,  9514 
   316,  1849,  1815,  1772,   674,  9517,  7051,  9516,  9518,  6963,  6828 
   317,   256,   399,  1772,  1814,  9519,  9520,  6936,  7118,  9521,  7047 
   318,    26,   600,  1137,  1545,  6494,  9523,  3798,  9522,  5350,  9524 
   319,  1813,   401,  1808,   258,  9525,  9526,  7128,  7142,  9527,  6942 
   320,  1736,  1713,  1173,  1657,  6199,  9529,  9528,  6198,  6101,  9022 
   321,  1944,  2133,   452,  1945,  9202,  9530,  7573,  7577,  9531,  7575 
   322,   452,  1945,  2063,   453,  7575,  9533,  9532,  2606,  7576,  9534 
   323,   245,  1009,  1388,   388,  3394,  9537,  9535,  9536,  9176,  4944 
   324,   389,  1820,   247,   390,  9539,  7141,  9538,  2542,  9541,  9540 
   325,  2019,  1915,  2169,  2101,  7989,  9543,  9279,  9542,  9544,  8579 
   326,  1860,  1820,   389,   390,  9545,  9539,  7379,  7380,  9541,  2542 
   327,  1867,   383,  1804,  1868,  7367,  9547,  9546,  7233,  7417,  9548 
   328,  1694,  1549,  1189,  1668,  5970,  9550,  9549,  5994,  5959,  9551 
   329,   455,   922,  1155,   329,  9041,  4226,  9552,  9040,  3617,  3857 
   330,  1158,  1700,  1305,  1638,  9071,  9553,  4576,  9072,  6018,  9554 
   331,  2126,  2092,  2160,  1930,  8636,  8570,  8718,  8966,  9555,  8965 
   332,  1305,  1337,  1748,  1700,  4716,  9557,  9556,  9553,  9558,  6281 
   333,   657,  1890,   715,  1891,  7298,  9559,  6787,  7300,  7302,  9560 
   334,   390,   248,  1135,   391,  9320,  4473,  9164,  2543,  9561,  9150 
   335,  1057,  1413,   430,   431,  9563,  5004,  9562,  9564,  5003,  2584 
   336,   433,  2053,  1925,   432,  9565,  9566,  7516,  2586,  9567,  7515 
   337,  1889,   714,   656,  1890,  9568,  6784,  7295,  7299,  9569,  7297 
   338,   716,  1835,  1794,  1892,  7012,  7082,  6873,  9570,  9488,  9571 
   339,  1793,  1835,   715,  1890,  7025,  7013,  6870,  9572,  9573,  9559 
   340,   377,  1785,   235,   236,  9410,  6908,  9574,  9362,  6907,  2383 
   341,  1653,  1227,  1493,  1582,  9515,  9575,  5826,  5605,  8840,  6077 
   342,  1638,  1700,  1305,  1748,  6018,  9553,  9554,  6279,  6281,  9556 
   343,  2053,  2163,  1925,  2095,  8698,  8786,  9566,  8623,  8573,  8787 
   344,  1999,  1998,  2160,  1930,  7740,  9577,  9576,  7999,  7921,  8965 
   345,  2148,  1974,  1973,  1949,  9321,  7665,  9578,  9579,  8006,  7956 
   346,  1992,   761,   762,   841,  7717,  2973,  7718,  9580,  8018,  8019 
   347,  1561,  1618,  1338,  1391,  5707,  9582,  9581,  5588,  5708,  9583 
   348,   397,  1391,  1561,  1010,  4954,  5588,  5406,  9584,  9586,  9585 
   349,   254,  1773,   397,   253,  6933,  9587,  9113,  2401,  6934,  9588 
   350,   330,   456,  1155,   329,  9589,  9590,  3858,  2479,  9591,  3857 
   351,  1207,  1726,  1609,  1608,  9593,  6150,  9592,  9594,  6149,  5675 
   352,  1207,  1318,  1726,  1208,  4620,  9595,  9593,  4158,  4621,  9596 
   353,   902,   370,   228,   229,  9597,  9598,  3361,  3362,  9599,  2376 
   354,  2091,  1930,  1998,  1931,  8964,  7921,  9600,  9601,  7535,  7922 
   355,   694,   636,   693,  1869,  6757,  6754,  2901,  9602,  7235,  9603 
   356,  2058,  2128,  1935,   442,  8541,  9604,  9160,  8819,  8821,  7545 
   357,   378,   379,  1005,  1554,  2531,  9605,  9405,  5380,  5379,  9606 
   358,   245,   388,  1388,   387,  9536,  4944,  9535,  9607,  2540,  4945 
   359,  1280,  1249,  1232,  1633,  4421,  4498,  4542,  9608,  9610,  9609 
   360,  1944,  1943,   451,  2062,  7574,  7570,  7572,  9203,  9611,  9201 
   361,  1034,  1216,  1363,  1362,  4181,  9614,  9612,  9613,  9615,  4873 
   362,  2127,   314,   440,  2057,  8348,  9617,  9616,  8540,  8203,  9618 
   363,  1067,   314,   440,  1066,  3574,  9617,  9619,  3576,  3572,  9620 
   364,  1837,   358,  1840,  1898,  9500,  7148,  9501,  9621,  7321,  7323 
   365,   813,  2143,   814,   732,  8384,  8383,  3026,  8032,  9622,  8077 
   366,  1992,   762,  2157,   841,  7718,  9624,  9623,  9580,  8019,  8412 
   367,  2057,  2158,  1934,  1933,  8645,  9627,  9625,  9626,  9628,  7544 
   368,   693,  1869,   635,  1782,  9603,  7234,  6755,  6848,  9630,  9629 
   369,  2102,   791,   869,   868,  9003,  8024,  8293,  8294,  8023,  3081 
   370,  1458,  1274,  1584,  1421,  9298,  9631,  5752,  5753,  9300,  5607 
   371,  2101,   867,   789,  2020,  8291,  8097,  9632,  9633,  9634,  7801 
   372,  2164,  2007,   855,  2095,  9635,  9636,  8426,  8514,  9637,  8279 
   373,   986,  1527,  1720,  1268,  9639,  6130,  9638,  4333,  9641,  9640 
   374,  1457,   495,   120,   915,  5115,  6645,  9642,  9643,  9186,  3178 
   375,   761,   841,  1992,  2088,  8018,  9580,  7717,  9179,  8265,  9145 
   376,  1524,   216,  1525,   989,  9644,  9645,  5561,  9340,  3329,  9646 
   377,  1888,  1887,  1792,  1799,  7293,  9649,  9647,  9648,  9287,  7134 
   378,  1189,  1148,   998,  1549,  4094,  3853,  4095,  9550,  9651,  9650 
   379,  1992,   841,  2157,  2088,  9580,  8412,  9623,  9145,  8265,  8507 
   380,   898,  1668,  1549,  1435,  9653,  5959,  9652,  9654,  5889,  5954 
   381,  1046,   420,   419,   293,  8941,  2573,  9655,  3512,  9126,  9656 
   382,  1777,  1820,  1859,   390,  7039,  9659,  9657,  9658,  9541,  7381 
   383,  1390,  1177,  1152,  1136,  9660,  4725,  9269,  9270,  4045,  4054 
   384,   998,   366,   367,  1549,  9662,  2519,  9661,  9650,  5369,  5368 
   385,   898,  1435,  1549,  1162,  9654,  5954,  9652,  4706,  8825,  8824 
   386,   898,  1162,  1549,  1189,  4706,  8824,  9652,  4268,  4365,  9550 
   387,   774,   852,  2094,  2004,  8116,  8278,  9663,  7754,  9665,  9664 
   388,  1310,  1732,  1273,  1217,  9666,  9667,  4721,  4589,  9668,  4722 
   389,   382,   240,  1804,  1824,  9670,  6914,  9669,  9671,  7038,  7037 
   390,   932,  1121,   144,  1479,  3888,  3740,  3215,  8754,  8755,  9672 
   391,  1522,  1660,  1712,  1183,  5852,  6093,  6092,  9673,  9675,  9674 
   392,   694,  1824,  1783,  1869,  6985,  6984,  6851,  9602,  9677,  9676 
   393,  1786,  1875,  1802,  1876,  9678,  9679,  7093,  9271,  7257,  9272 
   394,  1939,  2154,  2086,  2060,  9681,  8564,  9680,  9682,  8657,  8654 
   395,  1294,  1273,  1732,  1217,  4504,  9667,  9441,  4767,  4722,  9668 
   396,   649,   706,  1789,   648,  6816,  6863,  9683,  2854,  6809,  9684 
   397,  1829,   373,   232,  1788,  9095,  9096,  7140,  7097,  9685,  6902 
   398,  1859,  1858,   683,  1777,  7206,  9399,  9398,  9657,  9686,  6839 
   399,  2131,  2154,  1939,  2060,  8656,  9681,  9687,  8481,  8657,  9682 
   400,  1491,  1716,   956,  1482,  6119,  9689,  9688,  5209,  6117,  9690 
   401,  1987,  2154,  1939,  1986,  9691,  9681,  7938,  7704,  9692,  7939 
   402,  1987,  2154,  2086,  1939,  9691,  8564,  9693,  7938,  9681,  9680 
   403,  1284,  1711,  1716,  1491,  9695,  6244,  9694,  9696,  6087,  6119 
   404,   221,   362,  1794,   363,  9697,  9699,  6886,  9698,  2515,  9700 
   405,  1753,  1744,  1328,  1630,  6296,  9702,  9701,  6295,  6294,  9103 
   406,  2127,  2056,  1932,   439,  8477,  9705,  9703,  9704,  9706,  7536 
   407,  1077,   324,   450,  1076,  3604,  9708,  9707,  3606,  3602,  9709 
   408,  1845,   611,  1812,  1844,  7162,  9711,  9710,  7164,  7160,  9712 
   409,   323,  1076,   450,   324,  3601,  9709,  9713,  2473,  3602,  9708 
   410,   858,  2165,  2010,   779,  8427,  9715,  9714,  8059,  9183,  7771 
   411,  1902,  1901,  2041,  2178,  7450,  9718,  9716,  9717,  9719,  8709 
   412,   390,   391,  1135,   567,  2543,  9150,  9164,  4949,  4948,  9149 
   413,   154,  1506,    19,    50,  9720,  9721,  2289,  6574,  5245,  2793 
   414,   408,  2180,  2041,  1901,  9723,  8315,  9722,  7446,  9724,  9718 
   415,  1203,  1729,  1635,  1612,  9725,  6161,  8829,  9726,  6159,  5961 
   416,  1394,  1620,  1200,  1688,  5713,  9258,  9727,  5938,  5940,  9259 
   417,  1419,  1492,  1170,  1502,  5835,  9729,  9728,  5834,  5544,  9730 
   418,  1903,  2177,  1904,  2035,  9731,  9732,  7456,  7873,  9733,  7874 
   419,  1185,  1144,  1056,  1576,  4361,  4211,  4212,  8911,  8909,  9734 
   420,  1170,   949,  1502,  1492,  4015,  9735,  9730,  9729,  9736,  5544 
   421,  1085,  1428,  1235,  1234,  8921,  9737,  4241,  4239,  8934,  4243 
   422,   975,    27,   584,   196,  3302,  6459,  9738,  3301,  2339,  6461 
   423,  2099,  2167,  2014,   862,  8577,  9318,  9207,  8288,  8431,  9739 
   424,    52,  1513,  1521,   967,  5263,  5550,  5287,  9740,  9234,  9741 
   425,  1084,  1428,  1234,  1589,  9742,  8934,  4238,  9743,  5649,  9744 
   426,  1190,  1323,  1764,  1306,  4724,  9446,  9444,  4577,  4736,  9745 
   427,  1661,  1678,  1261,  1560,  6096,  9747,  9746,  6193,  6355,  9748 
   428,   282,    80,     4,     2,  3480,  2200,  2431,  8989,  3120,  3126 
   429,  2122,  1922,  2009,  1923,  9750,  7906,  9749,  9751,  7511,  7907 
   430,  1217,  1566,  1626,  1623,  9753,  5729,  9752,  9754,  5718,  5730 
   431,  2122,  1923,  2009,  2052,  9751,  7907,  9749,  8590,  9756,  9755 
   432,  1230,  1666,  1623,  1294,  9758,  5991,  9757,  4503,  9759,  9442 
   433,  2176,  2033,  1904,  2034,  9761,  7875,  9760,  9762,  7845,  7993 
   434,  1288,  1577,  1057,  1058,  9763,  9764,  4446,  4467,  9765,  3549 
   435,   989,  1524,   215,   988,  9340,  8936,  3330,  3828,  9341,  3327 
   436,   462,  2068,  2138,   336,  9767,  8551,  9766,  8995,  8225,  8370 
   437,   316,  2058,   443,   442,  8205,  9154,  9768,  8820,  8819,  2596 
   438,  1344,  1347,  1763,  1325,  4817,  9770,  9769,  4769,  4841,  9771 
   439,  1176,  1645,   954,  1179,  9772,  9773,  4042,  4050,  9774,  4048 
   440,   879,  2176,   803,  2033,  8450,  9776,  8132,  9775,  9761,  7841 
   441,  1685,   988,   989,  1188,  9339,  3828,  9338,  9777,  4093,  4092 
   442,  1070,  1227,  1653,  1582,  4218,  9515,  9778,  9779,  8840,  5605 
   443,  1559,   569,   184,   963,  5558,  6432,  9780,  9781,  9782,  3789 
   444,  1621,  1395,  1695,  1180,  5715,  5987,  5986,  9783,  9785,  9784 
   445,  1882,   370,   371,  1800,  7346,  2523,  7347,  9786,  9788,  9787 
   446,  1948,  1947,  2149,  1976,  7586,  9790,  9789,  7981,  7982,  9791 
   447,  2135,  2064,   455,   329,  8485,  9793,  9792,  8365,  8216,  9040 
   448,  2142,   812,   730,  1961,  8381,  8014,  9794,  9795,  9796,  7624 
   449,   363,   995,  1379,   996,  9797,  9799,  4919,  9798,  3350,  9408 
   450,  1793,   222,   364,   223,  6890,  9801,  9800,  6889,  2370,  9802 
   451,  1426,  1587,  1167,  1081,  5480,  8740,  8739,  9803,  9804,  4117 
   452,  1592,   465,  1090,   466,  5492,  9805,  8813,  5491,  2619,  9806 
   453,  1156,   466,  1090,   340,  9807,  9806,  3964,  3860,  9808,  3645 
   454,  1310,  1200,  1620,  1343,  4745,  9258,  9190,  4754,  4783,  9453 
   455,  1240,  1396,   406,  1092,  9810,  4965,  9809,  4256,  8792,  9811 
   456,   466,   339,  1090,   340,  9812,  3644,  9806,  9808,  2489,  3645 
   457,   382,  1478,   932,   931,  5387,  9814,  9813,  9220,  9815,  3738 
   458,  1085,  1428,  1084,   460,  8921,  9742,  3631,  9816,  5034,  9817 
   459,  1312,  1557,  1387,  1007,  9819,  5586,  9818,  4597,  9361,  9820 
   460,   426,  1052,  1053,   300,  9822,  3534,  9821,  9823,  3530,  3532 
   461,  1019,   467,   264,   357,  9824,  9826,  3433,  9825,  4913,  8734 
   462,  1701,  1175,  1487,  1652,  9827,  9828,  6082,  6026,  9829,  5822 
   463,  1501,   551,   164,   550,  5234,  6553,  8875,  5233,  2718,  6554 
   464,  1463,  1275,   912,  1652,  9831,  4366,  9830,  5893,  9833,  9832 
   465,   462,   461,  2138,  1954,  2615,  9834,  9766,  7603,  7602,  9076 
   466,  1463,   912,  1464,  1652,  9830,  9835,  5134,  5893,  9832,  5894 
   467,  1354,  1330,  1632,  1329,  4810,  9837,  9836,  4809,  4675,  9838 
   468,  1878,  1787,   703,  1829,  9840,  6858,  9839,  9841,  7063,  6998 
   469,   758,   838,   759,  1989,  8047,  8046,  2970,  7708,  9842,  7709 
   470,  2113,  2043,  1904,  2108,  8530,  9844,  9843,  8694,  8706,  9845 
   471,   920,  1586,   488,   487,  8986,  5476,  9846,  9847,  5502,  2645 
   472,   569,  1559,   184,   570,  5558,  9780,  6432,  2741,  5278,  6431 
   473,  1304,  1300,  1287,  1615,  4777,  4771,  4573,  9848,  9347,  9345 
   474,   928,    46,   959,  1485,  9849,  9850,  3866,  8802,  5193,  8806 
   475,    76,  1567,  1095,  1157,  9851,  9852,  3659,  3862,  9853,  3863 
   476,   880,  2176,   803,   879,  8449,  9776,  8067,  3092,  8450,  8132 
   477,  1273,  1095,  1096,  1696,  4354,  3663,  4355,  9854,  9856,  9855 
   478,  1095,  1399,  1096,  1696,  9857,  9858,  3663,  9856,  6003,  9855 
   479,   760,   839,  2156,  1990,  8098,  8410,  9859,  7712,  9861,  9860 
   480,   998,  1549,   367,  1381,  9650,  5368,  9661,  9862,  5367,  4923 
   481,   760,  2156,  1991,  1990,  9859,  9863,  7714,  7712,  9860,  7716 
   482,  1218,  1626,  1566,  1403,  9865,  5729,  9864,  9460,  5728,  5427 
   483,  1310,  1732,  1695,  1273,  9666,  6178,  9192,  4721,  9667,  9866 
   484,    76,    75,    68,  1157,  2195,  3110,  3111,  3862,  3864,  9867 
   485,  1266,  1531,  1682,  1663,  9869,  5925,  9868,  9870,  5866,  6186 
   486,  1251,  1672,  1673,  1474,  8926,  6076,  8924,  9871,  5900,  5901 
   487,   836,  2086,   837,   757,  8262,  8261,  3049,  8094,  9872,  8095 
   488,   851,  2093,  2003,  2002,  8275,  9875,  9873,  9874,  9876,  7752 
   489,  1833,  1887,  1792,   654,  9068,  9649,  7078,  9069,  7289,  9877 
   490,  1288,  1682,  1577,  1663,  9878,  6105,  9763,  9879,  6186,  5869 
