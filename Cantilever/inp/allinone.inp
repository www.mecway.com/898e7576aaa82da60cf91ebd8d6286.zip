  3055,   832,  1983,   752,  1982, 10585,  7690,  8165,  9931,  7692,  7688 
  3056,   451,  1077,  1423,  1078, 11602, 11474,  5023, 11524,  3609, 11473 
  3057,  1372,   352,  1024,  1371,  4898, 10036, 11428,  4900,  4896, 10174 
  3058,   751,  1982,  1981,   831,  7687,  7689,  7685,  8147, 11947, 11054 
  3059,  2164,  2007,  1924,  2008,  9635,  7996, 10399, 11279,  7767,  7909 
  3060,  1925,  2005,  2006,  2163,  7912,  7761,  7911,  8786, 10045,  8788 
  3061,  2163,  2005,  2006,   775, 10045,  7761,  8788, 10047,  7757,  7759 
  3062,  1926,  1925,  2124,  2163,  7520, 11271,  8981, 11258,  8786,  8697 
  3063,  2124,  2094,  1926,  2163,  8696, 10248,  8981,  8697,  8513, 11258 
  3064,   257,   401,  1771,   258, 11946, 11939,  6938,  2405,  9527,  6940 
  3065,  1020,  1635,  1376,  1375,  9470,  5956, 11110, 11112,  5955,  4912 
  3066,   286,  1038,   411,   412,  3490,  9933, 11721,  9432,  9431,  2565 
  3067,  1103,   900,  1381,   508,  3872,  9483, 11916, 11367, 11368,  5689 
  3068,   257,   401,   400,  1771, 11946,  2553, 11438,  6938, 11939, 11440 
  3069,  1685,  1686,   989,  1524,  5982, 11948,  9338,  5931,  5932,  9340 
  3070,  1570,  1039,  1038,  1219, 10449,  3494,  9929, 10778,  4189,  4188 
  3071,  1225,  1340,  1752,  1160,  4734, 10266, 11731,  4209,  4735, 11553 
  3072,  1608,  1725,  1607,  1208,  6147,  6146,  5672, 11851, 11949, 11596 
  3073,  2028,   875,   798,  2029, 10236,  8136,  7826,  7830, 11801,  7828 
  3074,  1724,  1319,  1607,  1725,  9212, 11099,  6144,  6148, 11818,  6146 
  3075,  1607,  1725,  1319,  1208,  6146, 11818, 11099, 11596, 11949,  4623 
  3076,  2106,  2030,  2029,  2174, 10770,  7833, 10956,  8584, 11951, 11950 
  3077,   767,  1997,  2091,  1998,  7733, 11050, 11260,  7735,  7737,  9600 
  3078,   546,  1417,  1499,  1127,  5229,  5457,  5228, 10002,  9144, 10000 
  3079,  1096,  1095,    77,  1399,  3663,  3660,  3661,  9858,  9857, 10417 
  3080,  1628,  1404,  1570,  1220,  5735,  5643,  5736,  9261, 10446, 10447 
  3081,  1998,  1997,  2091,  1931,  7737, 11050,  9600,  7922,  7923,  9601 
  3082,  2159,  2056,  2091,  1931,  8641,  8638,  8569, 11922,  9886,  9601 
  3083,  1932,  2056,  2159,  1931,  9705,  8641, 10911,  7538,  9886, 11922 
  3084,   461,   460,   334,  2067,  2614, 10891,  8997, 10823, 11236,  8223 
  3085,  1196,  1342,  1731,  1617,  4740, 11952, 11400, 11532, 11953,  6191 
  3086,   263,   406,  1092,  1018, 10362,  9811,  3843,  3431, 10532,  3842 
  3087,  1397,  1092,  1093,    73,  8791,  3655, 10188, 10186,  3652,  3653 
  3088,  1328,  1329,  1753,  1630,  4672,  9910,  9701,  9103, 11954,  6295 
  3089,  1707,  1280,  1296,  1704, 11192,  4517, 10202,  6309, 11955, 10203 
  3090,  1969,  1953,  2146,  1952,  7963,  9047,  9046,  7962,  7601,  8893 
  3091,  1327,  1336,  1359,  1762,  4701,  4845,  4844, 11956, 10106,  8844 
  3092,   935,   519,   518,  1473, 11496,  2681,  8756, 11675,  5162,  5161 
  3093,  1328,  1744,  1353,  1337,  9702, 10428,  4806,  4805, 10361,  4808 
  3094,  1100,  1440,  1441,    90, 10410,  5065,  9463,  3674, 11541, 10055 
  3095,  1068,   315,   316,   442,  3577,  2465,  3578,  9943, 10793,  8820 
  3096,  1632,  1234,  1235,  1428,  8932,  4243, 11930,  5765,  8934,  9737 
  3097,  1753,  1329,  1632,  1630,  9910,  9838,  6303,  6295, 11954,  5766 
  3098,   323,   322,  2061,   449,  2472,  8211,  8210,  8865, 10869,  8866 
  3099,   997,   223,   224,   365,  3351,  2371,  3352, 11638, 11910, 10258 
  3100,  1287,  1183,  1660,   988,  4433,  9675, 11376,  4432,  4064, 11377 
  3101,  1408,   420,  1047,   421,  4994,  8943, 10794,  4993,  2574, 11573 
  3102,   821,  1971,   741,   740, 11048,  7655,  8084,  8083,  7654,  2952 
  3103,   253,   252,   396,  1153,  2400, 10816, 10372,  3847,  3846,  9324 
  3104,  1158,  1098,  1437,  1638,  3965, 11304,  9070,  9072, 11957,  5779 
  3105,  2080,  1975,   744,  1974, 10010,  7666, 10864, 10011,  7668,  7664 
  3106,  1632,  1329,  1234,  1630,  9838,  4670,  8932,  5766, 11954,  8933 
  3107,  2075,  1964,  1957,  1956, 10134,  7971, 10191, 11430,  7970,  7613 
  3108,  1951,  2147,  2136,  2066,  8748,  8679, 11347,  8749,  8678,  8549 
  3109,  1236,  1631,  1331,  1330, 10664,  9509,  4676,  4674, 11011,  4678 
  3110,  1951,  2136,   458,  2066, 11347, 10038,  7593,  8749,  8549, 11664 
  3111,  1234,  1329,  1328,  1630,  4670,  4672,  4668,  8933, 11954,  9103 
  3112,  1082,  1249,  1588,  1232,  4497, 11958, 11704,  4233,  4498, 11706 
  3113,  2058,  1935,  2157,  2088,  9160, 10126,  8646,  8649,  9147,  8507 
  3114,   287,   412,  2043,   413, 11883, 11679,  8174, 11880,  2566, 11296 
  3115,  1426,  1278,   924,  1446, 11238,  4436, 11184,  6057, 11181, 10940 
  3116,  1827,   377,   235,  1802, 11237,  9574,  7108,  7094, 11959,  6905 
  3117,  2057,  1933,  1934,   441,  9626,  7544,  9625, 11662,  7540,  7542 
  3118,  2043,   412,   287,   286, 11679, 11883,  8174,  8175,  9432,  2436 
  3119,   316,   442,   315,  2128,  8820, 10793,  2465,  8350,  8821,  8351 
  3120,   235,   376,   377,  1003, 10514,  2529,  9574,  3371, 10303, 11960 
  3121,  1003,  1384,   377,  1553, 10304,  4934, 11960, 11487,  5697,  5378 
  3122,  1552,  1384,  1002,  1292,  5639,  8848,  8846,  9998,  9999,  4460 
  3123,  1774,  1853,   678,   677, 11449, 10639,  6832,  6833, 11778,  2885 
  3124,  1706,  1708,  1163,  1747,  6060, 11676, 11177,  6375,  6374, 11178 
  3125,  1046,   419,   420,  1573,  9655,  2573,  8941,  8940,  5436,  5435 
  3126,  2101,  2019,  1915,  2020,  9542,  7989,  9544,  9633,  7803,  7891 
  3127,  1667,  1378,  1613,  1190,  5886,  5872,  6108, 10192, 10206,  9445 
  3128,   374,   373,  1551,  1150,  2526,  5374,  5373, 11961, 11027, 11427 
  3129,   678,  1853,   619,   677, 10639,  7186,  6729,  2885, 11778,  6726 
  3130,  2168,  2100,  1917,  2049,  8578, 10938, 11509,  8618,  8615, 10937 
  3131,  2168,  2100,  2017,  1917,  8578, 10700, 11829, 11509, 10938,  7895 
  3132,  2111,  2180,  1959,  2110,  8593, 11259, 11269,  8732,  8730,  9430 
  3133,  1042,  1405,   415,  1571, 11383,  4987, 11381, 11435,  5595,  5432 
  3134,  1959,  2110,  2180,  1901,  9430,  8730, 11259,  7861, 10830,  9724 
  3135,  1541,   974,  1265,   973, 10985,  4323, 11355, 10986,  3804,  4324 
  3136,   791,   868,  2021,   790,  8023,  9002,  7805,  3002,  8062,  7804 
  3137,  1152,   394,  1390,  1520, 11962,  4953,  9269,  9267,  5704,  5556 
  3138,   675,   616,  1850,   617,  6723,  7177, 10605,  6722,  2822,  7178 
  3139,    85,  2111,  1959,    84, 10658, 11269,  7619,  2207, 10659,  7618 
  3140,  2179,  2111,    81,    84,  8457,  8313,  8458, 11963, 10659,  3122 
  3141,  1959,  2111,  2179,    84, 11269,  8457,  9428,  7618, 10659, 11963 
  3142,  1500,  1418,  1580,  1128,  5813,  5747,  5620, 11197, 10900, 10623 
  3143,  2052,   431,   430,  1923, 11410,  2584, 11409,  9756,  7510,  7509 
  3144,  2009,  1923,  2008,  2096,  7907,  7908,  7770, 10960, 11921, 11280 
  3145,  1074,  1073,  1584,  1274,  3597, 10672, 10060,  4357,  4360,  9631 
  3146,  1304,  1736,  1186,  1314,  9995, 11588,  4572,  4757, 11964,  4693 
  3147,   346,  1366,  1031,   276,  4880, 11855, 11854,  3737, 11869,  3468 
  3148,  2123,   431,  2052,  1923, 11923, 11410,  8473, 10401,  7510,  9756 
  3149,  1475,   520,   928,    46,  5166, 10572,  8803,  5165,  2683,  9849 
  3150,   865,  2169,   788,  2018,  8436,  9278,  8122, 11185, 10807,  7796 
  3151,   928,    46,    15,   959,  9849,  2789,  3207,  3866,  9850,  3269 
  3152,   165,  1502,  1130,    20, 10153, 10152,  3768,  2301, 10972,  3767 
  3153,  1701,  1652,   912,  1175,  6026,  9832, 11324,  9827,  9829,  4376 
  3154,   777,  2007,  2164,  2008,  7763,  9635, 11208,  7765,  7767, 11279 
  3155,  1174,  1301,  1284,  1711,  4557,  4551,  4420, 10302, 10290,  9695 
  3156,   173,   537,  1133,  1490,  6538,  9421,  3776, 10425,  5204, 10424 
  3157,  1407,   418,  1045,   419,  4992, 11691, 10694,  4991,  2572, 11281 
  3158,   422,  2048,   297,   423, 10026,  8184, 11965,  2576,  9066,  9064 
  3159,   451,   324,   450,  1077, 10568,  9708,  2604, 11602,  3604,  9707 
  3160,  1942,  2084,  2152,  1982, 10070,  8562, 10876,  7944,  9932,  9930 
  3161,  1162,  1469,   899,  1435,  8823, 10536,  3975,  8825,  5496, 10256 
  3162,  1831,   228,   369,   370,  7004, 11305, 11530, 11481,  9598,  2522 
  3163,  2082,  1946,  2134,  2063,  9495, 11175,  8668,  8669, 10075,  8484 
  3164,  1079,   453,  1452,  1424, 11492,  5479, 11330, 10579,  5025,  5102 
  3165,  1862,   629,  1779,  1821,  7214,  9317, 11528, 11529, 11079,  7075 
  3166,  1365,  1364,   345,  1032,  4879,  4875,  4877, 11009,  9967,  9966 
  3167,   327,  2063,  2134,   453,  8214,  8484,  8363, 10971,  9534, 11853 
  3168,  1957,  2143,  1958,  1963, 10847, 10948,  7616,  7972, 10231,  7973 
  3169,   337,  1088,   463,   464,  3638, 11478, 10820, 11374, 10944,  2617 
  3170,   991,  1034,   342,  1362,  3867, 11157, 10749, 10860,  9613,  4869 
  3171,   576,   214,   215,  1523,  6439,  2361,  6442,  5291,  9356,  8935 
  3172,   422,   423,   297,  1049,  2576,  9064, 11965, 11885, 11365,  3522 
  3173,   422,  1049,   297,   296, 11885,  3522, 11965, 11025,  3521,  2446 
  3174,  1178,  1388,  1683,  1719, 11827,  6172, 10382, 10384,  6264,  6393 
  3175,  1988,  2155,   837,   758, 10980,  8408, 10967,  7706, 11936,  8096 
  3176,   828,  1978,   748,   747, 11350,  7676,  8088,  8087,  7675,  2959 
  3177,  1078,   326,   452,   325,  3608, 10178, 10894,  3607,  2475, 11966 
  3178,  1530,   581,   208,    28,  5308,  6458, 10143, 10922,  6452,  2352 
  3179,  1933,   440,  2127,  1932,  7539,  9616, 10005,  7541,  7537,  9703 
  3180,   758,  2155,   837,   838, 11936,  8408,  8096,  8047,  8407,  3050 
  3181,   422,   296,   297,  2048, 11025,  2446, 11965, 10026,  8185,  8184 
  3182,   441,  1067,   440,  1418, 11303,  9619,  2594,  5013, 10899,  5014 
  3183,   342,   358,   991,  1362,  4868, 10750, 10749,  4869,  5353, 10860 
  3184,  1302,  1168,  1386,  1281,  4556, 11244,  9949,  4555,  4438,  9950 
  3185,  2012,  2166,   781,   860,  9884, 11913,  7777,  9056,  8429,  8119 
  3186,  1922,  2165,  2010,  2097, 11207,  9715,  7995, 11206,  8575, 10929 
  3187,   980,  1055,  1537,  1412,  4061, 11454, 10779, 11511, 11512,  5334 
  3188,  2098,  2012,  2013,   860, 10652,  7782, 10040,  8286,  9056, 10041 
  3189,  2124,   434,   308,   307,  8983, 11548,  8342,  8343,  9903,  2457 
  3190,   433,   434,  2124,   307,  2587,  8983,  8982,  9901,  9903,  8343 
  3191,  2003,   852,   851,   773, 11101,  3064,  9873,  7751,  8115,  8114 
  3192,   305,  1058,  1057,   431,  3547,  3549,  3545, 11290, 11967,  9564 
  3193,  2113,  2177,  1904,  1903,  8596,  9732,  9843, 10755,  9731,  7456 
  3194,   881,   805,  2177,   882,  8134, 11968,  8452,  3094,  8069,  8451 
  3195,   290,   416,   417,  1043, 10403,  2570, 10402,  3503, 10728, 10729 
  3196,  1339,  1198,  1614,  1309,  4727,  9309,  9308,  4726,  4608, 10163 
  3197,  1610,  1023,  1372,  1373, 11969, 11407,  5676,  5677, 11126,  4903 
  3198,   290,   416,  2115,  2045, 10403, 10255,  8322,  8179, 10405,  8532 
  3199,  1903,  2035,  2036,  2177,  7873,  7851,  7872,  9731,  9733, 11970 
  3200,  2109,  1903,  2036,  2177, 11616,  7872, 11699,  8587,  9731, 11970 
  3201,  2130,   446,   319,   445, 11919, 10850,  8355, 11262,  2599, 10804 
  3202,    83,  2180,    85,    82,  8459, 11348,  3125,  2203,  8460,  3124 
  3203,   449,  1941,  2061,  2132,  7564,  8745,  8866,  8867, 11661,  8482 
  3204,  1874,   699,   641,  1875,  9242,  6808,  7250,  7254,  9243,  7252 
  3205,  1786,   700,  1827,  1875,  6857,  6994,  7077,  9678, 11971, 10466 
  3206,    80,    79,    72,  1091,  2199,  3118,  3119,  3647,  3650,  9921 
  3207,   446,  1421,  1073,  1072,  5020, 10673, 11574, 10852, 11673,  3594 
  3208,   642,   700,  1786,  1875,  6801,  6857, 10563,  7253, 11971,  9678 
  3209,  1639,  1099,   891,  1439, 11667,  3868,  9352,  5782,  9956, 10360 
  3210,    48,   541,    21,   952,  2708,  6546,  2791, 10273, 10274,  3255 
  3211,   793,  2103,  2024,  2023, 11399, 10355,  7813,  7811, 11459,  7815 
  3212,  1762,  1347,  1763,  1765, 11972,  9770,  6352,  6403, 11559,  6368 
  3213,  1225,  1708,  1706,  1444, 11677,  6060, 11973, 11974,  6059,  6052 
  3214,   954,  1740,  1489,  1645, 10635,  6240, 10406,  9773,  6241,  5801 
  3215,   491,   130,   131,  1425,  6628,  2260,  6621,  5504, 10488, 11494 
  3216,  1301,  1164,  1735,  1697,  4710, 11748, 11742,  9197,  9199,  6206 
  3217,  1174,  1176,  1647,  1740,  4408, 11493, 10301, 11658, 10871,  6262 
  3218,  1174,  1490,  1133,  1740, 11599, 10424,  4026, 11658,  6226, 10636 
  3219,    22,    47,  1491,   956,  2790,  5208, 10642,  3264, 10112,  9688 
  3220,   377,  1003,   376,  1384, 11960, 10303,  2529,  4934, 10304,  4935 
  3221,   253,  1774,   396,   252,  6931, 10814, 10372,  2400,  6932, 10816 
  3222,  2130,   445,  1937,  1938, 11262,  7552, 10724, 10964,  7554,  7556 
  3223,   253,   396,   397,  1010, 10372,  2549,  9588,  3407, 10818,  9584 
  3224,   667,   666,  1811,  1842,  2874,  6954,  6953, 10575, 10066, 10576 
  3225,  1408,  1264,  1573,  1689, 11975, 11587,  5627,  5995,  9123,  5999 
  3226,    25,    53,   191,  1516,  2780,  6412,  2332,  9980,  5270, 11976 
  3227,   342,  1362,  1034,   343,  4869,  9613, 11157,  2494,  4870, 10720 
  3228,   608,   666,   667,  1842,  6707,  2874,  6811,  7153, 10066, 10575 
  3229,  1024,  1025,  1371,   270,  3452, 11425, 10174,  3448,  3450, 10175 
  3230,   271,   270,   351,  1025,  2419,  5147,  5148,  3451,  3450, 11424 
  3231,  1026,  1025,   271,  1370,  3455,  3451,  3453, 11877, 11426, 11363 
  3232,   289,  2115,   415,  2044,  8323, 10709, 11977,  8176,  8465, 10710 
  3233,   418,   417,  1572,  1044,  2571,  5434,  5433, 11456, 11696, 11614 
  3234,   415,   414,  1405,  1041,  2568,  4988,  4987, 11382, 11545, 10155 
  3235,  2177,   805,  2036,   882, 11968,  7849, 11970,  8451,  8069, 11929 
  3236,   730,  1960,  2142,  1961,  7623, 11609,  9794,  7624,  7626,  9795 
  3237,  1440,   475,  1441,    90,  5061,  5063,  5065, 11541,  6608, 10055 
  3238,  1308,  1616,  1742,  1637, 11978,  6236, 11943, 11136,  5979,  6237 
  3239,  2130,  1938,   446,   445, 10964,  7555, 11919, 11262,  7554,  2599 
  3240,  1667,  1307,  1745,  1743,  9974, 11777,  6273,  6252, 11135,  6272 
  3241,  1442,    91,  1441,   476, 11744, 10056,  5068,  5066,  6607,  5064 
  3242,  2028,  1908,  2105,  2174,  7881, 10627, 10224, 11719, 11356,  8524 
  3243,  1274,  1112,  1450,  1584,  4358, 11413, 11865,  9631, 10059,  5755 
  3244,  1924,   431,  2123,  1923,  7512, 11923,  8979,  7514,  7510, 10401 
  3245,  1059,  1414,  1253,  1226, 10386, 10388,  4486,  4215, 10379,  4485 
  3246,  1266,   983,  1288,  1682,  4327,  4444,  4443,  9868, 11450,  9878 
  3247,   990,  1525,    54,   216,  9372,  5295,  9370,  3332,  9645,  6443 
  3248,    23,    54,   960,   563,  2781, 10370,  3272,  6413,  2734, 10371 
  3249,   483,  1450,   122,  1759,  5089, 11412,  6619,  5091,  5093, 10508 
  3250,  2182,    40,  1449,    13, 11322,  5086, 11979, 11858,  2799, 10878 
  3251,  1449,   121,   917,    13, 11411,  3182, 11465, 10878,  2250,  3183 
  3252,   388,  1821,  1861,  1862, 11980, 11349,  7377,  7376, 11529,  7215 
  3253,   954,   172,   536,  1489,  3259,  6536, 11293, 10406, 10407,  5202 
  3254,   330,   456,  2065,   457,  9589,  9985,  8219, 10738,  2610, 10057 
  3255,  1863,  1864,  1822,   630,  7221,  8768,  8767,  7217,  7219, 11525 
  3256,   967,  1514,  1678,   968,  9232,  5913,  9233,  3794, 10524, 10991 
  3257,  1195,  1690,  1544,  1138, 11981,  5945, 11693,  4119, 11336, 11331 
  3258,  1675,   959,  1484,  1485,  8805, 11982,  5906,  5907,  8806,  5528 
  3259,   414,   413,  1404,  1040,  2567,  4986,  4985, 11657, 11551, 11550 
  3260,   967,  1513,  1514,   560,  9234,  5549,  9232, 11983,  5264,  5265 
  3261,   969,   970,   191,  1516,  3796,  3292,  3289, 11984,  9982, 11976 
  3262,  1239,  1238,  1430,  1703,  4255, 11308,  9493, 10108, 10107,  6036 
  3263,  2140,  2070,  2039,  2040,  8553, 10992, 10117, 10118, 10947,  7977 
  3264,  1315,  1729,  1333,  1204,  9440, 11213,  4819,  4612, 11417,  4747 
  3265,  1315,  1611,  1728,  1729, 11985,  6156,  9438,  9440,  6158,  6160 
  3266,   190,   189,  1514,   560,  2330, 10523, 11759,  6409,  6406,  5265 
  3267,    52,   189,   967,    24,  6407,  3285,  9740,  2779,  2329,  3286 
  3268,   506,    97,   899,     9,  6671,  3146, 11523,  6669,  2222,  3147 
  3269,   968,   189,  1514,   190,  3288, 10523, 10524,  3287,  2330, 11759 
  3270,   716,   659,  1892,   717,  6788,  7304,  9570,  2924,  6791,  9312 
  3271,  2174,  1908,  2105,  2115, 11356, 10627,  8524,  8602, 10254,  8605 
  3272,  1888,   365,   366,  1799,  7336,  2518,  7337,  9648, 10247,  9286 
  3273,  2039,   467,  1900,  2070,  7865,  7859,  7889, 10992, 11187, 11043 
  3274,  1243,   896,  1715,   897,  4267, 10280, 10241,  4266,  3679, 10281 
  3275,  1921,  2051,  2097,  2166,  9436,  8717,  9888,  9883,  8711,  8516 
  3276,  1768,   607,   606,  1841, 11986, 10182,  6950, 11387,  7151, 10181 
  3277,   865,   787,  2100,  2018,  8121, 10701,  8289, 11185,  7795, 10702 
  3278,  2181,   478,    93,  1101, 10614,  6599, 10714, 10715, 11895,  3675 
  3279,   425,  1051,  1052,   299, 11317,  3531, 11316, 11987,  3527,  3529 
  3280,   341,   264,    35,    33,  3432,  4627,  9484,  2491,  2412,  4628 
  3281,   415,  1908,  1907,  2044,  7465,  7467,  7464, 10710, 10711, 11725 
  3282,  1381,  1469,   507,  1102,  5685,  5149,  5965,  9481, 11988, 11468 
  3283,   407,   604,   601,  1897,  9280,  6694,  7318,  7413,  9266,  7319 
  3284,   832,  1982,   751,   831,  9931,  7687,  8148,  3044, 11947,  8147 
  3285,   341,    33,    35,   887,  2491,  4628,  9484,  8230,  3101,  4795 
  3286,   506,   899,  1102,  1469, 11523,  3871, 11989,  5146, 10536, 11988 
  3287,  1571,  1043,   416,  1042, 10734, 10728,  5431, 11435,  3505, 11656 
  3288,  1081,   456,  1426,  1587, 10736,  5030,  9803,  9804,  5481,  5480 
  3289,   466,   340,   341,  2070,  9808,  2490, 11300, 10993,  8229,  8228 
  3290,   370,  1831,   228,   229, 11481,  7004,  9598,  9599,  7031,  2376 
  3291,  1103,   508,  1381,   368, 11367,  5689, 11916, 11990,  4925,  4922 
  3292,  1704,  1296,  1436,  1700, 10203, 11834,  6038,  6039, 11942,  6019 
  3293,   514,   513,   903,  1550,  2675, 11889, 11378,  5151,  5150, 11162 
  3294,  1307,  1743,  1308,  1347, 11135, 11137,  4585,  4780, 10221,  4781 
  3295,   439,  1417,  1066,  1065,  5011,  9091, 11682, 11686,  9134,  3573 
  3296,  2127,   313,   440,   314,  8349, 11750,  9616,  8348,  2463,  9617 
  3297,  1684,  1538,  1530,   982,  5928,  5565,  5929, 11670, 11991, 10142 
  3298,  1185,  1699,  1576,  1413,  8912,  6204,  8911, 11292,  6163,  5647 
  3299,   439,  1417,  1580,  1066,  5011,  5538,  5461, 11682,  9091,  9089 
  3300,  1531,   582,   209,   581,  5310,  6454, 11264,  5309,  2756,  6453 
  3301,   466,  2070,   341,   467, 10993,  8228, 11300,  2620, 11187,  9485 
  3302,   887,   467,   727,    35,  9486,  7441,  4849,  4795,  2621,  2937 
  3303,   602,   603,  1838,   605,  2805, 10209,  9898,  6696,  6700,  7120 
  3304,  1115,   127,   488,   128,  3719,  6638,  8873,  3718,  2257,  6633 
  3305,  1900,   467,   727,   887,  7859,  7441,  7442, 11041,  9486,  4849 
  3306,  1103,   368,  1381,   999, 11990,  4922, 11916,  4380, 11893,  9482 
  3307,   451,  1078,   452,   325, 11524, 10894,  2605, 10567,  3607, 11966 
  3308,  1482,  1674,  1716,   956,  5904,  6118,  6117,  9690, 10959,  9689 
  3309,  1176,  1740,   954,  1645, 10871, 10635,  4042,  9772,  6241,  9773 
  3310,  1838,   603,   606,   605, 10209,  6699,  7123,  7120,  6700,  2810 
  3311,  1385,   930,  1118,   523, 11182,  3732, 11031,  5174, 11992, 11344 
  3312,   380,   379,  1385,   929,  2532,  4937,  4936, 11033, 11030, 10395 
  3313,  1258,  1674,   957,   956,  8951, 10300,  4305,  4306, 10959,  3779 
  3314,  1075,  1076,  1585,   449,  3603,  8880, 11736, 10868, 10649,  5472 
  3315,  1823,  1780,  1805,  1866,  7057,  7111,  7090, 10906, 10921, 10618 
  3316,  1173,  1736,  1679,  1314,  9528,  6201, 10935,  4607, 11964, 11589 
  3317,  1900,   467,   887,  2070,  7859,  9486, 11041, 11043, 11187,  8376 
  3318,  1422,  1593,  1585,  1113,  5757,  5756,  5608, 11737,  8903, 10803 
  3319,   606,   665,    61,    60,  6819,  2872,  2811,  6698,  6703,  2807 
  3320,   547,  1417,   946,  1580,  5230,  9090, 10841,  5539,  5538,  9088 
  3321,  1651,  1384,  1282,  1553,  6169, 11617,  9246,  6168,  5697, 11486 
  3322,   693,  1782,   635,   634,  6848,  9629,  6755,  6806, 11129,  2840 
  3323,  2181,   894,    93,  1444, 10716,  3137, 10714, 10613,  9101,  9100 
  3324,   733,   732,   814,  1963,  2944,  8077,  8078,  7631,  7630, 10230 
  3325,   814,  2075,   733,  1963,  8240, 10132,  8078, 10230, 10133,  7631 
  3326,  1570,   412,  1039,   413,  5429,  9433, 10449,  5428,  2566, 11552 
  3327,  1283,  1501,  1502,   948, 11600,  5237, 10874,  4413,  8876, 10154 
  3328,    78,    79,  1097,    71,  2198,  3665,  3664,  3116,  3117, 11838 
  3329,    92,   478,  1101,    93,  6596, 11895,  3676,  2216,  6599,  3675 
  3330,  1097,    79,  1400,    71,  3665, 11730, 11837, 11838,  3117,  4976 
  3331,  1132,   170,   535,   171,  3775,  6531, 11212,  3774,  2308,  6534 
  3332,  1488,  1487,   953,  1652,  5201,  8914,  8913,  5823,  5822, 11451 
  3333,    89,  1440,   892,    90,  8822,  8863,  3133,  2213, 11541,  3132 
  3334,  1794,   221,   220,   362,  6886,  2368,  6887,  9699,  9697, 10831 
  3335,   477,   478,  1101,    92,  2633, 11895, 11313,  6597,  6596,  3676 
  3336,  1452,   490,   921,   489,  5101, 11938, 10128,  5100,  2647, 10130 
  3337,   389,  1778,  1860,  1861, 11222, 11935,  7379,  7378, 11223,  7212 
  3338,  2120,  1919,   426,  1918, 10754,  7497, 10753,  9327,  7499,  7495 
  3339,  1640,  1439,  1099,  1639,  5784,  9956, 11549,  5786,  5782, 11667 
  3340,  2014,   861,  2013,   783, 11766, 10042,  7785,  7783,  8166,  7781 
  3341,  1651,  1259,  1734,  1674,  9245,  8950,  6187,  5962,  8952,  6189 
  3342,  1042,   416,   290,  1043, 11656, 10403,  3501,  3505, 10728,  3503 
  3343,  1137,   600,  1544,  1545,  9523,  5348, 10473,  9524,  5350,  5352 
  3344,  1483,   956,   530,   174, 10369, 10111,  5188,  8956,  3263,  6523 
  3345,   917,  1458,  1449,  2182, 11878,  5508, 11465, 11993, 11323, 11979 
  3346,   237,   379,   238,   929,  8899, 11994,  2385,  3378, 11030,  3379 
  3347,   591,   592,   979,   204,  2767, 10557, 10556,  6478,  6477,  3309 
  3348,  1640,  1639,  1099,  1231,  5786, 11667, 11549,  9466,  9467,  4231 
  3349,  1871,  1784,  1803,  1825, 10306,  7087, 10305, 10903,  7076,  7088 
  3350,  2119,  1916,   424,   423, 10931,  7489,  9086,  9065,  7488,  2577 
  3351,  1823,  1780,  1866,  1865,  7057, 10921, 10906,  8757,  8759,  7227 
  3352,   200,   977,  1141,  1600,  3305,  3908,  3811,  8762, 11362,  8761 
  3353,   591,  1411,   590,  1142,  5329,  5328,  2766, 11610, 11372, 11373 
  3354,   381,  1869,  1783,  1824,  7365,  9676, 11342, 11343,  9677,  6984 
  3355,  1147,  1523,  1522,  1183,  9411,  5559,  9013,  4065, 11995,  9673 
  3356,  1640,  1231,  1099,   892,  9466,  4231, 11549,  8862,  4230,  3859 
  3357,   686,  1861,  1778,  1821,  9377, 11223,  6840,  6979, 11349,  7055 
  3358,  1295,  1556,  1473,  1250, 11074,  5816, 11075,  4513, 10647, 11069 
  3359,   892,    89,   474,  1440,  3133,  6606,  8871,  8863,  8822,  5060 
  3360,   892,  1439,  1640,  1440,  8872,  5784,  8862,  8863,  5062,  5785 
  3361,   411,   410,  1566,  1037,  2564,  5415,  5417,  9927, 11674,  9928 
  3362,  1187,  1173,  1509,   938,  4558,  9020,  9151,  4292,  4023,  9074 
  3363,  1162,  1549,   998,  1381,  8824,  9650,  4342, 11597,  5367,  9862 
  3364,  1422,  1759,  1112,  1450,  6336, 11169, 10322,  5754,  5093, 11413 
  3365,   529,    16,  1481,   145,  6501, 11514,  5182,  6503,  2277, 11764 
  3366,  1782,  1781,   634,   692,  6983,  9374, 11129,  6849,  6846,  6752 
  3367,  1108,   112,   498,  1461,  3698,  6651, 10936, 11808, 11672,  5124 
  3368,  1584,  1422,  1112,  1450,  5632, 10322, 10059,  5755,  5754, 11413 
  3369,   129,   489,   921,   490,  6635, 10130,  3190,  6634,  2647, 11938 
  3370,   940,   553,   941,   153,  8967, 10171,  3753,  3231,  6573,  3234 
  3371,   553,   940,   552,   152,  8967, 11700,  2721,  6570,  3232,  6571 
  3372,   232,   374,  1801,   233,  9098, 10856,  6904,  2380, 11996,  6903 
  3373,   517,    10,   905,   108,  6672,  3158,  9083,  6674,  2234,  3159 
  3374,   249,   963,   248,   391,  3402,  3401,  2396, 11446, 11447,  9561 
  3375,   243,   385,   386,  1007, 11247,  2538, 11246,  3388, 11268,  9359 
  3376,   979,  1411,   591,  1142, 10744,  5329, 10556,  3955, 11372, 11610 
  3377,  1807,  1818,  1856,  1776,  7132, 10882,  8938,  7131,  7074, 11007 
  3378,  1276,  1460,  1461,  1108, 11092,  5126, 11091,  4371, 10365, 11808 
  3379,  1264,   973,   972,  1689,  4321,  3803,  4322,  9123, 11861,  9122 
  3380,  1205,  1204,  1022,  1611,  4149,  4145,  4147, 11997, 11630, 11998 
  3381,   552,   940,  1503,   152, 11700, 11506,  5239,  6571,  3232, 11507 
  3382,  1023,  1373,  1610,  1205, 11126,  5677, 11969,  4148, 11127, 11595 
  3383,   466,  1156,   341,   340,  9807,  3861, 11300,  9808,  3860,  2490 
  3384,  1026,  1369,  1209,  1370, 11653, 11999,  4159, 11877,  4894, 11707 
  3385,  1541,   973,   972,   597, 10986,  3803,  9061,  5341, 10987,  9063 
  3386,  1108,  1461,   498,  1460, 11808,  5124, 10936, 10365,  5126,  5122 
  3387,  2028,  1908,  2174,  2029,  7881, 11356, 11719,  7830,  7992, 11950 
  3388,  2174,  1908,  2030,  2029, 11356,  7985, 11951, 11950,  7992,  7833 
  3389,   113,  1461,   910,  1109,  8905, 11671,  3168,  3701, 11482,  3878 
  3390,   967,  1513,  1521,  1285,  9234,  5550,  9741,  4422, 11564, 11565 
  3391,  1537,   593,   980,  1412,  5332, 11357, 10779,  5334,  5331, 11511 
  3392,  1503,  1171,  1671,   939,  9506,  9505,  5898, 11505,  4020, 11832 
  3393,   921,   489,   129,   128, 10130,  6635,  3190,  3191,  6632,  2258 
  3394,   410,   409,  2112,  1902,  2563, 12000, 10609,  7449,  7448, 11911 
  3395,  1656,   941,  1254,  1253, 10052,  4296, 10681, 10644,  4293,  4649 
  3396,   972,   973,   194,   597,  3803,  3298,  3295,  9063, 10987,  6490 
  3397,  1500,   548,   162,  1128,  5231,  6562, 10620, 11197, 10621,  3762 
  3398,   939,   940,  1503,  1171,  3752, 11506, 11505,  4020,  4019,  9506 
  3399,  1936,   444,  2059,  2129,  7549, 11944, 12001, 10121, 11782,  8542 
  3400,  1078,  1586,   452,  1424,  8984,  5474, 10894, 10580,  5473,  5026 
  3401,  1389,   390,   961,   962,  4946, 10915, 10485, 10486,  9165,  3900 
  3402,   551,   164,   165,   948,  6553,  2300,  6556,  8877,  3248,  3247 
  3403,  1115,  1586,  1078,  1424,  8985,  8984,  4001,  9512,  5473, 10580 
  3404,   481,  1447,   480,   134,  5081,  5080,  2637,  6613,  9027,  6612 
  3405,   459,  2137,   333,   460, 10835,  8369,  9963,  2613, 10836, 11933 
  3406,  1276,  1108,  1461,   910,  4371, 11808, 11091,  4373,  3929, 11671 
  3407,  1195,  1754,  1746,  1311, 12003,  6306, 12002,  4596, 10251,  9905 
  3408,  2138,  1953,  2067,  2077,  9127, 10824,  8488,  8684,  9039,  8685 
  3409,   403,   402,  1394,  1016,  2555,  4961,  4960,  9283,  9171,  9282 
  3410,  1665,  1754,  1746,  1195,  6304,  6306,  6276, 11694, 12003, 12002 
  3411,  1295,  1556,  1250,  1006, 11074, 10647,  4513,  4657, 11064,  4653 
  3412,  1101,  1160,  1643,   893,  3970, 12005, 12004,  3870,  3971,  9303 
  3413,  1216,  1215,  1363,  1692,  4182, 12006,  9614, 10197, 12007,  5952 
  3414,   246,   961,   389,   247,  3397,  9471,  9173,  2394,  3398,  9538 
  3415,   628,   627,   686,  1861,  2833,  6743,  6742,  7211,  7210,  9377 
  3416,  1779,  1806,  1863,  1862,  7083, 10500,  9376, 11528,  9336,  7218 
  3417,  1031,  1366,  1365,  1603, 11855,  4882, 10990, 10988,  5656,  5655 
  3418,   264,   357,   265,  1019,  8734,  8733,  2413,  3433,  9825,  3434 
  3419,   267,  1374,  1022,  1021,  9475,  9473,  3441,  3439, 11654,  3443 
  3420,   353,  1023,   268,  1373, 11406,  3444,  6320,  4901, 11126, 10743 
  3421,  1778,  1861,   686,   685, 11223,  9377,  6840,  6841,  9378,  2893 
  3422,   607,  1768,   606,   665, 11986,  6950, 10182,  6702,  6821,  6819 
  3423,  1203,  1729,  1333,  1703,  9725, 11213,  4746, 10166,  6233, 10078 
  3424,  1812,   610,  1843,  1844, 11107,  7157, 11542,  9712,  7159,  7161 
  3425,   144,  1480,  1121,   145, 11627, 11504,  3740,  2276, 11335,  3739 
  3426,   404,  1769,  1811,  1843, 12008,  6952, 11272,  7407, 10465, 10574 
  3427,  1808,  1844,  1812,  1769, 11897,  9712,  7130,  7119, 10464,  7048 
  3428,    98,   900,    99,   508,  3149,  3148,  2224,  6677, 11368,  6680 
  3429,  1481,  1472,  1386,  1281,  5184,  5951,  6260, 11334, 10004,  9950 
  3430,  1561,   397,  1011,   398,  5406,  9115, 11615,  5405,  2550,  9116 
  3431,   403,  1844,  1808,  1769,  7405, 11897, 11403, 10463, 10464,  7119 
  3432,  1481,  1480,   529,   145,  5185,  5180,  5182, 11764, 11335,  6503 
  3433,   237,   929,  1005,   379,  3378,  4110,  3376,  8899, 11030,  9605 
  3434,  1811,  1769,   667,  1843,  6952,  6823,  6953, 10574, 10465, 10573 
  3435,   403,  1769,  1808,   259, 10463,  7119, 11403, 11404,  6944,  6941 
  3436,   260,  1769,   404,   403,  6943, 12008, 10167, 11445, 10463,  2556 
  3437,  1101,  1160,  1225,  1643,  3970,  4209,  4208, 12004, 12005, 12009 
  3438,   393,  1807,   250,  1775, 11346,  6927, 10334, 11117,  7115,  6930 
  3439,   246,  1778,   389,   388,  6922, 11222,  9173,  9174, 11224,  2541 
  3440,  1387,  1556,  1295,  1006,  5583, 11074, 11076, 11063, 11064,  4657 
  3441,  1779,  1862,  1863,   629, 11528,  7218,  9376,  9317,  7214,  7216 
  3442,   349,   273,  1027,  1368,  4465,  3457, 10772,  4887,  9163,  9161 
  3443,  1497,  1125,   542,   156, 11539, 11464,  5221, 11537,  3756,  6550 
  3444,  1685,  1188,   989,  1686,  9777,  4092,  9338,  5982,  9364, 11948 
  3445,  1497,   542,   543,   156,  5221,  2710,  5222, 11537,  6550,  6549 
  3446,  1302,   384,   385,  1556, 10800,  2537, 11685,  9951,  5389,  5388 
  3447,  1321,  1721,  1722,  1212, 12010,  6139, 10412,  4633, 12012, 12011 
  3448,   510,   511,   370,  1104,  2672,  5875,  4926, 11886, 11712, 11711 
  3449,   395,   394,  1390,  1152,  2547,  4953,  4952, 10235, 11962,  9269 
  3450,  1698,  1342,  1309,  1617, 12013,  4741,  9263,  6182, 11953, 10164 
  3451,  1196,  1561,  1011,  1392, 11401, 11615,  4121, 11533,  5587, 10216 
  3452,  1661,  1560,  1261,  1262,  6193,  9748,  9746, 11253, 12014,  4523 
  3453,  1559,   392,   569,   963,  5397,  4950,  5558,  9781,  9168,  9782 
  3454,  2179,    84,    81,   809, 11963,  3122,  8458, 10958,  7617, 10781 
  3455,  1262,  1560,  1261,  1153, 12014,  9748,  4523,  4594,  9325,  4655 
  3456,  1039,  1220,  1404,  1040,  4191, 10446, 10448,  3497,  4192, 11550 
  3457,   413,  1040,   287,  1039, 11551,  3495, 11880, 11552,  3497,  3493 
  3458,   411,  1037,  1038,   285,  9927,  3491,  9933, 10349,  3487,  3489 
  3459,  1199,  1015,  1200,  1688,  4130,  4132,  4134,  9248, 11167,  9259 
  3460,   188,   966,    24,   574,  3284,  3283,  2328,  6414, 11561,  6416 
  3461,   296,   422,   421,  2118, 11025,  2575, 11254,  8329, 10690, 11019 
  3462,  1654,  1256,  1493,  1494, 10458, 10908,  5827,  5828, 10910,  5533 
  3463,   166,   539,   950,   167,  6540, 12015,  3252,  2303,  6543,  3251 
  3464,   188,   574,   573,  1136,  6414,  2745,  6415,  3791, 11560, 10436 
  3465,   976,   585,  1139,  1409, 11873, 12016,  3958, 11941,  6243, 11352 
  3466,  1409,   422,  1574,  1049,  4996,  5437,  5628, 11364, 11885, 12017 
  3467,   950,   539,   540,   167, 12015,  2706, 10961,  3251,  6543,  6542 
  3468,   392,   391,   569,   963,  2544,  4951,  4950,  9168, 11447,  9782 
  3469,  1926,  2163,  2094,  2005, 11258,  8513, 10248,  7998, 10045, 11142 
  3470,  1496,  1579,  1415,  1172,  5745,  5601,  5746,  8991, 12018,  8993 
  3471,  1947,  2081,  1977,  1946, 12019, 10950,  7953,  7583, 11103,  7952 
  3472,  2027,  1909,  1910,  2173,  7883,  7473,  7884,  8850,  8852, 10008 
  3473,   417,   416,  2045,  1909,  2570, 10405, 10404,  7469,  7468, 10616 
  3474,  2101,   866,   789,   867,  8292,  8060,  9632,  8291,  3079,  8097 
  3475,  1302,  1556,   385,  1006,  9951,  5388, 11685,  4588, 11064, 11062 
  3476,   418,  1045,   419,   292, 11691, 11281,  2572,  9329,  3509, 12020 
  3477,   565,   178,  1599,   564,  6421, 12021,  5555,  2736,  6419,  5554 
  3478,  1599,   178,   565,   179, 12021,  6421,  5555, 12022,  2318,  6423 
  3479,  1503,   940,  1504,  1171, 11506, 10051,  5541,  9506,  4019, 10660 
  3480,   925,  1446,  1278,  1644,  9026, 11181,  4385, 10022,  5796, 11240 
  3481,  1504,  1655,  1503,  1171,  5832,  5831,  5541, 10660,  9507,  9506 
  3482,  1907,  2030,  2031,  2106,  7986,  7836,  7978, 11724, 10770, 11660 
  3483,  2069,  2143,  1958,  1957,  8629, 10948, 11039, 10846, 10847,  7616 
  3484,  2142,  2074,  1961,  2040,  8592, 10030,  9795, 10945, 11022,  7976 
  3485,  1156,  1592,  1090,   466,  8814,  8813,  3964,  9807,  5491,  9806 
  3486,   298,   424,   425,  1051,  9085,  2578, 11160,  3526, 11905, 11317 
  3487,  1599,   178,  1518,   564, 12021, 11645,  5849,  5554,  6419,  5274 
  3488,  1156,   466,  1431,  1592,  9807,  5040, 10179,  8814,  5491,  5636 
  3489,  1442,  1643,  1101,  1443,  5793, 12004, 11314,  5071,  5794, 10113 
  3490,  1599,   178,  1134,  1518, 12021,  3784,  9030,  5849, 11645, 10390 
  3491,  2181,  1444,    93,   478, 10613,  9100, 10714, 10614,  5072,  6599 
  3492,  1290,   896,  1715,  1243,  4453, 10280, 10312,  4468,  4267, 10241 
  3493,  1224,  1664,  1573,  1689,  9128,  6013, 11586,  9129,  6107,  5999 
  3494,   892,  1440,  1100,    90,  8863, 10410,  3869,  3132, 11541,  3674 
  3495,  1664,  1286,  1540,  1689,  9130, 11717,  5871,  6107,  9124,  5941 
  3496,  1573,  1264,  1224,  1689, 11587,  4480, 11586,  5999,  9123,  9129 
  3497,  1167,  1587,  1155,  1081,  8740, 11329,  4116,  4117,  9804,  3919 
  3498,   826,  2081,   827,   746,  8252,  8251,  3039,  8086, 10951,  8043 
  3499,  1599,   179,   961,   178, 12022,  3273,  9032, 12021,  2318,  3274 
  3500,  1134,  1599,   961,   178,  9030,  9032,  3783,  3784, 12021,  3274 
  3501,  1181,  1263,  1338,  1681,  4320,  4718,  4717,  9294, 11866, 10215 
  3502,  1104,   511,   102,   101, 11712,  6693,  3686,  3687,  6686,  2227 
  3503,  2124,  2053,   433,   307,  8474,  9565,  8982,  8343,  8194,  9901 
  3504,   510,   511,  1104,   101,  2672, 11712, 11886,  6687,  6686,  3687 
  3505,   120,   915,   495,   119,  3178,  9186,  6645,  2248,  3179,  6644 
  3506,   969,   191,  1515,  1516,  3289, 11152,  9892, 11984, 11976,  5552 
  3507,  1132,  1179,  1662,  1275,  4049, 10150, 10151,  4415,  4417, 10364 
  3508,  1585,  1076,  1075,  1113,  8880,  3603, 11736, 10803,  4004,  4225 
  3509,   205,   204,  1143,   592,  2348,  3815,  3814,  6469,  6477, 11026 
  3510,  2131,   322,   448,  2061,  8356, 10867, 11806,  8544,  8211, 10320 
  3511,  1195,  1138,  1181,  1690,  4119,  4056,  4475, 11981, 11336, 12023 
  3512,  1095,  1567,  1399,  1619,  9852,  5641,  9857, 10071,  5711,  5710 
  3513,   829,  1979,  2082,  2151, 10207,  9496,  8253,  8400, 10085,  8501 
  3514,   587,  1535,  1140,  1410,  5323, 10704, 10703,  5324,  5439, 11575 
  3515,  2141,  2073,   810,   729,  8724,  8236,  8380, 11580,  8918,  8011 
  3516,  1410,   977,   587,   588, 11576, 11035,  5324,  5325, 11036,  2763 
  3517,  2153,  1941,  1942,  2132, 10872,  7568, 10069,  8660, 11661, 10877 
  3518,  1145,    29,    56,   211,  3823,  2783,  9389,  3822,  2356,  6446 
  3519,  1526,   578,   986,   211,  5297, 12024, 10173,  8838,  6445,  3324 
  3520,  1026,  1369,  1027,  1209, 11653, 10773,  3458,  4159, 11999,  4160 
  3521,  1826,   698,   697,  1873,  6991,  2905,  6992, 11057, 11620, 11619 
  3522,  1526,   986,  1145,   211, 10173,  3961,  9390,  8838,  3324,  3822 
  3523,  1475,  1476,  1119,   928,  5169,  8882,  8885,  8803, 11918,  3733 
  3524,  1717,   959,  1161,  1260,  8804,  3973, 11752,  8794,  4309,  4363 
  3525,   175,  1483,   958,  1484,  9934,  9922,  3268,  9935,  5527, 12025 
  3526,  1145,   211,    56,  1526,  3822,  6446,  9389,  9390,  8838,  5296 
  3527,  1794,   222,   363,  1835,  6888, 10080,  9700,  7082,  7104,  9489 
  3528,  1496,   542,   943,    50,  5220,  8961, 11703,  5219,  2709,  8962 
  3529,  1793,  1890,   363,  1835,  9572,  7332, 10457,  7025,  9573,  9489 
  3530,    69,  1399,  1095,  1567,  4974,  9857, 10409,  5419,  5641,  9852 
  3531,   309,  2125,   436,   435,  8345,  9009, 11318, 11124, 11325,  2589 
  3532,  1926,  2162,  2124,  1927, 10249,  8631,  8981,  7523, 11090, 12026 
  3533,  1379,   995,  1192,   996,  9799,  4101, 10542,  9408,  3350,  4102 
  3534,   951,  1494,  1495,   541,  9215,  5534,  9214, 10667,  5216,  5217 
  3535,   566,   567,   962,   180,  2738,  9166, 10790,  6424,  6426,  3276 
  3536,  1801,   374,   375,   233, 10856,  2527, 10291,  6903, 11996, 10292 
  3537,  1893,   660,   717,   659,  7307,  6790,  9311,  7306,  2865,  6791 
  3538,   991,   281,   342,   280,  3336,  6269, 10749,  3852,  2429,  6266 
  3539,    34,  1840,   726,   724,  7147,  7146,  2936,  4526,  9499,  6390 
  3540,  1185,  1056,  1057,  1413,  4212,  3546,  4213, 11292, 11289,  9563 
  3541,   617,  1851,   675,   676,  7180, 10606,  6722,  6725, 10453,  2883 
  3542,   384,   383,  1386,  1151,  2536,  4941,  4940, 10801, 11555, 10593 
  3543,  1852,   619,  1816,   618,  7184,  9238,  9140,  7183,  2824, 10541 
  3544,  1525,  1686,  1269,  1719,  5933,  9363, 12027,  6127,  6263, 11500 
  3545,   375,   233,   234,  1828, 10292,  2381, 10555, 10293,  7032,  7034 
  3546,  1518,  1683,  1134,  1558,  5927, 10389, 10390,  6097,  6122,  9029 
  3547,  1851,   676,  1816,  1773, 10453,  6965, 10368, 10358,  6830,  7052 
  3548,   604,  1810,   605,  1897,  6949,  6948,  2809,  9266, 10825,  9265 
  3549,  1827,  1875,   377,  1802, 10466,  7428, 11237,  7094,  9679, 11959 
  3550,   474,  1439,    88,  1099,  5058,  9402,  6604,  9955,  9956,  3672 
  3551,  1786,  1828,  1877,  1876,  7062, 10518, 12028,  9271,  9273,  7260 
  3552,   375,  1383,  1001,   374,  4932, 11230, 11229,  2527,  4933, 12029 
  3553,   138,   522,  1385,   523,  6510,  5173, 10394,  6509,  2686,  5174 
  3554,   375,   374,  1001,   233,  2527, 12029, 11229, 10292, 11996,  3366 
  3555,  1856,  1807,  1775,  1818,  8938,  7115, 11345, 10882,  7132,  7054 
  3556,  1765,  1763,  1743,  1347,  6368,  6358,  6366, 11559,  9770, 10221 
  3557,  1060,  1578,  1254,  1253, 10676, 10159,  4489,  4488, 10387,  4649 
  3558,   245,   387,   244,  1806,  9607, 11882,  2392,  6920,  9337,  6921 
  3559,  1060,  1061,  1254,  1578,  3558,  4490,  4489, 10676, 10677, 10159 
  3560,  1665,  1754,  1195,  1182,  6304, 12003, 11694, 11585,  9380,  4120 
  3561,   245,   387,  1388,  1008,  9607,  4945,  9535,  3392, 11881, 12030 
  3562,  1876,  1802,   377,  1875,  9272, 11959,  7356,  7257,  9679,  7428 
  3563,  1761,  1361,  1357,  1766, 11735,  4864, 10336,  6397, 11734, 10337 
  3564,    70,  1399,    77,    69,  4973, 10417,  3114,  2187,  4974,  3113 
  3565,  1866,   633,   691,   632,  7226,  6750, 10905,  7225,  2838,  6751 
  3566,  2110,  1901,  2178,  2041, 10830,  9719,  8588,  8708,  9718,  8709 
  3567,  1059,  1578,  1060,  1253, 10385, 10676,  3555,  4486, 10387,  4488 
  3568,  1665,  1195,  1137,  1182, 11694,  4118, 10474, 11585,  4120,  4060 
  3569,  1680,   970,   969,  1516, 11647,  3796, 11646,  5920,  9982, 11984 
  3570,  1816,   396,   253,  1774,  9138, 10372,  7117,  7068, 10814,  6931 
  3571,   374,  1551,  1001,  1150,  5373, 12031, 12029, 11961, 11427,  3837 
  3572,   393,   392,   250,  1807,  2545, 10335, 10334, 11346,  8937,  6927 
  3573,  1393,  1013,  1197,  1198, 11794,  4124, 11720, 10608,  4126,  4128 
  3574,  1551,  1470,  1107,  1150,  5692,  9434,  9093, 11427, 10278,  3982 
  3575,  1515,  1680,   969,  1516,  5919, 11646,  9892,  5552,  5920, 11984 
  3576,  1470,   904,  1107,  1150, 10277,  3876,  9434, 10278,  3983,  3982 
  3577,  1137,  1687,  1665,  1182, 11080,  5937, 10474,  4060,  9381, 11585 
  3578,  1269,  1719,   990,  1525, 11500, 11709,  4335, 12027,  6127,  9372 
  3579,  1001,  1150,  1551,  1107,  3837, 11427, 12031,  4379,  3982,  9093 
  3580,  1528,  1146,  1658,  1527,  9050, 11121,  5857,  5303, 11604,  5856 
  3581,  1658,  1146,  1268,  1527, 11121,  4332, 11631,  5856, 11604,  9641 
  3582,  1717,  1005,   378,  1004, 11191,  9405,  5381,  8793,  3377,  9354 
  3583,   433,  1578,  1059,  1414,  5454, 10385, 11071,  5005,  5600, 10386 
  3584,  1783,   695,  1870,  1825,  6850, 11060, 11835,  7059,  6989, 11061 
  3585,  1675,  1260,  1717,  1553,  8808,  8794,  6134,  6340,  8796,  6337 
  3586,   312,   438,   439,  1065,  9384,  2592, 11761,  3568,  9133, 11686 
  3587,   981,   207,   595,    28,  3314,  6464, 12032,  3313,  2351,  6466 
  3588,   906,   109,  1466,   907,  3160, 10315, 11519,  3695,  3163, 11812 
  3589,  1547,  1190,   993,  1270, 12033,  4096,  9413, 10853,  4340,  4339 
  3590,   897,  1434,  1435,    96, 10283,  5495, 10325,  3142, 11146, 11392 
  3591,  1371,  1608,  1207,  1609,  5671,  9594, 11540,  5673,  5675,  9592 
  3592,   997,  1193,  1548,  1380,  4105, 10551, 11005, 12034, 12035,  5638 
  3593,  1101,  1643,  1225,  1443, 12004, 12009,  4208, 10113,  5794, 10114 
  3594,   982,  1538,    28,   981, 11991, 12036,  3316,  3818, 12037,  3313 
  3595,   898,  1189,  1549,  1668,  4268,  9550,  9652,  9653,  9551,  5959 
  3596,   982,  1538,  1530,    28, 11991,  5565, 10142,  3316, 12036, 10922 
  3597,  1893,   361,   362,  1836,  7328,  2514,  7329,  9459, 10834, 10832 
  3598,  1320,  1351,  1724,  1755,  4799,  9229,  9213, 10194,  9231,  6319 
  3599,  1363,  1362,  1216,  1692,  4873,  9615,  9614,  5952,  5958, 10197 
  3600,  1212,  1604,  1603,  1721, 11785,  5660, 10284, 12012,  6136,  6135 
  3601,  1833,  1886,   710,  1791, 10437, 10571,  6866,  7099, 10513,  7079 
  3602,  1837,   218,   359,  1798,  7023,  9289, 11927,  7024,  6883, 11926 
  3603,  1243,  1193,   997,  1380,  4459,  4105,  4454, 10314, 12035, 12034 
  3604,  1661,  1560,  1262,  1391,  6193, 12014, 11253,  6176,  5404, 11626 
  3605,   359,   358,  1837,  1898,  2511,  9500, 11927,  7322,  7321,  9621 
  3606,  1613,  1270,  1377,  1692, 11361, 10196,  5688,  5960, 10198,  5957 
  3607,  1196,  1011,  1012,  1392,  4121,  3414,  4122, 11533, 10216,  9396 
  3608,  1772,   398,  1849,   399, 11389,  7397,  9516,  9520,  2551,  7398 
  3609,  1616,  1193,  1636,  1380, 10539, 10537,  6084,  5824, 12035,  6083 
  3610,   433,  1578,  1060,  1059,  5454, 10676,  9900, 11071, 10385,  3555 
  3611,   239,   930,   238,   381,  3381,  3380,  2386, 11189, 11190, 11649 
  3612,  2098,  1919,  2050,  2167,  8970,  8968,  8622,  8517,  9404,  8619 
  3613,  1907,  2114,  2175,  1906, 11912,  8601, 10653,  7862, 11294, 10654 
  3614,   139,   138,  1118,   523,  2270,  3727,  3729,  6511,  6509, 11344 
  3615,  1478,   527,   143,   526,  5176,  6518, 10602,  5175,  2690,  6519 
  3616,  1906,   413,   414,  2114,  7460,  2567,  7461, 11294,  9194,  9196 
  3617,   414,  2114,  1907,  1906,  9196, 11912,  7463,  7461, 11294,  7862 
  3618,  1968,  2077,   818,   819,  9038,  8244, 10843,  8923,  8243,  3031 
  3619,   443,  1070,   318,   317, 11298,  3584, 10731,  9156,  3583,  2467 
  3620,  2043,  2114,   287,   413,  8464,  8321,  8174, 11296,  9194, 11880 
  3621,   426,   300,  2120,   299,  9823,  8333, 10753, 12038,  2449,  8334 
  3622,  1470,   515,   516,   904,  5154,  2677,  5155, 10277, 10788, 12039 
  3623,  2120,   425,   426,   299, 11227,  2579, 10753,  8334, 11987, 12038 
  3624,  1991,  2156,   840,  2088,  9863,  8409,  9177,  9178,  8566,  8266 
  3625,  2120,  2049,   425,   299,  8470, 11161, 11227,  8334,  8186, 11987 
  3626,  1817,  1854,  1853,   395, 10638,  7191, 10637, 11811,  7390,  7391 
  3627,   426,   299,  1052,   300, 12038,  3529,  9822,  9823,  2449,  3530 
  3628,   426,   299,   425,  1052, 12038, 11987,  2579,  9822,  3529, 11316 
  3629,  2027,  2026,   873,  2173,  7824, 11108, 10554,  8850, 11114,  8444 
  3630,   294,   420,   293,  2117,  9125,  9126,  2443,  8327, 11652,  8328 
  3631,  2171,  2117,  2103,  1912,  8702,  8701,  8581, 11266, 11527, 11460 
  3632,  2046,   293,   419,  2117,  8180,  9656,  9344,  8467,  8328, 11655 
  3633,  1044,  1043,   417,  1406,  3508, 10729, 11696, 11612, 10730,  4989 
  3634,    62,   725,   664,   722,  2934,  7143,  2870,  6704, 11156,  6705 
  3635,   359,  1377,  1216,  1362,  4915, 10195, 10861,  5361,  5363,  9615 
  3636,   795,  2104,  2025,   872, 11757, 11284,  7817,  8124,  8298, 11282 
  3637,   364,  1793,  1889,  1890,  9800, 10225,  7334,  7333,  9572,  7299 
  3638,   947,   549,  1598,   163, 10525,  5542,  9450,  3245,  6552,  9452 
  3639,   884,   808,   807,  2038,  8027,  3019,  8073,  9425,  7856,  7855 
  3640,   311,   437,   436,  2055,  8958,  2590,  8957,  8198, 11311,  9008 
  3641,  2061,  1941,  2153,  2132,  8745, 10872,  8661,  8482, 11661,  8660 
  3642,  1207,  1609,  1024,  1371,  9592, 11774,  4153, 11540,  5673, 10174 
  3643,  2109,  2177,  2036,   882,  8587, 11970, 11699,  8308,  8451, 11929 
  3644,  1209,  1369,  1607,  1370, 11999,  5667, 11098, 11707,  4894,  5668 
  3645,  2074,  2143,  1958,  2140,  8493, 10948, 10949,  8693,  8691, 10119 
  3646,  1129,  1598,   550,   163,  9451,  5543, 10158,  3765,  9452,  6551 
  3647,  2035,   805,  2036,  2177,  7847,  7849,  7851,  9733, 11968, 11970 
  3648,  1623,  1696,  1294,  1666,  6314,  9443,  9442,  5991,  6005,  9759 
  3649,  1346,  1743,  1347,  1765, 11870, 10221,  4782, 11053,  6366, 11559 
  3650,  1333,  1729,  1203,  1204, 11213,  9725,  4746,  4747, 11417,  4146 
  3651,   309,   435,   436,  1062, 11124,  2589, 11318,  3559, 11728, 11371 
  3652,  1225,  1160,  1752,  1643,  4209, 11553, 11731, 12009, 12005,  6291 
  3653,   309,  1062,   436,   310,  3559, 11371, 11318,  2459,  3560,  9007 
  3654,   893,  1643,  1242,  1160,  9303,  9302,  4262,  3971, 12005,  4264 
  3655,   836,  2154,  1987,  1986,  8405,  9691, 11803, 11802,  9692,  7704 
  3656,   744,   824,  2080,  1974,  8039,  8250, 10864,  7664,  9323, 10011 
  3657,  1119,   137,   136,  1476,  3730,  2268,  3731,  8882, 11034,  8944 
  3658,   381,   380,   524,   930,  2533,  4939,  4938, 11190, 11183, 11651 
  3659,  1063,   310,   436,  1062,  3562,  9007,  8959,  3564,  3560, 11371 
  3660,   947,  1500,   162,  1128, 10619, 10620,  3246,  3939, 11197,  3762 
  3661,   447,  1074,   448,   321, 11603, 10880,  2601, 11754,  3595, 10881 
  3662,   447,  1073,  1074,   321, 11605,  3597, 11603, 11754,  3593,  3595 
  3663,   132,   923,    14,   493,  3195,  3194,  2262,  6622,  9182,  6624 
  3664,  1765,  1743,  1745,  1346,  6366,  6272,  6367, 11053, 11870, 11624 
  3665,   571,   185,  1559,   570,  6433, 10996,  5279,  2742,  6434,  5278 
  3666,  1409,   586,   976,   585,  5567, 10686, 11941,  6243,  2761, 11873 
  3667,   448,   322,  2131,   321, 10867,  8356, 11806, 10881,  2471,  8357 
  3668,   985,  1267,  1532,   984,  4328, 10679, 10678,  3821,  4329, 11085 
  3669,   906,  1650,  1244,  1648, 11518, 11891,  4271, 12040,  5992, 11072 
  3670,   771,   850,  2002,  2001,  8140, 10116,  7747,  7745, 10003,  7749 
  3671,   298,   423,   424,  1050, 10024,  2577,  9085,  3524, 10025, 11199 
  3672,  1526,  1527,   986,   578,  5300,  9639, 10173,  5297,  5298, 12024 
  3673,  1005,  1554,  1119,  1161,  9606,  8883,  4386,  4112, 12041,  4010 
  3674,  1907,  2106,  2175,  2044, 11724,  8525, 10653, 11725,  8713,  8600 
  3675,  2131,   447,   448,   321, 11753,  2601, 11806,  8357, 11754, 10881 
  3676,  1427,  1083,  1588,  1232,  8836, 11705,  5650,  9043,  4234, 11706 
  3677,  1427,  1083,   459,   458,  8836, 11472,  5031,  5032, 11710,  2612 
  3678,  2078,  1952,  2137,  2066, 11666,  8894,  8680,  8681, 10822,  8487 
  3679,  1698,  1221,  1222,  1406,  9264,  4200, 10363,  5882, 10733, 11611 
  3680,  2017,   786,   787,   864,  7792,  2998,  7793, 11925,  8137,  8120 
  3681,  1042,  1571,   415,   416, 11435,  5432, 11381, 11656,  5431,  2569 
  3682,   804,  2034,   803,   880,  7844,  7843,  3015,  8066,  9904,  8067 
  3683,   458,   332,  1082,  1083, 10480,  3621, 10478, 11710,  3623,  3625 
  3684,   524,   380,  1385,   930,  4939,  4936,  5698, 11651, 11183, 11182 
  3685,  1420,  1582,  1654,  1228,  5648,  6021,  6020, 11415,  8842,  8841 
  3686,  2028,  2174,   875,  2029, 11719,  8446, 10236,  7830, 11950, 11801 
  3687,  1420,  1070,   444,  1582, 12042, 11632,  5018,  5648,  9779,  5465 
  3688,  1022,  1021,  1612,  1204,  3443, 11636, 12043,  4145,  4144, 11416 
  3689,   891,  1202,  1438,  1098,  4139,  9274,  9353,  3850,  4140, 12044 
  3690,  1876,   376,   377,  1802,  7355,  2529,  7356,  9272, 10516, 11959 
  3691,   982,    28,  1530,   208,  3316, 10922, 10142,  3315,  2352, 10143 
  3692,  1684,  1699,  1185,  1413,  6162,  8912, 11668,  6112,  6163, 11292 
  3693,   972,   973,  1541,  1689,  3803, 10986,  9061,  9122, 11861,  5942 
  3694,  1423,  1586,   451,  1078,  5501,  5475,  5023, 11473,  8984, 11524 
  3695,  1423,  1586,  1078,  1114,  5501,  8984, 11473,  9005, 11934,  4005 
  3696,  1364,  1215,  1602,  1692, 10706, 12045,  5653,  5953, 12007,  5978 
  3697,  1024,  1609,  1372,  1371, 11774,  5674, 11428, 10174,  5673,  4900 
  3698,  1215,  1270,  1602,  1692,  4749, 12046, 12045, 12007, 10198,  5978 
  3699,  1026,  1370,   271,   350, 11877, 11363,  3453, 11038,  4892,  4863 
  3700,  1936,  1991,  1992,  2088,  8001,  7719,  7932,  9146,  9178,  9145 
  3701,  1113,  1451,   485,  1593, 10802,  5094, 12047,  8903,  5617,  5500 
  3702,   444,  2129,  1936,   443, 11782, 10121,  7549,  2597,  9155,  7548 
  3703,  1317,  1726,  1207,  1318, 11046,  9593,  4618,  4622,  9595,  4620 
  3704,  1214,  1215,  1602,  1032,  4179, 12045, 11327,  4175,  4177, 11010 
  3705,  1372,  1206,  1610,  1609, 11429, 11594,  5676,  5674, 11775,  5678 
  3706,  1374,   354,  1022,  1373,  4904,  9474,  9473,  4906,  4902, 10742 
  3707,  1207,  1206,  1024,  1609,  4155,  4151,  4153,  9592, 11775, 11774 
  3708,  1727,  1609,  1610,  1206,  6152,  5678,  6153, 11773, 11775, 11594 
  3709,   485,  1593,   484,   123,  5500,  5499,  2642,  6629,  8902,  6627 
  3710,  1113,  1593,   485,   123,  8903,  5500, 12047,  3715,  8902,  6629 
  3711,  2050,  1919,  1920,   427,  8968,  7502,  8969,  9204,  7498,  7500 
  3712,  1834,   365,   224,   223, 10246, 10258,  7027,  7011, 11910,  2371 
  3713,   931,   240,   932,   382,  3383,  3384,  3738,  9220,  9670,  9813 
  3714,   364,   365,  1834,   223,  2517, 10246, 11018,  9802, 11910,  7011 
  3715,  2014,   861,   862,  2167, 11766,  3074,  9739,  9318,  8432,  8431 
  3716,  1113,   123,   485,   124,  3715,  6629, 12047,  3714,  2253,  6631 
  3717,  1243,  1380,  1694,  1715, 10314,  6166, 10239, 10241,  6190,  6115 
  3718,  1777,   684,  1859,  1820,  6838,  9121,  9657,  7039,  6977,  9659 
  3719,  1914,  2170,  2102,  2118, 11198,  8580, 10589, 10692,  8729,  8610 
  3720,  1548,   365,   364,   997,  5365,  2517,  5366, 11005, 11638, 11006 
  3721,   392,   391,  1819,  1858,  2544, 12048, 11470,  7384,  7383, 10081 
  3722,   407,   263,    32,   604,  8777,  2411,  8778,  9280,  6947,  2808 
  3723,  1113,   124,   485,  1451,  3714,  6631, 12047, 10802, 11554,  5094 
  3724,   923,  1117,  1167,  1454,  3995,  4356,  4009,  8738,  9181,  8737 
  3725,   235,  1003,   377,  1004,  3371, 11960,  9574,  3372,  3374,  9355 
  3726,   926,  1644,  1249,  1707, 10023, 10021,  4283, 11176,  6053, 11805 
  3727,  1080,   922,   454,   328,  3856, 11180, 11384,  3614,  3616, 12049 
  3728,  1002,   376,   234,  1003,  8847, 10515,  3368,  3839, 10303,  3370 
  3729,  1605,  1604,  1211,  1722,  5663, 12050, 11786,  6138,  6137, 11319 
  3730,  1211,  1029,  1605,  1028,  4166, 11772, 11786,  4165,  3464, 10726 
  3731,  1602,  1215,  1364,  1032, 12045, 10706,  5653, 11010,  4177,  9967 
  3732,   349,   273,  1368,   348,  4465,  9163,  4887,  2500,  3947,  4886 
  3733,   967,   560,  1514,   189, 11983,  5265,  9232,  3285,  6406, 10523 
  3734,  1603,  1721,  1739,  1213,  6135,  6222,  6221, 10285, 11714, 11713 
  3735,  1863,  1806,  1779,  1822, 10500,  7083,  9376,  8767,  7086,  7056 
  3736,   374,  1551,  1383,  1001,  5373,  5372,  4933, 12029, 12031, 11230 
  3737,  1878,   374,  1829,  1879,  7352,  9097,  9841,  7266,  7351, 10890 
  3738,  1012,   255,   399,   398,  3412, 10219,  9397,  9222,  9223,  2551 
  3739,   906,    10,  1466,   109,  3161, 10146, 11519,  3160,  2235, 10315 
  3740,  1643,  1708,  1225,  1443,  6061, 11677, 12009,  5794,  6058, 10114 
  3741,  1276,   910,  1461,  1647,  4373, 11671, 11091, 10294, 11780,  5806 
  3742,   375,   374,  1801,  1878,  2527, 10856, 10291,  7353,  7352, 10598 
  3743,   443,   444,   318,  1070,  2597, 11781, 10731, 11298, 11632,  3584 
  3744,   914,  1691,  1277,  1247,  9184,  8886,  4382,  4280, 11680,  4510 
  3745,   952,  1677,  1293,  1131,  8775,  8833,  4499,  4304, 12051,  4493 
  3746,  1464,   117,   503,  1111, 11171,  6659,  5133,  8809,  3706,  8780 
  3747,  2174,  2044,  1907,  1908,  8603, 11725, 11723, 11356, 10711,  7467 
  3748,   244,   387,   386,  1806, 11882,  2539, 10494,  6921,  9337, 10493 
  3749,  1225,  1708,  1444,  1443, 11677,  6059, 11974, 10114,  6058,  5075 
  3750,  1783,  1870,   694,  1869, 11835, 10435,  6851,  9676,  7239,  9602 
  3751,  1862,  1806,   388,  1821,  9336,  9335,  7376, 11529,  7084, 11980 
  3752,  1008,   387,   386,   244, 11881,  2539,  9358,  3391, 11882, 10494 
  3753,  1863,   387,  1862,  1806,  7374,  7375,  7218, 10500,  9337,  9336 
  3754,   386,   387,  1008,  1557,  2539, 11881,  9358,  5391,  5390,  9360 
  3755,  1803,  1825,   238,   380,  7088,  7109,  6909, 12052, 12053, 11650 
  3756,  1483,  1482,   530,   956,  5526,  5187,  5188, 10369,  9690, 10111 
  3757,  1253,  1171,  1656,   940,  4424, 10646, 10644,  4294,  4019, 10053 
  3758,  1651,  1675,   958,  1484,  6110, 11441,  9244,  5820,  5906, 12025 
  3759,    18,  1512,   939,  1503, 11261, 11831,  3230, 11690,  5545, 11505 
  3760,   943,    50,    19,  1506,  8962,  2793,  3238, 10519,  5245,  9721 
  3761,   526,  1555,   931,  1478,  5525,  9219,  9477,  5175,  5619,  9815 
  3762,   444,  1936,  2059,  1937,  7549, 12001, 11944,  7551,  7553,  9992 
  3763,  1486,   952,    21,  1131,  8773,  3255, 10324,  8929,  4304,  4043 
  3764,  1215,  1216,  1363,  1033,  4182,  9614, 12006,  4178,  4180, 11004 
  3765,  1363,  1215,  1364,  1692, 12006, 10706,  4876,  5952, 12007,  5953 
  3766,  1936,  2156,  1991,  2088, 10120,  9863,  8001,  9146,  8566,  9178 
  3767,   168,   541,   540,   951,  6545,  2707,  6544,  3253, 10667, 10962 
  3768,  1541,   974,   598,  1542, 10985, 10974,  5342,  5578, 10976,  5343 
  3769,  1712,  1147,  1522,  1183, 11499,  9013,  6092,  9674,  4065,  9673 
  3770,  1541,  1542,  1265,   974,  5578, 11815, 11355, 10985, 10976,  4323 
  3771,  1409,   585,  1139,  1534,  6243, 12016, 11352,  6015,  5321, 10562 
  3772,  1574,  1542,  1265,  1408,  5739, 11815, 12054,  5598,  5740, 11354 
  3773,  1574,  1542,  1335,  1265,  5739, 11221, 10559, 12054, 11815,  4696 
  3774,  1335,  1542,   975,   974, 11221, 10566,  4697,  4695, 10976,  3805 
  3775,  1033,  1215,  1364,  1363,  4178, 10706, 10705, 11004, 12006,  4876 
  3776,  1815,  1850,   398,  1773, 10592,  7396,  9314,  7067, 10604,  9315 
  3777,   729,  1960,  2141,  2073,  7622, 11629, 11580,  8918,  8917,  8724 
  3778,   408,  2041,   282,   409,  9722,  8171,  8988,  2562, 12056, 12055 
  3779,   282,  2041,   283,   409,  8171,  8170,  2432, 12055, 12056, 12057 
  3780,  1294,  1568,  1097,  1666, 10054,  9118,  4502,  9759,  5879, 12058 
  3781,  1382,   372,  1000,   373,  4931,  9079, 10299,  4930,  2525, 11028 
  3782,  1577,  1226,  1288,  1663, 12059,  4506,  9763,  5869, 10381,  9879 
  3783,  2123,  1924,  2053,   432,  8979,  8978,  8536, 10048,  7513,  9567 
  3784,  1921,  2051,  2166,  2121,  9436,  8711,  9883,  9448,  8335,  8699 
  3785,   983,   982,  1288,  1682,  3819,  4524,  4444, 11450, 11566,  9878 
  3786,  1035,   282,   283,   409,  3481,  2432,  3482,  8976, 12055, 12057 
  3787,   359,   218,  1837,   358,  9289,  7023, 11927,  2511, 11179,  9500 
  3788,   408,   282,  1035,   409,  8988,  3481, 12060,  2562, 12055,  8976 
  3789,   363,   362,  1794,  1892,  2515,  9699,  9700,  7331,  7330,  9571 
  3790,  1672,  1615,  1387,  1312,  6217,  5700,  6197, 12061,  9346,  9818 
  3791,  1265,  1047,  1408,  1264,  4483, 10794, 11354,  4522,  4482, 11975 
  3792,  1723,  1605,  1211,  1722,  6140, 11786,  9228,  6142,  6138, 11319 
  3793,   710,  1886,  1832,  1791, 10571, 10512,  7005,  7079, 10513,  7080 
  3794,  1005,   379,   378,   237,  9605,  2531,  9405,  3376,  8899,  8897 
  3795,    73,     3,   407,  1092,  2192,  8776, 10345,  3652,  3651,  8790 
  3796,   902,   370,   371,   512,  9597,  2523, 11359, 11621,  4929,  4928 
  3797,  1419,   443,  1069,  1653,  5015,  9983, 11644,  6131,  5604, 11299 
  3798,  1334,  1226,  1705,  1267,  4750, 10380, 11568,  4760,  4568, 11461 
  3799,  1643,  1442,  1101,   893,  5793, 11314, 12004,  9303, 11558,  3870 
  3800,  1557,  1685,  1312,  1615,  5974, 11820,  9819,  5699,  5975,  9346 
  3801,  1180,  1017,  1154,  1395,  4052,  3952,  4053,  9785,  9401, 10499 
  3802,   420,  1912,   419,  2117,  7478,  7477,  2573, 11652, 11527, 11655 
  3803,  1812,  1769,  1843,   668,  7048, 10465, 11542,  6957,  6822, 10761 
  3804,  1387,  1557,  1312,  1615,  5586,  9819,  9818,  5700,  5699,  9346 
  3805,   352,   270,  1371,   351,  5569, 10175,  4896,  2503,  5147,  4895 
  3806,  1211,  1320,  1210,  1723,  4630,  4629,  4167,  9228,  9211, 11601 
  3807,  2123,  1924,   432,   431,  8979,  7513, 10048, 11923,  7512,  2585 
  3808,  1104,   511,   902,   102, 11712, 11320,  3924,  3686,  6693,  3153 
  3809,   509,   369,   508,  1103,  5690,  4924,  2670,  9946,  9947, 11367 
  3810,   756,  1987,   836,   757,  7702, 11803,  8093,  2968,  7703,  8094 
  3811,  1745,  1755,  1756,  1351,  6395,  6323,  6385, 11625,  9231,  9230 
  3812,  2052,  1923,  2009,  2096,  9756,  7907,  9755,  8714, 11921, 10960 
  3813,  1923,  2096,  2164,  2008, 11921,  8574, 10400,  7908, 11280, 11279 
  3814,  1346,  1756,  1745,  1765, 11052,  6385, 11624, 11053,  6384,  6367 
  3815,  2113,  2108,  1904,  2177,  8694,  9845,  9843,  8596,  8527,  9732 
  3816,  1170,  1069,  1419,  1283,  4409, 11644,  9728,  4439,  4656, 10875 
  3817,  1332,  1237,  1238,  1634,  4679,  4252,  4680,  8860, 11747, 10131 
  3818,  1419,  1069,  1170,  1653, 11644,  4409,  9728,  6131, 11299,  9513 
  3819,   369,   509,   510,   901,  5690,  2671,  4927,  9945,  9944, 11887 
  3820,   125,  1451,   124,   919,  9010, 11554,  2254,  3186, 10545,  3187 
  3821,   920,   126,   487,   127,  3189,  6641,  9847,  3188,  2256,  6640 
  3822,  1628,  1620,  1343,  1622,  6202,  9453, 10526,  5737,  6338,  9454 
  3823,  1702,  1237,  1332,  1634, 11722,  4679,  9382,  6046, 11747,  8860 
  3824,   623,   681,   682,  1776,  6734,  2889,  6737, 11158,  6837,  6836 
  3825,  1942,   449,   450,  2132,  7566,  2603,  7567, 10877,  8867, 10998 
  3826,  1818,   681,   623,  1776,  6970,  6734, 10883,  7074,  6837, 11158 
  3827,  2134,  1946,   454,   453, 11175,  7579, 12062, 11853,  7578,  2607 
  3828,  1169,  1268,  1720,  1659,  4397,  9640, 11845, 11194, 11193,  6316 
  3829,   425,  1536,  1052,  1600,  5444, 10344, 11316,  5744,  5622, 10342 
  3830,   936,  1507,  1474,  1252, 11639,  5521, 10549,  4290, 10630, 10628 
  3831,  1068,   442,   316,  1069,  9943,  8820,  3578,  3582,  9984,  3580 
  3832,  1126,   944,  1416,  1498,  3892, 10534,  9014,  9016, 11535,  6089 
  3833,  1068,  1067,   441,  1581,  3579, 11303, 10791,  9941, 11463,  5464 
  3834,   455,  1587,  1155,   922,  5482, 11329,  9552,  9041, 11503,  4226 
  3835,  1581,  1419,  1068,  1283,  5462,  9942,  9941, 11606, 10875,  4570 
  3836,  1486,  1495,    48,   952,  5535,  5218,  5194,  8773,  8774, 10273 
  3837,   165,  1502,   551,   948, 10153,  5235,  6556,  3247, 10154,  8877 
  3838,   925,   926,  1447,  1644,  3726, 11095,  9028, 10022, 10023,  5797 
  3839,  1632,  1330,  1235,  1329,  9837,  4673, 11930,  9838,  4675,  4671 
  3840,  1570,  1219,  1403,  1622, 10778,  9462,  5626,  5716, 11890,  5717 
  3841,  1508,  1297,  1507,   937,  8764, 10766,  5250,  8765,  4520, 10674 
  3842,  1951,   458,   459,  2066,  7593,  2612,  7594,  8749, 11664,  9965 
  3843,  1583,  1248,  1421,  1072, 12063,  9301,  5631,  9367,  4659, 11673 
  3844,  2144,  1964,  2075,  1956, 10213, 10134,  8494, 10212,  7970, 11430 
  3845,  1948,  2149,  2080,  1975,  9789,  8499, 10927,  7954, 10859, 10010 
  3846,  1123,  1512,  1511,  1693, 11100,  5262, 10688, 10684,  5968,  5998 
  3847,  1018,   405,  1154,   262,  8785,  8783,  3963,  3430,  8798,  3849 
  3848,    70,  1096,    78,    77, 10504,  3662,  3115,  3114,  3661,  2197 
  3849,  1405,  1041,   414,  1040, 10155, 11545,  4988, 10156,  3854, 11657 
  3850,   405,  1842,   404,  1809,  7409,  7408,  2557,  8800, 11274, 11273 
  3851,  2094,   852,   774,   853,  8278,  8116,  9663,  8277,  3065,  8053 
  3852,  2065,  1950,  2079,  2136,  9960,  9962,  8677,  8486, 10037,  8676 
  3853,  1192,  1637,  1379,  1616,  8947,  5777, 10542, 10543,  5979,  5702 
  3854,  1398,  1567,    68,  1157,  5594,  5420,  4971, 10232,  9853,  9867 
  3855,  2144,  2139,  2068,  1956,  8688,  8489,  8689, 10212, 11402, 10472 
  3856,   950,   167,   540,   951,  3251,  6542, 10961,  3770,  3254, 10962 
  3857,  1955,  2068,   463,  1956,  9953,  9954,  7606,  7610, 10472,  7608 
  3858,   100,   101,   510,   901,  2226,  6687,  6684,  3151,  3150, 11887 
  3859,  2068,  2139,   463,  1956,  8489, 10819,  9954, 10472, 11402,  7608 
  3860,  1812,   668,  1843,   610,  6957, 10761, 11542, 11107,  6710,  7157 
  3861,   488,   127,   920,   487,  6638,  3188,  9846,  2645,  6640,  9847 
  3862,   510,   369,  1104,   370,  4927, 11888, 11886,  4926,  2522, 11711 
  3863,   376,   375,  1828,  1876,  2528, 10293, 12064,  7355,  7354,  9273 
  3864,  1376,  1271,  1431,  1635,  9256,  8861,  5950,  5956,  8828,  5772 
  3865,   451,   324,  1077,   325, 10568,  3604, 11602, 10567,  2474,  3605 
  3866,   369,   368,   999,   227,  2521, 11893, 10577, 10578,  9387,  3357 
  3867,  1973,  1949,  2065,  2148,  7956, 10058,  9959,  9578,  9579,  8728 
  3868,   130,   922,  1425,  1116,  3193,  9914, 10488,  3720,  3996,  9915 
  3869,   376,  1876,  1828,  1802,  7355,  9273, 12064, 10516,  9272,  7107 
  3870,  2160,   768,   848,   847, 10110,  8111,  8417,  8418,  8110,  3060 
  3871,   561,   190,  1515,  1514,  6408, 11153,  5267,  5266, 11759,  5551 
  3872,  1583,  1248,  1646,  1421, 12063, 10476,  6023,  5631,  9301,  5914 
  3873,   542,  1125,   155,   156, 11464,  3757,  6547,  6550,  3756,  2291 
  3874,    52,   189,   560,   967,  6407,  6406,  2730,  9740,  3285, 11983 
  3875,   561,   190,  1514,   560,  6408, 11759,  5266,  2731,  6409,  5265 
  3876,  1661,  1514,   968,  1678,  5854, 10524,  9895,  6096,  5913, 10991 
  3877,  1192,  1546,  1379,  1637,  8948,  5364, 10542,  8947,  5778,  5777 
  3878,  1375,   355,   356,   266,  4907,  2507,  4908, 11642,  6290,  6289 
  3879,   970,  1681,  1543,  1516,  9293,  5922,  9981,  9982,  5921,  5553 
  3880,  1772,   398,   399,   255, 11389,  2551,  9520,  6937,  9223, 10219 
  3881,   124,   486,   485,  1451,  6630,  2643,  6631, 11554,  5095,  5094 
  3882,  1046,  1224,  1045,  1573,  4205,  4204,  3514,  8940, 11586, 11434 
  3883,  1665,  1690,  1544,  1195,  5946,  5945,  5873, 11694, 11981, 11693 
  3884,    95,  1433,   469,   468, 11390,  5044,  6588,  6589,  5043,  2623 
  3885,  1379,   996,  1192,  1193,  9408,  4102, 10542, 10544,  4104,  4106 
  3886,  1049,  1050,  1535,   423,  3525, 10699, 10698, 11365, 10025,  5441 
  3887,  1268,  1146,  1658,  1187,  4332, 11121, 11631,  4334,  4090,  9152 
  3888,  1247,  1248,  1583,  1072,  4496, 12063, 11859,  4402,  4659,  9367 
  3889,  1247,  1248,  1646,  1583,  4496, 10476, 10483, 11859, 12063,  6023 
  3890,   579,  1527,   212,  1146,  5299, 12065,  6449,  9051, 11604,  3825 
  3891,  1720,   986,  1526,  1527,  9638, 10173,  6129,  6130,  9639,  5300 
  3892,  1713,  1187,  1146,   987, 11196,  4090, 10319, 10122,  4089,  3960 
  3893,  1163,   895,  1706,  1290,  3976, 12066, 11177,  4452,  4451, 11001 
  3894,  1020,  1271,  1376,  1635,  4347,  9256, 11110,  9470,  8828,  5956 
  3895,  1225,  1643,  1752,  1708, 12009,  6291, 11731, 11677,  6061,  6292 
  3896,  1493,   539,   540,   950,  5213,  2706,  5214, 10907, 12015, 10961 
  3897,  1431,  1019,  1156,  1271,  9255,  3969, 10179,  8861,  4346,  4349 
  3898,  1734,  1259,  1651,  1384,  8950,  9245,  6187,  6188, 10296,  6169 
  3899,  1717,  1554,  1005,  1161,  5382,  9606, 11191, 11752, 12041,  4112 
  3900,  1022,  1611,  1374,  1373, 11998,  5680,  9473, 10742,  5679,  4906 
  3901,   928,  1475,  1717,  1161,  8803,  6121,  8801,  3972, 12067, 11752 
  3902,   642,  1875,  1786,  1876,  7253,  9678, 10563,  7255,  7257,  9271 
  3903,  1119,  1161,  1475,   928,  4010, 12067,  8885,  3733,  3972,  8803 
  3904,  1848,   614,   615,  1814,  7171,  2820,  7172, 11015, 10455, 10454 
  3905,   622,   680,  1855,   621,  6732, 10719,  7193,  2827,  6733,  7192 
  3906,  1319,  1725,  1350,  1318, 11818, 11871,  4793,  4625, 11872,  4792 
  3907,  1962,  2074,  1958,  2040, 10029, 10949,  7980,  7987, 11022,  8009 
  3908,   813,  2074,  1962,   731,  8237, 10029, 11659,  8033, 10031,  7627 
  3909,  1855,   680,   679,   621, 10719,  2887, 10718,  7192,  6733,  6730 
  3910,   704,  1880,   705,   647, 10597, 10491,  2912,  6770,  7268,  6773 
  3911,  1245,  1670,   908,  1468, 12068, 12069,  4272,  9052,  5895,  9060 
  3912,  1013,   399,  1012,   256, 11515,  9397,  3417,  3415,  9519,  3413 
  3913,   615,  1772,  1848,  1814, 11876, 11875,  7172, 10454,  7047, 11015 
  3914,   993,   219,   360,   992,  3339, 10748,  9412,  3341,  3338,  9290 
  3915,  1772,   399,  1848,  1814,  9520,  7399, 11875,  7047,  9521, 11015 
  3916,  1816,   618,   619,   677, 10541,  2824,  9238,  6964,  6727,  6726 
  3917,  1772,   399,  1849,  1848,  9520,  7398,  9516, 11875,  7399,  7176 
  3918,   909,    42,    11,   908, 10932,  2801,  3167,  3697,  9059,  3164 
  3919,  1327,  1763,  1738,  1762, 12070,  6350, 11484, 11956,  6352,  6349 
  3920,  1728,  1205,  1610,  1611, 11633, 11595,  6155,  6156, 11997,  5681 
  3921,   268,  1022,   267,   354,  3442,  3441,  2416,  6383,  9474,  6328 
  3922,  1374,  1612,  1022,  1021,  5682, 12043,  9473, 11654, 11636,  3443 
  3923,   333,  2137,   334,   460,  8369,  8368,  2483, 11933, 10836, 10891 
  3924,   333,  1084,   459,   460,  3626, 11174,  9963, 11933,  9817,  2613 
  3925,   623,  1857,  1856,  1776,  7198,  7200,  7196, 11158, 11008, 11007 
  3926,   265,   266,  1020,   356,  2414,  3436,  3435,  7440,  6289, 11111 
  3927,  1020,  1375,   356,   266, 11112,  4908, 11111,  3436, 11642,  6289 
  3928,    99,  1103,   509,   508,  3685,  9946,  6683,  6680, 11367,  2670 
  3929,  1235,  1330,  1632,  1631,  4673,  9837, 11930, 11012, 11011,  5767 
  3930,  1960,   730,   811,   729,  7623,  8013,  8916,  7622,  2941,  8012 
  3931,   368,  1103,   508,   369, 11990, 11367,  4925,  2521,  9947,  4924 
  3932,  1029,  1604,  1367,  1366, 11784,  5659, 10227, 10229,  5658,  4885 
  3933,  1162,  1102,   899,  1469,  3974,  3871,  3975,  8823, 11988, 10536 
  3934,  1282,  1259,  1003,  1384,  4406,  4470,  4703, 11617, 10296, 10304 
  3935,  1734,  1384,  1649,  1292,  6188,  5966,  6254,  9313,  9999,  9997 
  3936,  1464,   117,  1111,   912, 11171,  3706,  8809,  9835,  3172,  3880 
  3937,   388,  1806,   245,  1821,  9335,  6920,  9536, 11980,  7084,  7101 
  3938,  1856,  1818,   623,  1776, 10882, 10883,  7196, 11007,  7074, 11158 
  3939,  1639,  1336,  1231,  1737, 10035,  4698,  9467,  6208, 10105,  9468 
  3940,  1459,  1468,   909,  1670,  5513, 11816, 11743,  5896,  5895, 11810 
  3941,   146,   934,    44,    16,  3219, 11024,  6496,  2278,  3220,  2787 
  3942,  1272,  1624,  1405,  1571, 10763,  5721,  9975, 11436,  5720,  5595 
  3943,   891,  1098,  1438,    87,  3850, 12044,  9353,  3131,  3669, 10665 
  3944,  1426,  1081,  1167,  1278,  9803,  4117,  8739, 11238,  4472,  4471 
  3945,   957,  1483,   175,   174,  9924,  9934,  3265,  3266,  8956,  2313 
  3946,  1437,   472,  1438,  1098,  5052,  5054,  5056, 11304, 12071, 12044 
  3947,  1674,  1482,  1483,   956,  5904,  5526,  5905, 10959,  9690, 10369 
  3948,  2043,  1905,   413,   412, 11217,  7458, 11296, 11679,  7457,  2566 
  3949,   957,  1483,   958,   175,  9924,  9922,  3780,  3265,  9934,  3268 
  3950,   202,  1142,   590,   978,  3813, 11373,  6480,  3307,  3909, 11225 
  3951,  1649,  1670,  1245,  1468,  6074, 12068, 10468,  5810,  5895,  9052 
  3952,   175,  1483,   531,   174,  9934,  5189,  6525,  2313,  8956,  6522 
  3953,  1638,  1733,  1305,  1336,  6183, 10098,  9554, 11860, 10104,  4700 
  3954,  1733,  1355,  1305,  1336, 10099,  4820, 10098, 10104,  4823,  4700 
  3955,  2054,   435,  1928,  2125, 11123,  7524, 10953,  8475, 11325, 10015 
  3956,   386,  1780,  1822,  1864, 10442,  7069,  8766,  7372, 10443,  8768 
  3957,   906,   907,  1466,  1648,  3695, 11812, 11519, 12040, 11908,  5807 
  3958,  1181,  1681,  1690,  1138,  9294,  5947, 12023,  4056,  9295, 11336 
  3959,  1563,  1014,  1199,  1015, 11395,  4129, 12072, 11168,  3423,  4130 
  3960,  1064,   311,   437,  1063,  3565,  8958, 11697,  3567,  3563,  8960 
  3961,   168,   951,   540,   167,  3253, 10962,  6544,  2304,  3254,  6542 
  3962,  1561,  1010,  1338,  1298,  9585,  4532,  9581, 10043,  4528,  4774 
  3963,  1075,   322,   448,  1074,  3598, 10867, 10866,  3600,  3596, 10880 
  3964,  1467,   907,  1466,   504,  9055, 11812,  5511,  5141, 11813,  5140 
  3965,   949,    20,  1502,    49,  3250, 10972,  9735, 12073,  2792,  5236 
  3966,   949,    49,  1502,  1492, 12073,  5236,  9735,  9736,  5211,  5544 
  3967,  1246,  1670,   908,  1245, 11809, 12069,  4275,  4389, 12068,  4272 
  3968,   183,   963,   569,   182,  3277,  9782,  6437,  2322,  3278,  6429 
  3969,   969,   190,  1515,   191,  3290, 11153,  9892,  3289,  2331, 11152 
  3970,   574,  1390,   966,  1521,  5851, 11571, 11561,  5286,  6271,  9958 
  3971,  1408,  1047,  1573,  1264, 10794,  8942,  5627, 11975,  4482, 11587 
  3972,  1790,   369,   227,  1832, 11309, 10578,  6897,  7029, 11892,  7105 
  3973,  1610,  1611,  1205,  1373,  5681, 11997, 11595,  5677,  5679, 11127 
  3974,   344,   343,   279,  1363,  2495,  4708,  4867,  4872,  4871, 11003 
  3975,   296,  2118,   421,   295,  8329, 11019, 11254,  2445,  8330,  9394 
  3976,  1335,  1139,  1574,  1048,  4428, 10560, 10559,  4429,  4195, 11945 
  3977,  1279,  1741,  1334,  1171, 11762, 11569,  4690,  4404, 10165,  4689 
  3978,  1550,   512,   902,   371,  5515, 11621, 11358,  5371,  4928, 11359 
  3979,  1689,   973,  1265,  1264, 11861,  4324, 11353,  9123,  4321,  4522 
  3980,   553,   940,  1504,   552,  8967, 10051,  5241,  2721, 11700,  5240 
  3981,  1245,  1649,  1734,  1670, 10468,  6254, 12074, 12068,  6074,  6258 
  3982,  1681,  1313,  1338,  1181, 10707,  4719, 10215,  9294,  4603,  4717 
  3983,  1602,  1270,  1613,  1692, 12046, 11361,  6171,  5978, 10198,  5960 
  3984,  1191,  1190,   994,  1378,  4100,  4097,  4098, 10205, 10206, 10747 
  3985,  1270,  1215,  1602,  1214,  4749, 12045, 12046,  4748,  4179, 11327 
  3986,  1379,   363,   996,   364,  4919,  9798,  9408,  4918,  2516,  9406 
  3987,   363,   362,  1546,   995,  2515,  5355,  5357,  9797, 11144, 10787 
  3988,  1706,   895,  1636,  1290, 12066, 11863,  6051, 11001,  4451, 11002 
  3989,  1313,  1746,  1690,  1681, 12076,  6275, 12075, 10707,  6315,  5947 
  3990,  1100,  1642,  1442,  1441,  9464,  5791, 11557,  9463,  5790,  5068 
  3991,  1390,   574,   966,  1136,  5851, 11561, 11571,  9270, 11560,  3945 
  3992,  1834,   713,  1889,   714,  7010, 11534, 11016,  7009,  2921,  9568 
  3993,   958,  1260,  1675,  1282,  4310,  8808, 11441,  4405,  4407, 11850 
  3994,   958,  1675,  1651,  1282, 11441,  6110,  9244,  4405, 11850,  9246 
  3995,   573,   574,  1390,  1136,  2745,  5851,  5557, 10436, 11560,  9270 
  3996,   223,   222,   364,   996,  2370,  9801,  9802,  3349,  3348,  9406 
  3997,  1258,  1716,  1735,  1674, 10914,  6196, 11740,  8951,  6118,  6194 
  3998,  1878,  1829,  1801,  1787,  9841,  7136, 10598,  9840,  7063,  7137 
  3999,  1746,  1313,  1618,  1681, 12076, 10708,  6308,  6315, 10707,  6311 
  4000,   997,   223,   364,   996,  3351,  9802, 11006,  3353,  3349,  9406 
  4001,  1002,  1326,  1552,  1292,  4702, 10470,  8846,  4460,  4692,  9998 
  4002,  1515,  1661,   969,  1680,  5855,  9894,  9892,  5919,  6185, 11646 
  4003,  1521,  1285,  1177,   966, 11565,  4437, 11572,  9958,  4423,  4044 
  4004,   560,  1513,    52,   967,  5264,  5263,  2730, 11983,  9234,  9740 
  4005,   187,  1136,   573,  1520,  3792, 10436,  6420, 11448,  9268,  5284 
  4006,   968,  1661,  1515,  1514,  9895,  5855,  9893, 10524,  5854,  5551 
  4007,  1096,  1294,  1273,  1696,  4501,  4504,  4355,  9855,  9443,  9854 
  4008,  1569,  1230,  1035,  1091, 11276,  4228,  8975, 11275,  4227,  3649 
  4009,  1613,  1270,  1739,  1323, 11361, 12077,  6223,  9447,  4723, 10740 
  4010,   377,   376,   235,  1802,  2529, 10514,  9574, 11959, 10516,  6905 
  4011,  1683,  1388,  1009,  1558,  6172,  9537, 12078,  6122,  5703,  9472 
  4012,  1009,  1388,  1178,  1269,  9537, 11827,  4560,  4600, 11501,  4744 
  4013,   426,  1536,  1053,  1052,  5443, 11366,  9821,  9822, 10344,  3534 
  4014,  1739,  1270,  1214,  1323, 12077,  4748, 12079, 10740,  4723,  4639 
  4015,  1862,  1861,   628,  1821,  7215,  7211,  7213, 11529, 11349, 11078 
  4016,   865,   864,  2100,   787,  3077,  8290,  8289,  8121,  8120, 10701 
  4017,  1877,   643,  1786,  1876,  7258, 12080, 12028,  7260,  7256,  9271 
  4018,   701,   643,  1786,  1877,  6764, 12080,  6856, 10640,  7258, 12028 
  4019,  1178,  1388,  1009,  1683, 11827,  9537,  4560, 10382,  6172, 12078 
  4020,  1558,  1388,  1009,   388,  5703,  9537,  9472,  5394,  4944,  9176 
  4021,   735,   817,  2076,   816,  8142,  8241, 10169,  8100,  3029,  8242 
  4022,  1451,  1113,   124,   919, 10802,  3714, 11554, 10545,  3932,  3187 
  4023,   323,  1076,  1075,   449,  3601,  3603,  3599,  8865, 10649, 10868 
  4024,  1585,  1077,  1423,   450,  8878, 11474,  5633,  5471,  9707,  5024 
  4025,   320,  1073,   447,   321,  3592, 11605, 11856,  2470,  3593, 11754 
  4026,   400,   399,  1013,   256,  2552, 11515, 11793, 11439,  9519,  3415 
  4027,  2076,   816,  1965,   735,  8242, 11543, 10377, 10169,  8100,  7637 
  4028,   994,   361,   362,  1378, 10746,  2514, 10845, 10747,  4917,  4916 
  4029,   400,  1562,  1013,   399,  5407, 11516, 11793,  2552,  5408, 11515 
  4030,  1379,  1616,  1548,  1193,  5702,  5701,  5584, 10544, 10539, 10551 
  4031,    85,  2180,  2111,    82, 11348,  8593, 10658,  3124,  8460,  8312 
  4032,  1902,  2178,  2041,  2112,  9717,  8709,  9716, 11911,  8707,  8461 
  4033,  1353,  1744,  1748,  1337, 10428,  6302, 10100,  4808, 10361,  9557 
  4034,   376,  1802,  1828,   234, 10516,  7107, 12064, 10515,  6906,  7034 
  4035,  2137,  1952,   459,  2066,  8894,  7596, 10835,  8487, 10822,  9965 
  4036,   458,   457,   331,  2136,  2611, 11901, 10479, 10038, 10039,  8367 
  4037,  1588,  1644,  1249,  1278,  6031, 10021, 11958, 11239, 11240,  4384 
  4038,   282,  2041,   408,  2180,  8171,  9722,  8988,  8314,  8315,  9723 
  4039,  1786,   643,   642,  1876, 12080,  2848, 10563,  9271,  7256,  7255 
  4040,   925,   134,  1447,   926,  3198,  9027,  9028,  3726,  3201, 11095 
  4041,  1566,  1217,  1218,  1037,  9753,  4187,  9864,  9928,  4184,  4185 
  4042,   283,  2041,  2112,   409,  8170,  8461,  8317, 12057, 12056, 12000 
  4043,   408,   409,  1035,  1569,  2562,  8976, 12060,  5426,  5425,  8975 
  4044,  1573,  1047,  1046,  1264,  8942,  3517,  8940, 11587,  4482,  4481 
  4045,  1299,  1257,  1654,  1676,  4691, 11577, 10244,  8901,  8830,  6085 
  4046,  2047,   295,   421,  2118,  8182,  9394,  9392,  8468,  8330, 11019 
  4047,   914,  1456,  1691,  1247, 10376,  5949,  9184,  4280, 10482, 11680 
  4048,  1574,  1265,  1335,  1048, 12054,  4696, 10559, 11945,  4484,  4429 
  4049,    12,   494,    41,   913,  6642,  2652,  2800,  3175, 11115,  8751 
  4050,   701,   643,   642,  1786,  6764,  2848,  6765,  6856, 12080, 10563 
  4051,  1462,   500,  1594,   911,  5128,  5509,  5804,  9918, 10279, 10135 
  4052,  1335,  1534,   975,  1542, 10561, 10565,  4697, 11221,  5579, 10566 
  4053,  1057,  1058,  1577,   431,  3549,  9765,  9764,  9564, 11967,  5452 
  4054,  1716,  1301,  1735,  1697, 10289, 11742,  6196,  6274,  9197,  6206 
  4055,  1786,  1828,   701,  1877,  7062,  7061,  6856, 12028, 10518, 10640 
  4056,  1415,  1579,   435,  1061,  5601,  5456,  5007,  9000, 12081, 11698 
  4057,  2074,  2070,  2140,  2040,  8692,  8553,  8693, 11022, 10947, 10118 
  4058,  1710,  1741,  1334,  1184,  6300, 11569, 11567, 12082, 11641,  4759 
  4059,  1867,  1804,  1805,  1781,  9546,  7110, 10721,  9373,  7112,  7089 
  4060,  1739,  1613,  1602,  1270,  6223,  6171,  6220, 12077, 11361, 12046 
  4061,  1499,   545,   945,  1597,  5227, 11201,  9018,  6090,  5537,  9019 
  4062,  1756,  1725,  1350,  1319,  6322, 11871, 10440, 10316, 11818,  4793 
  4063,   814,  2143,  2075,  1963,  8383,  8591,  8240, 10230, 10231, 10133 
  4064,  1133,  1176,  1174,  1740,  4041,  4408,  4026, 10636, 10871, 11658 
  4065,  1739,  1602,  1214,  1270,  6220, 11327, 12079, 12077, 12046,  4748 
  4066,   193,   194,   597,   972,  2336,  6490,  6486,  3296,  3295,  9063 
  4067,   759,  1989,  2087,  1990,  7709, 11857, 11940,  7711,  7713, 11267 
  4068,  1502,  1501,   551,   948,  5237,  5234,  5235, 10154,  8876,  8877 
  4069,  1227,  1493,  1654,  1256,  9575,  5827,  8839,  4416, 10908, 10458 
  4070,  1068,  1283,  1419,  1069,  4570, 10875,  9942,  3582,  4656, 11644 
  4071,  1129,  1501,  1581,   948, 10157,  5833, 10434,  3938,  8876, 11607 
  4072,   161,  1580,   946,  1128, 10622,  9088,  3243,  3763, 10623,  3894 
  4073,   748,  1978,   828,  2082,  7676, 11350,  8088, 10087, 11234,  8254 
  4074,  1266,  1531,  1532,   984,  9869,  5566, 11828,  4326, 10624, 11085 
  4075,  1169,  1289,  1720,  1268,  4549,  9416, 11845,  4397,  4466,  9640 
  4076,   193,   972,   597,   596,  3296,  9063,  6486,  6485, 11257,  2773 
  4077,   360,   359,  1377,   992,  2512,  4915,  4914,  9290,  9288, 10713 
  4078,  1947,  2064,  2134,   454, 11867,  8547, 12083,  7581, 12084, 12062 
  4079,   455,  2064,  1947,   454,  9793, 11867,  7582,  2608, 12084,  7581 
  4080,  1592,  1089,  1090,   465,  9491,  3646,  8813,  5492, 10502,  9805 
  4081,   338,  2139,  2069,   464,  8372,  8552,  8227, 10839, 10889, 10887 
  4082,  1304,  1736,  1712,  1186,  9995,  6200,  9994,  4572, 11588, 10125 
  4083,  1821,   388,  1861,  1778, 11980,  7377, 11349,  7055, 11224, 11223 
  4084,  2076,  2144,  1955,  1965,  8554, 10471, 11847, 10377, 10211,  7968 
  4085,  1608,  1208,  1726,  1725, 11851,  9596,  6149,  6147, 11949,  6151 
  4086,  1592,  1430,  1089,   465,  5614,  9492,  9491,  5492,  5037, 10502 
  4087,   854,  2163,  2006,   775,  8423,  8788, 11932,  8055, 10047,  7759 
  4088,   608,   666,  1768,   607,  6707,  6820, 10064,  2813,  6706, 11986 
  4089,   433,   306,  2053,   432, 11598,  8195,  9565,  2586, 10018,  9567 
  4090,  1313,  1681,  1690,  1181, 10707,  5947, 12075,  4603,  9294, 12023 
  4091,  1841,   608,  1768,   607,  7152, 10064, 11387,  7151,  2813, 11986 
  4092,  1208,  1725,  1319,  1318, 11949, 11818,  4623,  4621, 11872,  4625 
  4093,  1665,  1195,  1746,  1690, 11694, 12002,  6276,  5946, 11981,  6275 
  4094,  1208,  1318,  1726,  1725,  4621,  9595,  9596, 11949, 11872,  6151 
  4095,  1313,  1181,  1690,  1195,  4603, 12023, 12075,  4602,  4475, 11981 
  4096,  1522,  1523,  1660,  1183,  5559,  5853,  5852,  9673, 11995,  9675 
  4097,  1877,   644,  1878,  1787,  7259,  7261,  7263, 11904, 12085,  9840 
  4098,   239,   238,  1783,   381,  2386,  6912,  6911, 11189, 11649, 11342 
  4099,  1623,  1626,  1217,  1732,  5730,  9752,  9754,  6365,  6369,  9668 
  4100,  1230,  1294,  1623,  1217,  4503,  9442,  9757,  4500,  4767,  9754 
  4101,  1903,   410,   411,  2042,  7451,  2564,  7452, 10756, 10350, 10351 
  4102,  1272,  1627,  1339,  1194,  9976,  9911,  4786,  4353,  9978,  4785 
  4103,  2024,   871,   793,   794, 10353,  8065,  7813,  7814,  8064,  3005 
  4104,  1437,    86,   472,  1098,  8963,  6602,  5052, 11304,  3670, 12071 
  4105,  1438,   472,    87,  1098,  5054,  6595, 10665, 12044, 12071,  3669 
  4106,  1355,  1761,  1762,  1733, 11738,  6347, 11241, 10099,  6346,  6345 
  4107,   305,   431,  2123,   432, 11290, 11923,  8341, 10049,  2585, 10048 
  4108,  2152,  1982,   832,   831,  9930,  9931,  8401,  8402, 11947,  3044 
  4109,  2006,  1924,  1925,  2095,  7910,  7517,  7911,  8789,  8980,  8787 
  4110,  1761,  1361,  1354,  1355, 11735,  4856, 11216, 11738,  4855,  4822 
  4111,  1519,   394,   393,   965,  5398,  2546,  5399,  8772, 11444,  8770 
  4112,  1720,  1289,  1730,  1714,  9416, 11846,  6235,  6133,  9417,  6234 
  4113,  1134,   178,   177,  1518,  3784,  2317,  3785, 10390, 11645, 10966 
  4114,  1346,  1743,  1307,  1347, 11870, 11135,  4779,  4782, 10221,  4780 
  4115,  1134,  1683,  1009,  1558, 10389, 12078,  4559,  9029,  6122,  9472 
  4116,   990,   216,    54,    23,  3332,  6443,  9370,  3331,  2363,  2781 
  4117,  1308,  1743,  1742,  1347, 11137,  6253, 11943,  4781, 10221, 10220 
  4118,   675,   676,  1851,  1773,  2883, 10453, 10606,  6831,  6830, 10358 
  4119,   393,  1775,   250,   251, 11117,  6930, 10334, 10511,  6929,  2398 
  4120,  1730,  1289,  1184,  1714, 11846,  4448, 11640,  6234,  9417,  9419 
  4121,  1343,  1219,  1220,  1622,  4752,  4194,  4753,  9454, 11890, 12086 
  4122,  1343,  1220,  1628,  1622,  4753,  9261, 10526,  9454, 12086,  5737 
  4123,  1362,   358,   991,   359,  5353, 10750, 10860,  5361,  2511, 10587 
  4124,   509,  1103,   100,   901,  9946,  3684,  6685,  9944,  3925,  3151 
  4125,  1220,  1219,  1570,  1622,  4194, 10778, 10447, 12086, 11890,  5716 
  4126,  1628,  1220,  1570,  1622,  9261, 10447,  5736,  5737, 12086,  5716 
  4127,  1245,  1670,  1734,  1246, 12068,  6258, 12074,  4389, 11809, 11745 
  4128,   520,  1476,   928,   136,  5167, 11918, 10572,  6502,  8944,  3206 
  4129,  2179,   809,  1959,    84, 10958,  7620,  9428, 11963,  7617,  7618 
  4130,   136,   520,    15,   928,  6502,  6500,  2267,  3206, 10572,  3207 
  4131,  1679,  1297,  1173,  1314, 10767,  4531, 10935, 11589,  4604,  4607 
  4132,  1489,   537,  1133,   172,  5203,  9421, 10408, 10407,  6535,  3777 
  4133,  1711,  1490,  1174,  1740,  6086, 11599, 10302,  6227,  6226, 11658 
  4134,  1712,  1186,  1147,  1183, 10125,  4086, 11499,  9674,  4088,  4065 
  4135,  2145,  1967,  1966,  1954,  9117,  7644, 10090,  9109,  7965,  7966 
  4136,  1245,  1246,  1734,  1292,  4389, 11745, 12074,  4541,  4540,  9313 
  4137,  1969,   739,  1970,   820,  7649,  7651,  7653,  9494,  8035,  9971 
  4138,  1706,   894,  1225,  1444, 12087,  4207, 11973,  6052,  9101, 11974 
  4139,  1685,  1523,  1524,   988,  5930,  5560,  5931,  9339,  9348,  9341 
  4140,    83,     2,    85,   408,  3127,  2208,  3125,  8987,  2561,  7445 
  4141,  1738,  1737,  1327,  1762,  6213, 10317, 11484,  6349,  6348, 11956 
  4142,  1525,   989,  1686,  1524,  9646, 11948,  5933,  5561,  9340,  5932 
  4143,  1493,   950,   540,  1494, 10907, 10961,  5214,  5533, 10909,  5215 
  4144,   697,   640,   639,  1873,  6760,  2845,  6761, 11619,  7247,  7246 
  4145,   195,    27,    58,   974,  2338,  2785,  6489,  3300,  3299, 10975 
  4146,  1166,  1175,  1701,   912,  4375,  9827, 10252,  3994,  4376, 11324 
  4147,  1140,   586,   976,  1535, 10687, 10686,  3907, 10704,  5322, 10697 
  4148,  1044,  1572,   418,  1407, 11614,  5433, 11456, 11692,  5642,  4992 
  4149,   958,  1259,  1651,   957,  4307,  9245,  9244,  3780,  4308,  9923 
  4150,  1543,  1681,   970,  1138,  5922,  9293,  9981, 11337,  9295,  3905 
  4151,  1304,  1736,  1300,  1615,  9995, 12088,  4777,  9848,  6301,  9347 
  4152,  1691,  1646,  1629,  1247,  6062,  6024,  6207, 11680, 10483, 10925 
  4153,  1629,  1691,  1299,  1676,  6207, 10995, 10242,  6225,  6287,  8901 
  4154,  1445,   924,  1167,   923, 10510,  4008,  8735,  8736,  3724,  4009 
  4155,  2124,   434,  1926,  1927,  8983,  7519,  8981, 12026,  7521,  7523 
  4156,  1691,  1709,  1277,  1676,  6070,  8888,  8886,  6287,  6312,  8900 
  4157,  1300,  1736,  1673,  1615, 12088,  6335,  8925,  9347,  6301,  6255 
  4158,  1337,  1744,  1704,  1303, 10361,  6256, 10378,  4715, 10374, 12089 
  4159,  1046,  1045,   419,  1573,  3514, 11281,  9655,  8940, 11434,  5436 
  4160,  1704,  1744,  1669,  1303,  6256,  6261,  6245, 12089, 10374, 10019 
  4161,    18,  1503,   939,   152, 11690, 11505,  3230,  2286, 11507,  3229 
  4162,  1172,  1579,  1415,  1061, 12018,  5601,  8993,  4569, 12081,  9000 
  4163,  1280,  1303,  1704,  1633,  4563, 12089, 11955,  9608, 10020,  6246 
  4164,  2102,  1913,  2047,  2171, 10588, 11021,  8611,  8521, 11265,  8700 
  4165,   432,   431,  1577,  1058,  2585,  5452,  5451, 10017, 11967,  9765 
  4166,    51,  1503,    18,   552,  5238, 11690,  2794,  2720,  5239,  6569 
  4167,  1430,  1088,  1591,  1238, 10942, 10943,  5635, 11308,  4250, 11756 
  4168,  1618,  1313,  1746,  1731, 10708, 12076,  6308,  6174, 10977,  6307 
  4169,   216,  1524,  1525,   577,  9644,  5561,  9645,  6444,  5293,  5294 
  4170,   755,  1985,   835,  1986,  7697, 11235,  8091,  7699,  7701, 10329 
  4171,  1221,  1571,  1042,  1043, 10732, 11435,  4196,  4197, 10734,  3505 
  4172,   628,   629,  1862,  1821,  2834,  7214,  7213, 11078, 11079, 11529 
  4173,  1236,  1237,  1429,  1087,  4249, 11807, 11479,  4245,  4247, 10496 
  4174,  1704,  1303,  1669,  1633, 12089, 10019,  6245,  6246, 10020,  6016 
  4175,  1691,  1646,  1247,  1456,  6062, 10483, 11680,  5949,  5802, 10482 
  4176,  2182,  1458,  1449,    40, 11323,  5508, 11979, 11322,  5118,  5086 
  4177,  1020,  1021,  1203,  1375,  3440,  4143,  4142, 11112, 11635, 11634 
  4178,  1341,  1747,  1308,  1616, 11155, 12090,  4761, 10540,  6278, 11978 
  4179,  1375,  1612,  1374,  1021,  5683,  5682,  4909, 11635, 11636, 11654 
  4180,   708,   709,   650,  1884,  2916,  6777,  6802, 11767, 11769,  7279 
  4181,  1496,  1125,  1579,  1172, 11726,  8972,  5745,  8991,  4021, 12018 
  4182,  1741,  1671,  1171,  1279,  6228,  9505, 10165, 11762, 11822,  4404 
  4183,  1416,   944,  1497,  1498, 10534, 10533,  5943,  6089, 11535,  5226 
  4184,  1518,   563,   960,  1517,  5273, 10371,  9034,  5275,  5272,  9036 
  4185,   191,   970,    25,  1516,  3292,  3291,  2332, 11976,  9982,  9980 
  4186,  1884,   709,   650,   651, 11769,  6777,  7279,  7280,  6776,  2856 
  4187,   191,    53,   562,  1516,  6412,  2733,  6410, 11976,  5270,  5269 
  4188,  1885,   369,  1790,  1832,  7343, 11309, 12091, 10570, 11892,  7029 
  4189,   671,  1846,  1771,  1847,  8869,  8868,  6827, 11789,  7170, 11791 
  4190,  1308,  1747,  1742,  1616, 12090,  6298, 11943, 11978,  6278,  6236 
  4191,   710,  1832,  1885,   709,  7005, 10570, 10569,  2917,  7006, 11681 
  4192,   359,   218,   360,  1798,  9289,  9291,  2512, 11926,  6883,  8891 
  4193,   584,    27,   975,    58,  6459,  3302,  9738,  2759,  2785, 10564 
  4194,  1137,  1195,  1544,  1138,  4118, 11693, 10473,  3953,  4119, 11331 
  4195,  1341,  1340,  1308,  1747,  4775,  4804,  4761, 11155, 10268, 12090 
  4196,  2171,  2022,  1913,  2023, 11209,  7984, 11265, 11210,  7812,  7880 
  4197,   720,  1798,  1896,  1895,  7017, 12092,  9487, 11896,  8889,  7317 
  4198,   359,  1798,  1895,  1898, 11926,  8889,  7324,  7322, 11928,  7437 
  4199,   376,   234,  1828,   375, 10515,  7034, 12064,  2528, 10555, 10293 
  4200,  1308,  1340,  1742,  1747,  4804, 12093, 11943, 12090, 10268,  6298 
  4201,   613,  1847,   672,   614,  7168, 11790,  6719,  2819,  7169,  6718 
  4202,   404,  1843,  1811,  1842,  7407, 10574, 11272,  7408,  7158, 10576 
  4203,  1834,   714,  1889,  1793,  7009,  9568, 11016,  7008,  6871, 10225 
  4204,   450,  2132,   323,   324, 10998,  8359,  9713,  9708,  8358,  2473 
  4205,    34,   358,   217,   281,  2510, 11093, 10735,  4851, 10751,  3333 
  4206,   615,  1849,  1772,   674,  7174,  9516, 11876,  6805,  9518,  6828 
  4207,   615,   674,  1772,   673,  6805,  6828, 11876,  6720,  2881,  6829 
  4208,  1605,  1723,  1210,  1606,  6140, 11601, 11312,  5666,  6141,  9502 
  4209,   360,  1798,   219,  1795,  8891,  6882, 10748,  8892,  7022,  6885 
  4210,  1148,   997,   224,   365,  3962,  3352,  3831, 10828, 11638, 10258 
  4211,  1728,  1315,  1316,  1205,  9438,  4616,  8854, 11633,  4613,  4614 
  4212,   615,   673,  1772,  1814,  6720,  6829, 11876, 10454,  6960,  7047 
  4213,  1757,  1360,  1349,  1758, 10450,  4848, 10452,  6332, 10661, 11249 
  4214,  1651,  1282,  1675,  1553,  9246, 11850,  6110,  6168, 11486,  6340 
  4215,  1004,  1003,   377,  1553,  3374, 11960,  9355,  8795, 11487,  5378 
  4216,  1704,  1303,  1280,  1296, 12089,  4563, 11955, 10203,  4566,  4517 
  4217,    85,  2180,  1959,  2111, 11348, 11259,  7619, 10658,  8593, 11269 
  4218,  1360,  1758,  1757,  1766, 10661,  6332, 10450, 10451,  6401,  6399 
  4219,  1004,  1553,  1260,  1282,  8795,  8796,  4474,  4505, 11486,  4407 
  4220,  1878,  1828,   375,  1877, 10599, 10293,  7353,  7263, 10518,  7427 
  4221,  1477,   522,   138,   137,  5171,  6510, 10392, 10396,  6507,  2269 
  4222,   664,  1839,   722,   725,  7410, 10269,  6705,  7143,  7144, 11156 
  4223,  1742,  1340,  1752,  1747, 12093, 10266,  6394,  6298, 10268,  6378 
  4224,  1704,  1707,  1280,  1633,  6309, 11192, 11955,  6246,  6056,  9608 
  4225,  1708,  1340,  1163,  1747, 10267,  4776, 11676,  6374, 10268, 11178 
  4226,  1481,   933,   145,    16, 11341,  3218, 11764, 11514,  3217,  2277 
  4227,  1008,   387,  1686,  1557, 11881,  5581,  9365,  9360,  5390,  6167 
  4228,   689,  1864,  1822,  1780, 11065,  8768,  6980,  7058, 10443,  7069 
  4229,  1865,  1864,   689,  1780,  7224, 11065,  8758,  8759, 10443,  7058 
  4230,  1863,  1822,  1779,   630,  8767,  7056,  9376,  7217, 11525,  9316 
  4231,  1785,   698,  1873,  1874,  6855, 11620, 11884,  9240, 10352,  7251 
  4232,   528,  1480,   144,   145,  5179, 11627,  6505,  6504, 11335,  2276 
  4233,  1827,  1785,   235,   377,  7060,  6908,  7108, 11237,  9410,  9574 
  4234,  1290,  1380,  1636,  1193, 10313,  6083, 11002,  4579, 12035, 10537 
  4235,  1186,  1736,  1173,  1314, 11588,  9528,  4660,  4693, 11964,  4607 
  4236,  1785,  1874,  1873,   378,  9240,  7251, 11884,  9409,  7358,  7359 
  4237,  1856,   392,   393,  1807,  7385,  2545,  7386,  8938,  8937, 11346 
  4238,  1552,  1326,  1244,  1648, 10470,  4662, 10469,  6126, 11907, 11072 
  4239,  1122,   556,   149,   148,  9023,  6580,  3745,  3746,  6577,  2282 
  4240,  1727,  1348,  1728,  1758,  9112, 10234,  6157,  6330, 10662,  6331 
  4241,   516,   515,   107,   904,  2677,  6682,  6676, 12039, 10788,  3156 
  4242,  1232,  1249,  1588,  1633,  4498, 11958, 11706,  9609,  9610,  5769 
  4243,  1800,  1831,   370,   229,  7030, 11481,  9788,  6899,  7031,  9599 
  4244,   628,  1821,   686,   687, 11078,  6979,  6742,  6745,  6978,  2894 
  4245,  1673,  1736,  1300,  1314,  6335, 12088,  8925, 12094, 11964,  4606 
  4246,   652,   710,  1885,   651,  6778, 10569,  7283,  2857,  6779,  7282 
  4247,  1152,   252,  1324,   395,  3845,  4084,  4085, 10235, 10817,  9331 
  4248,  1815,   398,  1772,   255,  9314, 11389,  7051,  7127,  9223,  6937 
  4249,   147,   519,   518,   935,  6498,  2681,  6499,  3221, 11496,  8756 
  4250,  1300,  1252,  1673,  1314,  4547, 10629,  8925,  4606,  4605, 12094 
  4251,  1673,  1314,  1679,  1736, 12094, 11589,  5918,  6335, 11964,  6201 
  4252,    26,   192,  1137,   600,  2334,  3801,  3798,  6494,  6492,  9523 
  4253,  1816,   618,   677,   676, 10541,  6727,  6964,  6965,  6724,  2884 
  4254,  1365,  1602,  1364,  1032,  5654,  5653,  4879, 11009, 11010,  9967 
  4255,  1679,  1314,  1673,  1252, 11589, 12094,  5918, 11590,  4605, 10629 
  4256,   987,  1529,  1713,  1712, 10462,  6100, 10122, 10123,  6094,  6132 
  4257,  1178,  1009,  1134,  1683,  4560,  4559,  4046, 10382, 12078, 10389 
  4258,  1183,  1523,  1660,   988, 11995,  5853,  9675,  4064,  9348, 11377 
  4259,  1185,   981,  1144,  1699,  4083,  4058,  4361,  8912, 11924,  8910 
  4260,   539,    49,   166,   949,  2705,  6541,  6540, 12095, 12073,  3249 
  4261,  1443,   894,  2181,  1444, 10115, 10716, 10612,  5075,  9101, 10613 
  4262,   949,    49,   166,    20, 12073,  6541,  3249,  3250,  2792,  2302 
  4263,  1827,   699,  1785,  1875,  6995,  6854,  7060, 10466,  9243,  9241 
  4264,  1167,  1117,  1587,  1454,  4356, 11502,  8740,  8737,  9181,  5762 
  4265,  1803,  1872,   380,   379, 10307,  7362, 12052, 11332,  7361,  2532 
  4266,  1385,   138,  1118,   929, 10394,  3727, 11031, 10395,  3208,  3728 
  4267,  1819,   391,   248,  1777, 12048,  9561,  6975,  6972, 11833,  6925 
  4268,   165,    49,  1502,    20,  6555,  5236, 10153,  2301,  2792, 10972 
  4269,  1341,  1616,  1308,  1193, 10540, 11978,  4761,  4737, 10539,  4584 
  4270,  1738,  1327,  1159,  1325, 11484,  4663, 11476, 11732,  4665,  4648 
  4271,  1860,   626,   627,   685,  7207,  2832,  7208, 11591,  6812,  6799 
  4272,  1147,  1523,  1183,   988,  9411, 11995,  4065,  3959,  9348,  4064 
  4273,  1738,  1325,  1641,  1751, 11732, 12096,  6212,  6216, 11733,  6214 
  4274,  1641,  1325,  1242,  1751, 12096,  4647, 10189,  6214, 11733, 10190 
  4275,  1745,  1756,  1346,  1351,  6385, 11052, 11624, 11625,  9230,  4854 
  4276,  1352,  1755,  1745,  1351, 10200,  6395, 10391,  4803,  9231, 11625 
  4277,  1242,  1641,  1159,  1325, 10189, 11477,  4362,  4647, 12096,  4648 
  4278,  1272,  1627,  1405,  1624,  9976,  5732,  9975, 10763,  5734,  5721 
  4279,  1042,   289,   415,  1041,  3500, 11977, 11381,  3502,  3499, 11382 
  4280,  1729,  1204,  1315,  1611, 11417,  4612,  9440,  6158, 11630, 11985 
  4281,  1883,  1831,  1789,   707, 11219,  7098, 10812, 10785,  7003,  6862 
  4282,   418,  2046,  1910,  2116,  9330,  9480,  7472,  9328,  8324, 10007 
  4283,   425,  2049,   298,   299, 11161,  8187, 11160, 11987,  8186,  2448 
  4284,  1790,   369,  1884,  1883, 11309,  7426, 11768, 11531,  7344,  7281 
  4285,  1027,  1369,  1368,  1606, 10773,  4891,  9161,  9503,  5665,  5664 
  4286,  1827,  1875,   700,   699, 10466, 11971,  6994,  6995,  9243,  2907 
  4287,  1831,   370,   369,  1883, 11481,  2522, 11530, 11219,  7345,  7344 
  4288,   700,  1875,   641,   699, 11971,  7252,  6814,  2907,  9243,  6808 
  4289,   700,  1875,   642,   641, 11971,  7253,  6801,  6814,  7252,  2847 
  4290,   607,   665,   606,    60,  6702,  6819, 10182,  2812,  6703,  6698 
  4291,  2141,   728,   729,    64, 11490,  7444, 11580, 11579,  2939,  2940 
  4292,  2141,    64,   810,    65, 11579,  8010,  8380,  8378,  3100,  3022 
  4293,  1370,   350,  1026,  1369,  4892, 11038, 11877,  4894,  4890, 11653 
  4294,   820,   819,  1969,   739,  3032,  8922,  9494,  8035,  8082,  7649 
  4295,  1999,   768,   848,  2160,  7738,  8111, 11130,  9576, 10110,  8417 
  4296,  1159,  1641,  1738,  1325, 11477,  6212, 11476,  4648, 12096, 11732 
  4297,   612,  1813,  1845,   670, 11388, 11186,  7163,  6714,  6959, 11452 
  4298,  1639,  1638,  1202,  1336,  5783,  9276,  9275, 10035, 11860,  4699 
  4299,  1878,   644,   703,  1787,  7261,  6769,  9839,  9840, 12085,  6858 
  4300,  1274,  1449,  1450,   917, 10426,  5090, 11865,  4359, 11465, 11466 
  4301,  2083,  1980,  1981,   750,  9226,  7686,  9225, 11055,  7682,  7684 
  4302,   666,   665,  1768,   607,  2873,  6821,  6820,  6706,  6702, 11986 
  4303,  1421,  1457,  1458,  1248,  5860,  5507,  5753,  9301, 10477,  9299 
  4304,   513,  1105,   903,  1550, 11843,  3923, 11889,  5150, 11163, 11162 
  4305,   644,   702,   703,  1787,  6766,  2910,  6769, 12085,  6859,  6858 
  4306,  2147,   822,   741,  1972,  8391,  8037, 10520, 10521, 11045,  7657 
  4307,   751,   831,  1981,   750,  8147, 11054,  7685,  2962,  8146,  7684 
  4308,  2083,  2151,  1980,   830,  8561, 11056,  9226,  8256,  8399, 11593 
  4309,  1400,    79,    72,    71, 11730,  3118,  4975,  4976,  3117,  2189 
  4310,  2057,  2128,  1934,  2158,  8478, 10759,  9625,  8645,  8644,  9627 
  4311,   831,   830,  2083,   750,  3043,  8256,  8255,  8146,  8138, 11055 
  4312,   165,    49,   551,  1502,  6555,  2719,  6556, 10153,  5236,  5235 
  4313,  1257,  1256,  1654,  1494,  4487, 10458, 11577,  9217, 10910,  5828 
  4314,  1333,  1729,  1749,  1703, 11213,  6284, 10077, 10078,  6233,  6282 
  4315,  1430,  1238,  1591,  1634, 11308, 11756,  5635,  5770, 10131,  5771 
  4316,  1547,  1190,  1613,  1378, 12033,  9445,  5687,  5362, 10206,  5872 
  4317,  1591,   464,   463,  1088,  5489,  2617,  5490, 10943, 10944, 11478 
  4318,  1789,   706,   649,   707,  6863,  6816,  9683,  6862,  2914,  6775 
  4319,  1327,  1325,  1763,  1347,  4665,  9771, 12070,  4842,  4841,  9770 
  4320,  1062,  1579,  1125,  1172,  8973,  8972,  4030,  4553, 12018,  4021 
  4321,  1980,   750,  2083,   830,  7682, 11055,  9226, 11593,  8138,  8256 
  4322,  1492,    49,   539,   949,  5211,  2705,  5212,  9736, 12073, 12095 
  4323,  2065,  1949,  2080,  2148, 10058, 10012,  8675,  8728,  9579,  8558 
  4324,  2003,   772,   851,  2002,  7750,  8113,  9873,  7752,  7748,  9874 
  4325,  1588,  1633,  1427,  1232,  5769,  5768,  5650, 11706,  9609,  9043 
  4326,  1761,  1765,  1357,  1359,  6405, 10338, 10336,  8845,  8843,  4846 
  4327,  1097,  1568,    78,    71,  9118,  9119,  3664, 11838,  5421,  3116 
  4328,    78,  1568,    70,    71,  9119,  5422,  3115,  3116,  5421,  2188 
  4329,     6,     5,    81,   886,  2205,  2201,  3121,  8031,  3099,  8311 
  4330,  1427,  1633,  1669,  1232,  5768,  6016,  5891,  9043,  9609,  9045 
  4331,  1359,  1347,  1327,  1762,  4843,  4842,  4844,  8844, 11972, 11956 
  4332,  2131,  2061,   448,  1940,  8544, 10320, 11806, 11250,  8743,  7561 
  4333,  1327,  1347,  1763,  1762,  4842,  9770, 12070, 11956, 11972,  6352 
  4334,  1750,  1766,  1760,  1358,  6371,  6370,  6342, 10177, 10657, 11800 
  4335,  1878,  1829,   703,   645,  9841,  6998,  9839,  7262, 10863,  6768 
  4336,  2116,  1909,  2045,  2173, 10009, 10616,  8466,  8607,  8852,  8606 
