*HEADING


*NODE, NSET=NSET1
1,-3.908500195,-89.25000000,1.936725497
2,-3.908500195,-89.50000000,1.936725497
3,-3.908500195,-89.50000000,2.227720737
4,-3.908500195,-89.50000000,2.518716097
5,-3.908500195,-89.50000000,2.809711456
6,-3.908500195,-89.50000000,3.100706577
7,-3.908500195,-89.50000000,3.391701937
8,-3.908500195,-89.50000000,3.682697296
9,-3.908500195,-89.50000000,3.973692417
10,-3.908500195,-89.50000000,4.264687538
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*ELEMENT,TYPE=C3D10,ELSET=PART1_EG1
1,10096,10097,4932,4011,15664,38334,38335,45022,45021,45024
2,10096,4684,10098,10097,40062,40060,15663,15664,40061,15661
3,10096,4933,10099,4012,38330,38329,15662,45015,45017,45014
4,10096,4684,10097,4011,40062,40061,15664,45022,45025,45021
5,10096,10099,4679,4012,15662,40097,40099,45015,45014,45018
6,10100,10101,3991,4784,15653,45161,45162,39322,39321,45165
7,10100,10101,7390,4912,15653,23891,23892,38435,38434,38437
8,10100,10102,4779,3992,15652,39358,39359,45155,45154,45158
9,10100,10101,4912,3991,15653,38434,38435,45162,45161,45164
10,10100,4913,10102,3992,38430,38429,15652,45155,45157,45154
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
*SOLID SECTION,ELSET=PART1_EG1,MATERIAL=MAT1, ORIENT=RECT1

*NSET,NSET=BC_NSET1,
1,2,317,318,319,320,321,322,1493,1494,1495,1496,1497,1498,1499,1500,
1501,1502,1503,1504,1505,1506,1507,1508,1509,1510,1511,1512,1513,1514,1515,1516,
1517,1518,1519,1520,1521,1522,1523,1524,1525,1526,1527,3964,3965,3966,3967,3968,
3969,4889,4890,5316,5317,5318,5319,5320,5321,5322,6394,6395,6396,6397,6398,6399,
6400,6401,6402,6403,6404,6405,6406,6407,6408,6409,6410,6411,6412,6413,6414,6415,
6416,6417,6418,6419,6420,6421,6422,6423,6424,6425,6426,6427,6428,6429,6430,6431,
6432,6433,6434,6435,6436,30154,30159,30164,30169,30173,30176,30181,30182,30185,30188,30191,
30194,30197,30200,30203,30206,30209,30212,30215,30218,30221,30224,30227,30230,30233,30236,30239,
30241,30245,30248,30251,30254,30257,30260,30263,30266,30269,30272,30275,30278,30281,30284,30286,
36878,36883,36888,36893,36897,36898,36900,38541,38545,38547,45315,45318,45319,45320,45324,45328,
45329,45332,45335,45336,45339,45342,45343,45346,45349,45350,45352,62765,62766,62767,62768,62770,
62771,62774,62775,62776,62779,62780,62781,62784,62785,62786,62789,62790,62791,62794,62795,62796,
62799,62800,62801,62804,62805,62806,62809,62810,62811,62814,62815,62816,62819,62820,62821,62824,
62826,62827,62830,62832,62833,62836,62839,62840,62843,62846,62847,62850,62853,62854,62857,62860,
62861,62864,62867,62868,62871,62874,62875,62878,62881,62882,62885,62886,62887,62890,62891,62892,
62895,62896,62897,62900,62901,62902,62905,62906,62907,62910,62911,62912,62915,62916,62917,62920,
62921,62922,62925,62926,62927,62930,62931,62932,62935,62936,62937,62940,62941,62942,62945,62946,
62947,62950,62951,62952,62954,72252,72255,72256,72258,72263,72264,72267,72270,72271,72274,72277,
72278,72281,72284,72285,72288,72291,72292,72294,74185,74187,74192,74194,
*NSET,NSET=CL_NSET1,
156
*NSET,NSET=CL_NSET2,
157
*NSET,NSET=CL_NSET3,
311
*NSET,NSET=CL_NSET4,
312
*NSET,NSET=CL_NSET5,
313
*NSET,NSET=CL_NSET6,
314
*NSET,NSET=CL_NSET7,
315
*NSET,NSET=CL_NSET8,
316
*NSET,NSET=CL_NSET9,
1479
*NSET,NSET=CL_NSET10,
1480
*NSET,NSET=CL_NSET11,
1481
*NSET,NSET=CL_NSET12,
1482
*NSET,NSET=CL_NSET13,
1483
*NSET,NSET=CL_NSET14,
1484
*NSET,NSET=CL_NSET15,
1485
*NSET,NSET=CL_NSET16,
1486
*NSET,NSET=CL_NSET17,
1487
*NSET,NSET=CL_NSET18,
1488
*NSET,NSET=CL_NSET19,
1489
*NSET,NSET=CL_NSET20,
1490
*NSET,NSET=CL_NSET21,
1491
*NSET,NSET=CL_NSET22,
1492
*NSET,NSET=CL_NSET23,
5294
*NSET,NSET=CL_NSET24,
5295
*NSET,NSET=CL_NSET25,
5296
*NSET,NSET=CL_NSET26,
5297
*NSET,NSET=CL_NSET27,
5298
*NSET,NSET=CL_NSET28,
5299
*NSET,NSET=CL_NSET29,
5300
*NSET,NSET=CL_NSET30,
5301
*NSET,NSET=CL_NSET31,
5302
*NSET,NSET=CL_NSET32,
5303
*NSET,NSET=CL_NSET33,
5304
*NSET,NSET=CL_NSET34,
5305
*NSET,NSET=CL_NSET35,
5306
*NSET,NSET=CL_NSET36,
5307
*NSET,NSET=CL_NSET37,
5308
*NSET,NSET=CL_NSET38,
5309
*NSET,NSET=CL_NSET39,
5310
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*END ASSEMBLY
*MATERIAL,NAME=MAT1
*ELASTIC
0.290075E+08,0.290000E+00,


*DENSITY
0.736416E-03,
*STEP
*STATIC
*BOUNDARY
BC_NSET1,1,1
BC_NSET1,2,2
BC_NSET1,3,3
*CLOAD,
CL_NSET1,2,-0.623088E-05
*CLOAD,
CL_NSET2,2,0.149494E-06
*CLOAD,
CL_NSET3,2,-0.239387E-03
*CLOAD,
CL_NSET4,2,-0.239415E-05
*CLOAD,
CL_NSET5,2,0.454071E-06
*CLOAD,
CL_NSET6,2,0.129029E-05
*CLOAD,
CL_NSET7,2,0.129029E-05
*CLOAD,
CL_NSET8,2,0.456747E-05
*CLOAD,
CL_NSET9,2,-0.239688E-03
*CLOAD,
CL_NSET10,2,0.751229E-04
*CLOAD,
CL_NSET11,2,-0.240107E-03
*CLOAD,
CL_NSET12,2,-0.347124E-05
*CLOAD,
CL_NSET13,2,0.388694E-03
*CLOAD,
CL_NSET14,2,-0.430416E-05
*CLOAD,
CL_NSET15,2,-0.240107E-03
*CLOAD,
CL_NSET16,2,0.152065E-03
*CLOAD,
CL_NSET17,2,-0.240107E-03
*CLOAD,
CL_NSET18,2,-0.513717E-05
*CLOAD,
CL_NSET19,2,0.388701E-03
*CLOAD,
CL_NSET20,2,-0.430416E-05
*CLOAD,
CL_NSET21,2,-0.240114E-03
*CLOAD,
CL_NSET22,2,0.751229E-04
*CLOAD,
CL_NSET23,2,-0.762325E-04
*CLOAD,
CL_NSET24,2,0.163245E-03
*CLOAD,
CL_NSET25,2,0.163245E-03
*CLOAD,
CL_NSET26,2,0.769548E-05
*CLOAD,
CL_NSET27,2,-0.151158E-03
*CLOAD,
CL_NSET28,2,-0.151158E-03
*CLOAD,
CL_NSET29,2,0.769547E-05
*CLOAD,
CL_NSET30,2,0.242679E-03
*CLOAD,
CL_NSET31,2,0.243498E-03
*CLOAD,
CL_NSET32,2,0.687638E-05
*CLOAD,
CL_NSET33,2,-0.149506E-03
*CLOAD,
CL_NSET34,2,-0.150332E-03
*CLOAD,
CL_NSET35,2,0.687638E-05
*CLOAD,
CL_NSET36,2,0.164078E-03
*CLOAD,
CL_NSET37,2,0.164071E-03
*CLOAD,
CL_NSET38,2,-0.744527E-04
*CLOAD,
CL_NSET39,2,0.372845E-05
*CLOAD,
CL_NSET40,2,0.880231E-06
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  *NODE FILE
U,
  *EL FILE
S,


*END STEP
